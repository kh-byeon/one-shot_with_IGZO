*editor khb
mnway0_cell0 ML0 gate_way0_cell0 GND GND n1 W=1e-6 L=1e-6
mpway0_cell0 ML0 gate_way0_cell0 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell1 ML0 gate_way0_cell1 GND GND n1 W=1e-6 L=1e-6
mpway0_cell1 ML0 gate_way0_cell1 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell2 ML0 gate_way0_cell2 GND GND n1 W=1e-6 L=1e-6
mpway0_cell2 ML0 gate_way0_cell2 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell3 ML0 gate_way0_cell3 GND GND n1 W=1e-6 L=1e-6
mpway0_cell3 ML0 gate_way0_cell3 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell4 ML0 gate_way0_cell4 GND GND n1 W=1e-6 L=1e-6
mpway0_cell4 ML0 gate_way0_cell4 GND ML0 p1 W=2.4e-6 L=1e-6
mnway1_cell0 ML1 gate_way1_cell0 GND GND n1 W=1e-6 L=1e-6
mpway1_cell0 ML1 gate_way1_cell0 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell1 ML1 gate_way1_cell1 GND GND n1 W=1e-6 L=1e-6
mpway1_cell1 ML1 gate_way1_cell1 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell2 ML1 gate_way1_cell2 GND GND n1 W=1e-6 L=1e-6
mpway1_cell2 ML1 gate_way1_cell2 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell3 ML1 gate_way1_cell3 GND GND n1 W=1e-6 L=1e-6
mpway1_cell3 ML1 gate_way1_cell3 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell4 ML1 gate_way1_cell4 GND GND n1 W=1e-6 L=1e-6
mpway1_cell4 ML1 gate_way1_cell4 GND ML1 p1 W=2.4e-6 L=1e-6
mnway2_cell0 ML2 gate_way2_cell0 GND GND n1 W=1e-6 L=1e-6
mpway2_cell0 ML2 gate_way2_cell0 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell1 ML2 gate_way2_cell1 GND GND n1 W=1e-6 L=1e-6
mpway2_cell1 ML2 gate_way2_cell1 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell2 ML2 gate_way2_cell2 GND GND n1 W=1e-6 L=1e-6
mpway2_cell2 ML2 gate_way2_cell2 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell3 ML2 gate_way2_cell3 GND GND n1 W=1e-6 L=1e-6
mpway2_cell3 ML2 gate_way2_cell3 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell4 ML2 gate_way2_cell4 GND GND n1 W=1e-6 L=1e-6
mpway2_cell4 ML2 gate_way2_cell4 GND ML2 p1 W=2.4e-6 L=1e-6
mnway3_cell0 ML3 gate_way3_cell0 GND GND n1 W=1e-6 L=1e-6
mpway3_cell0 ML3 gate_way3_cell0 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell1 ML3 gate_way3_cell1 GND GND n1 W=1e-6 L=1e-6
mpway3_cell1 ML3 gate_way3_cell1 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell2 ML3 gate_way3_cell2 GND GND n1 W=1e-6 L=1e-6
mpway3_cell2 ML3 gate_way3_cell2 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell3 ML3 gate_way3_cell3 GND GND n1 W=1e-6 L=1e-6
mpway3_cell3 ML3 gate_way3_cell3 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell4 ML3 gate_way3_cell4 GND GND n1 W=1e-6 L=1e-6
mpway3_cell4 ML3 gate_way3_cell4 GND ML3 p1 W=2.4e-6 L=1e-6
mnway4_cell0 ML4 gate_way4_cell0 GND GND n1 W=1e-6 L=1e-6
mpway4_cell0 ML4 gate_way4_cell0 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell1 ML4 gate_way4_cell1 GND GND n1 W=1e-6 L=1e-6
mpway4_cell1 ML4 gate_way4_cell1 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell2 ML4 gate_way4_cell2 GND GND n1 W=1e-6 L=1e-6
mpway4_cell2 ML4 gate_way4_cell2 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell3 ML4 gate_way4_cell3 GND GND n1 W=1e-6 L=1e-6
mpway4_cell3 ML4 gate_way4_cell3 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell4 ML4 gate_way4_cell4 GND GND n1 W=1e-6 L=1e-6
mpway4_cell4 ML4 gate_way4_cell4 GND ML4 p1 W=2.4e-6 L=1e-6
mnway5_cell0 ML5 gate_way5_cell0 GND GND n1 W=1e-6 L=1e-6
mpway5_cell0 ML5 gate_way5_cell0 GND ML5 p1 W=2.4e-6 L=1e-6
mnway5_cell1 ML5 gate_way5_cell1 GND GND n1 W=1e-6 L=1e-6
mpway5_cell1 ML5 gate_way5_cell1 GND ML5 p1 W=2.4e-6 L=1e-6
mnway5_cell2 ML5 gate_way5_cell2 GND GND n1 W=1e-6 L=1e-6
mpway5_cell2 ML5 gate_way5_cell2 GND ML5 p1 W=2.4e-6 L=1e-6
mnway5_cell3 ML5 gate_way5_cell3 GND GND n1 W=1e-6 L=1e-6
mpway5_cell3 ML5 gate_way5_cell3 GND ML5 p1 W=2.4e-6 L=1e-6
mnway5_cell4 ML5 gate_way5_cell4 GND GND n1 W=1e-6 L=1e-6
mpway5_cell4 ML5 gate_way5_cell4 GND ML5 p1 W=2.4e-6 L=1e-6
mnway6_cell0 ML6 gate_way6_cell0 GND GND n1 W=1e-6 L=1e-6
mpway6_cell0 ML6 gate_way6_cell0 GND ML6 p1 W=2.4e-6 L=1e-6
mnway6_cell1 ML6 gate_way6_cell1 GND GND n1 W=1e-6 L=1e-6
mpway6_cell1 ML6 gate_way6_cell1 GND ML6 p1 W=2.4e-6 L=1e-6
mnway6_cell2 ML6 gate_way6_cell2 GND GND n1 W=1e-6 L=1e-6
mpway6_cell2 ML6 gate_way6_cell2 GND ML6 p1 W=2.4e-6 L=1e-6
mnway6_cell3 ML6 gate_way6_cell3 GND GND n1 W=1e-6 L=1e-6
mpway6_cell3 ML6 gate_way6_cell3 GND ML6 p1 W=2.4e-6 L=1e-6
mnway6_cell4 ML6 gate_way6_cell4 GND GND n1 W=1e-6 L=1e-6
mpway6_cell4 ML6 gate_way6_cell4 GND ML6 p1 W=2.4e-6 L=1e-6
mnway7_cell0 ML7 gate_way7_cell0 GND GND n1 W=1e-6 L=1e-6
mpway7_cell0 ML7 gate_way7_cell0 GND ML7 p1 W=2.4e-6 L=1e-6
mnway7_cell1 ML7 gate_way7_cell1 GND GND n1 W=1e-6 L=1e-6
mpway7_cell1 ML7 gate_way7_cell1 GND ML7 p1 W=2.4e-6 L=1e-6
mnway7_cell2 ML7 gate_way7_cell2 GND GND n1 W=1e-6 L=1e-6
mpway7_cell2 ML7 gate_way7_cell2 GND ML7 p1 W=2.4e-6 L=1e-6
mnway7_cell3 ML7 gate_way7_cell3 GND GND n1 W=1e-6 L=1e-6
mpway7_cell3 ML7 gate_way7_cell3 GND ML7 p1 W=2.4e-6 L=1e-6
mnway7_cell4 ML7 gate_way7_cell4 GND GND n1 W=1e-6 L=1e-6
mpway7_cell4 ML7 gate_way7_cell4 GND ML7 p1 W=2.4e-6 L=1e-6
