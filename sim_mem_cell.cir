*editor khb
mnway0_cell0 ml_0 gate_way0_cell0 GND GND n1 W=1e-6 L=1e-6
mpway0_cell0 ml_0 gate_way0_cell0 GND ml_0 p1 W=2.4e-6 L=1e-6
mnway0_cell1 ml_0 gate_way0_cell1 GND GND n1 W=1e-6 L=1e-6
mpway0_cell1 ml_0 gate_way0_cell1 GND ml_0 p1 W=2.4e-6 L=1e-6
mnway0_cell2 ml_0 gate_way0_cell2 GND GND n1 W=1e-6 L=1e-6
mpway0_cell2 ml_0 gate_way0_cell2 GND ml_0 p1 W=2.4e-6 L=1e-6
mnway0_cell3 ml_0 gate_way0_cell3 GND GND n1 W=1e-6 L=1e-6
mpway0_cell3 ml_0 gate_way0_cell3 GND ml_0 p1 W=2.4e-6 L=1e-6
mnway0_cell4 ml_0 gate_way0_cell4 GND GND n1 W=1e-6 L=1e-6
mpway0_cell4 ml_0 gate_way0_cell4 GND ml_0 p1 W=2.4e-6 L=1e-6
mnway0_cell5 ml_0 gate_way0_cell5 GND GND n1 W=1e-6 L=1e-6
mpway0_cell5 ml_0 gate_way0_cell5 GND ml_0 p1 W=2.4e-6 L=1e-6
mnway0_cell6 ml_0 gate_way0_cell6 GND GND n1 W=1e-6 L=1e-6
mpway0_cell6 ml_0 gate_way0_cell6 GND ml_0 p1 W=2.4e-6 L=1e-6
mnway0_cell7 ml_0 gate_way0_cell7 GND GND n1 W=1e-6 L=1e-6
mpway0_cell7 ml_0 gate_way0_cell7 GND ml_0 p1 W=2.4e-6 L=1e-6
mnway0_cell8 ml_0 gate_way0_cell8 GND GND n1 W=1e-6 L=1e-6
mpway0_cell8 ml_0 gate_way0_cell8 GND ml_0 p1 W=2.4e-6 L=1e-6
mnway0_cell9 ml_0 gate_way0_cell9 GND GND n1 W=1e-6 L=1e-6
mpway0_cell9 ml_0 gate_way0_cell9 GND ml_0 p1 W=2.4e-6 L=1e-6
mnway0_cell10 ml_0 gate_way0_cell10 GND GND n1 W=1e-6 L=1e-6
mpway0_cell10 ml_0 gate_way0_cell10 GND ml_0 p1 W=2.4e-6 L=1e-6
mnway0_cell11 ml_0 gate_way0_cell11 GND GND n1 W=1e-6 L=1e-6
mpway0_cell11 ml_0 gate_way0_cell11 GND ml_0 p1 W=2.4e-6 L=1e-6
mnway0_cell12 ml_0 gate_way0_cell12 GND GND n1 W=1e-6 L=1e-6
mpway0_cell12 ml_0 gate_way0_cell12 GND ml_0 p1 W=2.4e-6 L=1e-6
mnway0_cell13 ml_0 gate_way0_cell13 GND GND n1 W=1e-6 L=1e-6
mpway0_cell13 ml_0 gate_way0_cell13 GND ml_0 p1 W=2.4e-6 L=1e-6
mnway0_cell14 ml_0 gate_way0_cell14 GND GND n1 W=1e-6 L=1e-6
mpway0_cell14 ml_0 gate_way0_cell14 GND ml_0 p1 W=2.4e-6 L=1e-6
mnway0_cell15 ml_0 gate_way0_cell15 GND GND n1 W=1e-6 L=1e-6
mpway0_cell15 ml_0 gate_way0_cell15 GND ml_0 p1 W=2.4e-6 L=1e-6
mnway0_cell16 ml_0 gate_way0_cell16 GND GND n1 W=1e-6 L=1e-6
mpway0_cell16 ml_0 gate_way0_cell16 GND ml_0 p1 W=2.4e-6 L=1e-6
mnway0_cell17 ml_0 gate_way0_cell17 GND GND n1 W=1e-6 L=1e-6
mpway0_cell17 ml_0 gate_way0_cell17 GND ml_0 p1 W=2.4e-6 L=1e-6
mnway0_cell18 ml_0 gate_way0_cell18 GND GND n1 W=1e-6 L=1e-6
mpway0_cell18 ml_0 gate_way0_cell18 GND ml_0 p1 W=2.4e-6 L=1e-6
mnway0_cell19 ml_0 gate_way0_cell19 GND GND n1 W=1e-6 L=1e-6
mpway0_cell19 ml_0 gate_way0_cell19 GND ml_0 p1 W=2.4e-6 L=1e-6
mnway0_cell20 ml_0 gate_way0_cell20 GND GND n1 W=1e-6 L=1e-6
mpway0_cell20 ml_0 gate_way0_cell20 GND ml_0 p1 W=2.4e-6 L=1e-6
mnway0_cell21 ml_0 gate_way0_cell21 GND GND n1 W=1e-6 L=1e-6
mpway0_cell21 ml_0 gate_way0_cell21 GND ml_0 p1 W=2.4e-6 L=1e-6
mnway0_cell22 ml_0 gate_way0_cell22 GND GND n1 W=1e-6 L=1e-6
mpway0_cell22 ml_0 gate_way0_cell22 GND ml_0 p1 W=2.4e-6 L=1e-6
mnway0_cell23 ml_0 gate_way0_cell23 GND GND n1 W=1e-6 L=1e-6
mpway0_cell23 ml_0 gate_way0_cell23 GND ml_0 p1 W=2.4e-6 L=1e-6
mnway0_cell24 ml_0 gate_way0_cell24 GND GND n1 W=1e-6 L=1e-6
mpway0_cell24 ml_0 gate_way0_cell24 GND ml_0 p1 W=2.4e-6 L=1e-6
mnway0_cell25 ml_0 gate_way0_cell25 GND GND n1 W=1e-6 L=1e-6
mpway0_cell25 ml_0 gate_way0_cell25 GND ml_0 p1 W=2.4e-6 L=1e-6
mnway0_cell26 ml_0 gate_way0_cell26 GND GND n1 W=1e-6 L=1e-6
mpway0_cell26 ml_0 gate_way0_cell26 GND ml_0 p1 W=2.4e-6 L=1e-6
mnway0_cell27 ml_0 gate_way0_cell27 GND GND n1 W=1e-6 L=1e-6
mpway0_cell27 ml_0 gate_way0_cell27 GND ml_0 p1 W=2.4e-6 L=1e-6
mnway0_cell28 ml_0 gate_way0_cell28 GND GND n1 W=1e-6 L=1e-6
mpway0_cell28 ml_0 gate_way0_cell28 GND ml_0 p1 W=2.4e-6 L=1e-6
mnway0_cell29 ml_0 gate_way0_cell29 GND GND n1 W=1e-6 L=1e-6
mpway0_cell29 ml_0 gate_way0_cell29 GND ml_0 p1 W=2.4e-6 L=1e-6
mnway0_cell30 ml_0 gate_way0_cell30 GND GND n1 W=1e-6 L=1e-6
mpway0_cell30 ml_0 gate_way0_cell30 GND ml_0 p1 W=2.4e-6 L=1e-6
mnway0_cell31 ml_0 gate_way0_cell31 GND GND n1 W=1e-6 L=1e-6
mpway0_cell31 ml_0 gate_way0_cell31 GND ml_0 p1 W=2.4e-6 L=1e-6
mnway0_cell32 ml_0 gate_way0_cell32 GND GND n1 W=1e-6 L=1e-6
mpway0_cell32 ml_0 gate_way0_cell32 GND ml_0 p1 W=2.4e-6 L=1e-6
mnway0_cell33 ml_0 gate_way0_cell33 GND GND n1 W=1e-6 L=1e-6
mpway0_cell33 ml_0 gate_way0_cell33 GND ml_0 p1 W=2.4e-6 L=1e-6
mnway0_cell34 ml_0 gate_way0_cell34 GND GND n1 W=1e-6 L=1e-6
mpway0_cell34 ml_0 gate_way0_cell34 GND ml_0 p1 W=2.4e-6 L=1e-6
mnway0_cell35 ml_0 gate_way0_cell35 GND GND n1 W=1e-6 L=1e-6
mpway0_cell35 ml_0 gate_way0_cell35 GND ml_0 p1 W=2.4e-6 L=1e-6
mnway0_cell36 ml_0 gate_way0_cell36 GND GND n1 W=1e-6 L=1e-6
mpway0_cell36 ml_0 gate_way0_cell36 GND ml_0 p1 W=2.4e-6 L=1e-6
mnway0_cell37 ml_0 gate_way0_cell37 GND GND n1 W=1e-6 L=1e-6
mpway0_cell37 ml_0 gate_way0_cell37 GND ml_0 p1 W=2.4e-6 L=1e-6
mnway0_cell38 ml_0 gate_way0_cell38 GND GND n1 W=1e-6 L=1e-6
mpway0_cell38 ml_0 gate_way0_cell38 GND ml_0 p1 W=2.4e-6 L=1e-6
mnway0_cell39 ml_0 gate_way0_cell39 GND GND n1 W=1e-6 L=1e-6
mpway0_cell39 ml_0 gate_way0_cell39 GND ml_0 p1 W=2.4e-6 L=1e-6
mnway0_cell40 ml_0 gate_way0_cell40 GND GND n1 W=1e-6 L=1e-6
mpway0_cell40 ml_0 gate_way0_cell40 GND ml_0 p1 W=2.4e-6 L=1e-6
mnway0_cell41 ml_0 gate_way0_cell41 GND GND n1 W=1e-6 L=1e-6
mpway0_cell41 ml_0 gate_way0_cell41 GND ml_0 p1 W=2.4e-6 L=1e-6
mnway0_cell42 ml_0 gate_way0_cell42 GND GND n1 W=1e-6 L=1e-6
mpway0_cell42 ml_0 gate_way0_cell42 GND ml_0 p1 W=2.4e-6 L=1e-6
mnway0_cell43 ml_0 gate_way0_cell43 GND GND n1 W=1e-6 L=1e-6
mpway0_cell43 ml_0 gate_way0_cell43 GND ml_0 p1 W=2.4e-6 L=1e-6
mnway0_cell44 ml_0 gate_way0_cell44 GND GND n1 W=1e-6 L=1e-6
mpway0_cell44 ml_0 gate_way0_cell44 GND ml_0 p1 W=2.4e-6 L=1e-6
mnway0_cell45 ml_0 gate_way0_cell45 GND GND n1 W=1e-6 L=1e-6
mpway0_cell45 ml_0 gate_way0_cell45 GND ml_0 p1 W=2.4e-6 L=1e-6
mnway0_cell46 ml_0 gate_way0_cell46 GND GND n1 W=1e-6 L=1e-6
mpway0_cell46 ml_0 gate_way0_cell46 GND ml_0 p1 W=2.4e-6 L=1e-6
mnway0_cell47 ml_0 gate_way0_cell47 GND GND n1 W=1e-6 L=1e-6
mpway0_cell47 ml_0 gate_way0_cell47 GND ml_0 p1 W=2.4e-6 L=1e-6
mnway0_cell48 ml_0 gate_way0_cell48 GND GND n1 W=1e-6 L=1e-6
mpway0_cell48 ml_0 gate_way0_cell48 GND ml_0 p1 W=2.4e-6 L=1e-6
mnway0_cell49 ml_0 gate_way0_cell49 GND GND n1 W=1e-6 L=1e-6
mpway0_cell49 ml_0 gate_way0_cell49 GND ml_0 p1 W=2.4e-6 L=1e-6
mnway0_cell50 ml_0 gate_way0_cell50 GND GND n1 W=1e-6 L=1e-6
mpway0_cell50 ml_0 gate_way0_cell50 GND ml_0 p1 W=2.4e-6 L=1e-6
mnway0_cell51 ml_0 gate_way0_cell51 GND GND n1 W=1e-6 L=1e-6
mpway0_cell51 ml_0 gate_way0_cell51 GND ml_0 p1 W=2.4e-6 L=1e-6
mnway0_cell52 ml_0 gate_way0_cell52 GND GND n1 W=1e-6 L=1e-6
mpway0_cell52 ml_0 gate_way0_cell52 GND ml_0 p1 W=2.4e-6 L=1e-6
mnway0_cell53 ml_0 gate_way0_cell53 GND GND n1 W=1e-6 L=1e-6
mpway0_cell53 ml_0 gate_way0_cell53 GND ml_0 p1 W=2.4e-6 L=1e-6
mnway0_cell54 ml_0 gate_way0_cell54 GND GND n1 W=1e-6 L=1e-6
mpway0_cell54 ml_0 gate_way0_cell54 GND ml_0 p1 W=2.4e-6 L=1e-6
mnway0_cell55 ml_0 gate_way0_cell55 GND GND n1 W=1e-6 L=1e-6
mpway0_cell55 ml_0 gate_way0_cell55 GND ml_0 p1 W=2.4e-6 L=1e-6
mnway0_cell56 ml_0 gate_way0_cell56 GND GND n1 W=1e-6 L=1e-6
mpway0_cell56 ml_0 gate_way0_cell56 GND ml_0 p1 W=2.4e-6 L=1e-6
mnway0_cell57 ml_0 gate_way0_cell57 GND GND n1 W=1e-6 L=1e-6
mpway0_cell57 ml_0 gate_way0_cell57 GND ml_0 p1 W=2.4e-6 L=1e-6
mnway0_cell58 ml_0 gate_way0_cell58 GND GND n1 W=1e-6 L=1e-6
mpway0_cell58 ml_0 gate_way0_cell58 GND ml_0 p1 W=2.4e-6 L=1e-6
mnway0_cell59 ml_0 gate_way0_cell59 GND GND n1 W=1e-6 L=1e-6
mpway0_cell59 ml_0 gate_way0_cell59 GND ml_0 p1 W=2.4e-6 L=1e-6
mnway0_cell60 ml_0 gate_way0_cell60 GND GND n1 W=1e-6 L=1e-6
mpway0_cell60 ml_0 gate_way0_cell60 GND ml_0 p1 W=2.4e-6 L=1e-6
mnway0_cell61 ml_0 gate_way0_cell61 GND GND n1 W=1e-6 L=1e-6
mpway0_cell61 ml_0 gate_way0_cell61 GND ml_0 p1 W=2.4e-6 L=1e-6
mnway0_cell62 ml_0 gate_way0_cell62 GND GND n1 W=1e-6 L=1e-6
mpway0_cell62 ml_0 gate_way0_cell62 GND ml_0 p1 W=2.4e-6 L=1e-6
mnway0_cell63 ml_0 gate_way0_cell63 GND GND n1 W=1e-6 L=1e-6
mpway0_cell63 ml_0 gate_way0_cell63 GND ml_0 p1 W=2.4e-6 L=1e-6
mnway0_cell64 ml_0 gate_way0_cell64 GND GND n1 W=1e-6 L=1e-6
mpway0_cell64 ml_0 gate_way0_cell64 GND ml_0 p1 W=2.4e-6 L=1e-6
mnway0_cell65 ml_0 gate_way0_cell65 GND GND n1 W=1e-6 L=1e-6
mpway0_cell65 ml_0 gate_way0_cell65 GND ml_0 p1 W=2.4e-6 L=1e-6
mnway0_cell66 ml_0 gate_way0_cell66 GND GND n1 W=1e-6 L=1e-6
mpway0_cell66 ml_0 gate_way0_cell66 GND ml_0 p1 W=2.4e-6 L=1e-6
mnway0_cell67 ml_0 gate_way0_cell67 GND GND n1 W=1e-6 L=1e-6
mpway0_cell67 ml_0 gate_way0_cell67 GND ml_0 p1 W=2.4e-6 L=1e-6
mnway0_cell68 ml_0 gate_way0_cell68 GND GND n1 W=1e-6 L=1e-6
mpway0_cell68 ml_0 gate_way0_cell68 GND ml_0 p1 W=2.4e-6 L=1e-6
mnway0_cell69 ml_0 gate_way0_cell69 GND GND n1 W=1e-6 L=1e-6
mpway0_cell69 ml_0 gate_way0_cell69 GND ml_0 p1 W=2.4e-6 L=1e-6
mnway0_cell70 ml_0 gate_way0_cell70 GND GND n1 W=1e-6 L=1e-6
mpway0_cell70 ml_0 gate_way0_cell70 GND ml_0 p1 W=2.4e-6 L=1e-6
mnway0_cell71 ml_0 gate_way0_cell71 GND GND n1 W=1e-6 L=1e-6
mpway0_cell71 ml_0 gate_way0_cell71 GND ml_0 p1 W=2.4e-6 L=1e-6
mnway0_cell72 ml_0 gate_way0_cell72 GND GND n1 W=1e-6 L=1e-6
mpway0_cell72 ml_0 gate_way0_cell72 GND ml_0 p1 W=2.4e-6 L=1e-6
mnway0_cell73 ml_0 gate_way0_cell73 GND GND n1 W=1e-6 L=1e-6
mpway0_cell73 ml_0 gate_way0_cell73 GND ml_0 p1 W=2.4e-6 L=1e-6
mnway0_cell74 ml_0 gate_way0_cell74 GND GND n1 W=1e-6 L=1e-6
mpway0_cell74 ml_0 gate_way0_cell74 GND ml_0 p1 W=2.4e-6 L=1e-6
mnway0_cell75 ml_0 gate_way0_cell75 GND GND n1 W=1e-6 L=1e-6
mpway0_cell75 ml_0 gate_way0_cell75 GND ml_0 p1 W=2.4e-6 L=1e-6
mnway0_cell76 ml_0 gate_way0_cell76 GND GND n1 W=1e-6 L=1e-6
mpway0_cell76 ml_0 gate_way0_cell76 GND ml_0 p1 W=2.4e-6 L=1e-6
mnway0_cell77 ml_0 gate_way0_cell77 GND GND n1 W=1e-6 L=1e-6
mpway0_cell77 ml_0 gate_way0_cell77 GND ml_0 p1 W=2.4e-6 L=1e-6
mnway0_cell78 ml_0 gate_way0_cell78 GND GND n1 W=1e-6 L=1e-6
mpway0_cell78 ml_0 gate_way0_cell78 GND ml_0 p1 W=2.4e-6 L=1e-6
mnway0_cell79 ml_0 gate_way0_cell79 GND GND n1 W=1e-6 L=1e-6
mpway0_cell79 ml_0 gate_way0_cell79 GND ml_0 p1 W=2.4e-6 L=1e-6
mnway0_cell80 ml_0 gate_way0_cell80 GND GND n1 W=1e-6 L=1e-6
mpway0_cell80 ml_0 gate_way0_cell80 GND ml_0 p1 W=2.4e-6 L=1e-6
mnway0_cell81 ml_0 gate_way0_cell81 GND GND n1 W=1e-6 L=1e-6
mpway0_cell81 ml_0 gate_way0_cell81 GND ml_0 p1 W=2.4e-6 L=1e-6
mnway0_cell82 ml_0 gate_way0_cell82 GND GND n1 W=1e-6 L=1e-6
mpway0_cell82 ml_0 gate_way0_cell82 GND ml_0 p1 W=2.4e-6 L=1e-6
mnway0_cell83 ml_0 gate_way0_cell83 GND GND n1 W=1e-6 L=1e-6
mpway0_cell83 ml_0 gate_way0_cell83 GND ml_0 p1 W=2.4e-6 L=1e-6
mnway0_cell84 ml_0 gate_way0_cell84 GND GND n1 W=1e-6 L=1e-6
mpway0_cell84 ml_0 gate_way0_cell84 GND ml_0 p1 W=2.4e-6 L=1e-6
mnway0_cell85 ml_0 gate_way0_cell85 GND GND n1 W=1e-6 L=1e-6
mpway0_cell85 ml_0 gate_way0_cell85 GND ml_0 p1 W=2.4e-6 L=1e-6
mnway0_cell86 ml_0 gate_way0_cell86 GND GND n1 W=1e-6 L=1e-6
mpway0_cell86 ml_0 gate_way0_cell86 GND ml_0 p1 W=2.4e-6 L=1e-6
mnway0_cell87 ml_0 gate_way0_cell87 GND GND n1 W=1e-6 L=1e-6
mpway0_cell87 ml_0 gate_way0_cell87 GND ml_0 p1 W=2.4e-6 L=1e-6
mnway0_cell88 ml_0 gate_way0_cell88 GND GND n1 W=1e-6 L=1e-6
mpway0_cell88 ml_0 gate_way0_cell88 GND ml_0 p1 W=2.4e-6 L=1e-6
mnway0_cell89 ml_0 gate_way0_cell89 GND GND n1 W=1e-6 L=1e-6
mpway0_cell89 ml_0 gate_way0_cell89 GND ml_0 p1 W=2.4e-6 L=1e-6
mnway0_cell90 ml_0 gate_way0_cell90 GND GND n1 W=1e-6 L=1e-6
mpway0_cell90 ml_0 gate_way0_cell90 GND ml_0 p1 W=2.4e-6 L=1e-6
mnway0_cell91 ml_0 gate_way0_cell91 GND GND n1 W=1e-6 L=1e-6
mpway0_cell91 ml_0 gate_way0_cell91 GND ml_0 p1 W=2.4e-6 L=1e-6
mnway0_cell92 ml_0 gate_way0_cell92 GND GND n1 W=1e-6 L=1e-6
mpway0_cell92 ml_0 gate_way0_cell92 GND ml_0 p1 W=2.4e-6 L=1e-6
mnway0_cell93 ml_0 gate_way0_cell93 GND GND n1 W=1e-6 L=1e-6
mpway0_cell93 ml_0 gate_way0_cell93 GND ml_0 p1 W=2.4e-6 L=1e-6
mnway0_cell94 ml_0 gate_way0_cell94 GND GND n1 W=1e-6 L=1e-6
mpway0_cell94 ml_0 gate_way0_cell94 GND ml_0 p1 W=2.4e-6 L=1e-6
mnway0_cell95 ml_0 gate_way0_cell95 GND GND n1 W=1e-6 L=1e-6
mpway0_cell95 ml_0 gate_way0_cell95 GND ml_0 p1 W=2.4e-6 L=1e-6
mnway0_cell96 ml_0 gate_way0_cell96 GND GND n1 W=1e-6 L=1e-6
mpway0_cell96 ml_0 gate_way0_cell96 GND ml_0 p1 W=2.4e-6 L=1e-6
mnway0_cell97 ml_0 gate_way0_cell97 GND GND n1 W=1e-6 L=1e-6
mpway0_cell97 ml_0 gate_way0_cell97 GND ml_0 p1 W=2.4e-6 L=1e-6
mnway0_cell98 ml_0 gate_way0_cell98 GND GND n1 W=1e-6 L=1e-6
mpway0_cell98 ml_0 gate_way0_cell98 GND ml_0 p1 W=2.4e-6 L=1e-6
mnway0_cell99 ml_0 gate_way0_cell99 GND GND n1 W=1e-6 L=1e-6
mpway0_cell99 ml_0 gate_way0_cell99 GND ml_0 p1 W=2.4e-6 L=1e-6
mnway1_cell0 ml_1 gate_way1_cell0 GND GND n1 W=1e-6 L=1e-6
mpway1_cell0 ml_1 gate_way1_cell0 GND ml_1 p1 W=2.4e-6 L=1e-6
mnway1_cell1 ml_1 gate_way1_cell1 GND GND n1 W=1e-6 L=1e-6
mpway1_cell1 ml_1 gate_way1_cell1 GND ml_1 p1 W=2.4e-6 L=1e-6
mnway1_cell2 ml_1 gate_way1_cell2 GND GND n1 W=1e-6 L=1e-6
mpway1_cell2 ml_1 gate_way1_cell2 GND ml_1 p1 W=2.4e-6 L=1e-6
mnway1_cell3 ml_1 gate_way1_cell3 GND GND n1 W=1e-6 L=1e-6
mpway1_cell3 ml_1 gate_way1_cell3 GND ml_1 p1 W=2.4e-6 L=1e-6
mnway1_cell4 ml_1 gate_way1_cell4 GND GND n1 W=1e-6 L=1e-6
mpway1_cell4 ml_1 gate_way1_cell4 GND ml_1 p1 W=2.4e-6 L=1e-6
mnway1_cell5 ml_1 gate_way1_cell5 GND GND n1 W=1e-6 L=1e-6
mpway1_cell5 ml_1 gate_way1_cell5 GND ml_1 p1 W=2.4e-6 L=1e-6
mnway1_cell6 ml_1 gate_way1_cell6 GND GND n1 W=1e-6 L=1e-6
mpway1_cell6 ml_1 gate_way1_cell6 GND ml_1 p1 W=2.4e-6 L=1e-6
mnway1_cell7 ml_1 gate_way1_cell7 GND GND n1 W=1e-6 L=1e-6
mpway1_cell7 ml_1 gate_way1_cell7 GND ml_1 p1 W=2.4e-6 L=1e-6
mnway1_cell8 ml_1 gate_way1_cell8 GND GND n1 W=1e-6 L=1e-6
mpway1_cell8 ml_1 gate_way1_cell8 GND ml_1 p1 W=2.4e-6 L=1e-6
mnway1_cell9 ml_1 gate_way1_cell9 GND GND n1 W=1e-6 L=1e-6
mpway1_cell9 ml_1 gate_way1_cell9 GND ml_1 p1 W=2.4e-6 L=1e-6
mnway1_cell10 ml_1 gate_way1_cell10 GND GND n1 W=1e-6 L=1e-6
mpway1_cell10 ml_1 gate_way1_cell10 GND ml_1 p1 W=2.4e-6 L=1e-6
mnway1_cell11 ml_1 gate_way1_cell11 GND GND n1 W=1e-6 L=1e-6
mpway1_cell11 ml_1 gate_way1_cell11 GND ml_1 p1 W=2.4e-6 L=1e-6
mnway1_cell12 ml_1 gate_way1_cell12 GND GND n1 W=1e-6 L=1e-6
mpway1_cell12 ml_1 gate_way1_cell12 GND ml_1 p1 W=2.4e-6 L=1e-6
mnway1_cell13 ml_1 gate_way1_cell13 GND GND n1 W=1e-6 L=1e-6
mpway1_cell13 ml_1 gate_way1_cell13 GND ml_1 p1 W=2.4e-6 L=1e-6
mnway1_cell14 ml_1 gate_way1_cell14 GND GND n1 W=1e-6 L=1e-6
mpway1_cell14 ml_1 gate_way1_cell14 GND ml_1 p1 W=2.4e-6 L=1e-6
mnway1_cell15 ml_1 gate_way1_cell15 GND GND n1 W=1e-6 L=1e-6
mpway1_cell15 ml_1 gate_way1_cell15 GND ml_1 p1 W=2.4e-6 L=1e-6
mnway1_cell16 ml_1 gate_way1_cell16 GND GND n1 W=1e-6 L=1e-6
mpway1_cell16 ml_1 gate_way1_cell16 GND ml_1 p1 W=2.4e-6 L=1e-6
mnway1_cell17 ml_1 gate_way1_cell17 GND GND n1 W=1e-6 L=1e-6
mpway1_cell17 ml_1 gate_way1_cell17 GND ml_1 p1 W=2.4e-6 L=1e-6
mnway1_cell18 ml_1 gate_way1_cell18 GND GND n1 W=1e-6 L=1e-6
mpway1_cell18 ml_1 gate_way1_cell18 GND ml_1 p1 W=2.4e-6 L=1e-6
mnway1_cell19 ml_1 gate_way1_cell19 GND GND n1 W=1e-6 L=1e-6
mpway1_cell19 ml_1 gate_way1_cell19 GND ml_1 p1 W=2.4e-6 L=1e-6
mnway1_cell20 ml_1 gate_way1_cell20 GND GND n1 W=1e-6 L=1e-6
mpway1_cell20 ml_1 gate_way1_cell20 GND ml_1 p1 W=2.4e-6 L=1e-6
mnway1_cell21 ml_1 gate_way1_cell21 GND GND n1 W=1e-6 L=1e-6
mpway1_cell21 ml_1 gate_way1_cell21 GND ml_1 p1 W=2.4e-6 L=1e-6
mnway1_cell22 ml_1 gate_way1_cell22 GND GND n1 W=1e-6 L=1e-6
mpway1_cell22 ml_1 gate_way1_cell22 GND ml_1 p1 W=2.4e-6 L=1e-6
mnway1_cell23 ml_1 gate_way1_cell23 GND GND n1 W=1e-6 L=1e-6
mpway1_cell23 ml_1 gate_way1_cell23 GND ml_1 p1 W=2.4e-6 L=1e-6
mnway1_cell24 ml_1 gate_way1_cell24 GND GND n1 W=1e-6 L=1e-6
mpway1_cell24 ml_1 gate_way1_cell24 GND ml_1 p1 W=2.4e-6 L=1e-6
mnway1_cell25 ml_1 gate_way1_cell25 GND GND n1 W=1e-6 L=1e-6
mpway1_cell25 ml_1 gate_way1_cell25 GND ml_1 p1 W=2.4e-6 L=1e-6
mnway1_cell26 ml_1 gate_way1_cell26 GND GND n1 W=1e-6 L=1e-6
mpway1_cell26 ml_1 gate_way1_cell26 GND ml_1 p1 W=2.4e-6 L=1e-6
mnway1_cell27 ml_1 gate_way1_cell27 GND GND n1 W=1e-6 L=1e-6
mpway1_cell27 ml_1 gate_way1_cell27 GND ml_1 p1 W=2.4e-6 L=1e-6
mnway1_cell28 ml_1 gate_way1_cell28 GND GND n1 W=1e-6 L=1e-6
mpway1_cell28 ml_1 gate_way1_cell28 GND ml_1 p1 W=2.4e-6 L=1e-6
mnway1_cell29 ml_1 gate_way1_cell29 GND GND n1 W=1e-6 L=1e-6
mpway1_cell29 ml_1 gate_way1_cell29 GND ml_1 p1 W=2.4e-6 L=1e-6
mnway1_cell30 ml_1 gate_way1_cell30 GND GND n1 W=1e-6 L=1e-6
mpway1_cell30 ml_1 gate_way1_cell30 GND ml_1 p1 W=2.4e-6 L=1e-6
mnway1_cell31 ml_1 gate_way1_cell31 GND GND n1 W=1e-6 L=1e-6
mpway1_cell31 ml_1 gate_way1_cell31 GND ml_1 p1 W=2.4e-6 L=1e-6
mnway1_cell32 ml_1 gate_way1_cell32 GND GND n1 W=1e-6 L=1e-6
mpway1_cell32 ml_1 gate_way1_cell32 GND ml_1 p1 W=2.4e-6 L=1e-6
mnway1_cell33 ml_1 gate_way1_cell33 GND GND n1 W=1e-6 L=1e-6
mpway1_cell33 ml_1 gate_way1_cell33 GND ml_1 p1 W=2.4e-6 L=1e-6
mnway1_cell34 ml_1 gate_way1_cell34 GND GND n1 W=1e-6 L=1e-6
mpway1_cell34 ml_1 gate_way1_cell34 GND ml_1 p1 W=2.4e-6 L=1e-6
mnway1_cell35 ml_1 gate_way1_cell35 GND GND n1 W=1e-6 L=1e-6
mpway1_cell35 ml_1 gate_way1_cell35 GND ml_1 p1 W=2.4e-6 L=1e-6
mnway1_cell36 ml_1 gate_way1_cell36 GND GND n1 W=1e-6 L=1e-6
mpway1_cell36 ml_1 gate_way1_cell36 GND ml_1 p1 W=2.4e-6 L=1e-6
mnway1_cell37 ml_1 gate_way1_cell37 GND GND n1 W=1e-6 L=1e-6
mpway1_cell37 ml_1 gate_way1_cell37 GND ml_1 p1 W=2.4e-6 L=1e-6
mnway1_cell38 ml_1 gate_way1_cell38 GND GND n1 W=1e-6 L=1e-6
mpway1_cell38 ml_1 gate_way1_cell38 GND ml_1 p1 W=2.4e-6 L=1e-6
mnway1_cell39 ml_1 gate_way1_cell39 GND GND n1 W=1e-6 L=1e-6
mpway1_cell39 ml_1 gate_way1_cell39 GND ml_1 p1 W=2.4e-6 L=1e-6
mnway1_cell40 ml_1 gate_way1_cell40 GND GND n1 W=1e-6 L=1e-6
mpway1_cell40 ml_1 gate_way1_cell40 GND ml_1 p1 W=2.4e-6 L=1e-6
mnway1_cell41 ml_1 gate_way1_cell41 GND GND n1 W=1e-6 L=1e-6
mpway1_cell41 ml_1 gate_way1_cell41 GND ml_1 p1 W=2.4e-6 L=1e-6
mnway1_cell42 ml_1 gate_way1_cell42 GND GND n1 W=1e-6 L=1e-6
mpway1_cell42 ml_1 gate_way1_cell42 GND ml_1 p1 W=2.4e-6 L=1e-6
mnway1_cell43 ml_1 gate_way1_cell43 GND GND n1 W=1e-6 L=1e-6
mpway1_cell43 ml_1 gate_way1_cell43 GND ml_1 p1 W=2.4e-6 L=1e-6
mnway1_cell44 ml_1 gate_way1_cell44 GND GND n1 W=1e-6 L=1e-6
mpway1_cell44 ml_1 gate_way1_cell44 GND ml_1 p1 W=2.4e-6 L=1e-6
mnway1_cell45 ml_1 gate_way1_cell45 GND GND n1 W=1e-6 L=1e-6
mpway1_cell45 ml_1 gate_way1_cell45 GND ml_1 p1 W=2.4e-6 L=1e-6
mnway1_cell46 ml_1 gate_way1_cell46 GND GND n1 W=1e-6 L=1e-6
mpway1_cell46 ml_1 gate_way1_cell46 GND ml_1 p1 W=2.4e-6 L=1e-6
mnway1_cell47 ml_1 gate_way1_cell47 GND GND n1 W=1e-6 L=1e-6
mpway1_cell47 ml_1 gate_way1_cell47 GND ml_1 p1 W=2.4e-6 L=1e-6
mnway1_cell48 ml_1 gate_way1_cell48 GND GND n1 W=1e-6 L=1e-6
mpway1_cell48 ml_1 gate_way1_cell48 GND ml_1 p1 W=2.4e-6 L=1e-6
mnway1_cell49 ml_1 gate_way1_cell49 GND GND n1 W=1e-6 L=1e-6
mpway1_cell49 ml_1 gate_way1_cell49 GND ml_1 p1 W=2.4e-6 L=1e-6
mnway1_cell50 ml_1 gate_way1_cell50 GND GND n1 W=1e-6 L=1e-6
mpway1_cell50 ml_1 gate_way1_cell50 GND ml_1 p1 W=2.4e-6 L=1e-6
mnway1_cell51 ml_1 gate_way1_cell51 GND GND n1 W=1e-6 L=1e-6
mpway1_cell51 ml_1 gate_way1_cell51 GND ml_1 p1 W=2.4e-6 L=1e-6
mnway1_cell52 ml_1 gate_way1_cell52 GND GND n1 W=1e-6 L=1e-6
mpway1_cell52 ml_1 gate_way1_cell52 GND ml_1 p1 W=2.4e-6 L=1e-6
mnway1_cell53 ml_1 gate_way1_cell53 GND GND n1 W=1e-6 L=1e-6
mpway1_cell53 ml_1 gate_way1_cell53 GND ml_1 p1 W=2.4e-6 L=1e-6
mnway1_cell54 ml_1 gate_way1_cell54 GND GND n1 W=1e-6 L=1e-6
mpway1_cell54 ml_1 gate_way1_cell54 GND ml_1 p1 W=2.4e-6 L=1e-6
mnway1_cell55 ml_1 gate_way1_cell55 GND GND n1 W=1e-6 L=1e-6
mpway1_cell55 ml_1 gate_way1_cell55 GND ml_1 p1 W=2.4e-6 L=1e-6
mnway1_cell56 ml_1 gate_way1_cell56 GND GND n1 W=1e-6 L=1e-6
mpway1_cell56 ml_1 gate_way1_cell56 GND ml_1 p1 W=2.4e-6 L=1e-6
mnway1_cell57 ml_1 gate_way1_cell57 GND GND n1 W=1e-6 L=1e-6
mpway1_cell57 ml_1 gate_way1_cell57 GND ml_1 p1 W=2.4e-6 L=1e-6
mnway1_cell58 ml_1 gate_way1_cell58 GND GND n1 W=1e-6 L=1e-6
mpway1_cell58 ml_1 gate_way1_cell58 GND ml_1 p1 W=2.4e-6 L=1e-6
mnway1_cell59 ml_1 gate_way1_cell59 GND GND n1 W=1e-6 L=1e-6
mpway1_cell59 ml_1 gate_way1_cell59 GND ml_1 p1 W=2.4e-6 L=1e-6
mnway1_cell60 ml_1 gate_way1_cell60 GND GND n1 W=1e-6 L=1e-6
mpway1_cell60 ml_1 gate_way1_cell60 GND ml_1 p1 W=2.4e-6 L=1e-6
mnway1_cell61 ml_1 gate_way1_cell61 GND GND n1 W=1e-6 L=1e-6
mpway1_cell61 ml_1 gate_way1_cell61 GND ml_1 p1 W=2.4e-6 L=1e-6
mnway1_cell62 ml_1 gate_way1_cell62 GND GND n1 W=1e-6 L=1e-6
mpway1_cell62 ml_1 gate_way1_cell62 GND ml_1 p1 W=2.4e-6 L=1e-6
mnway1_cell63 ml_1 gate_way1_cell63 GND GND n1 W=1e-6 L=1e-6
mpway1_cell63 ml_1 gate_way1_cell63 GND ml_1 p1 W=2.4e-6 L=1e-6
mnway1_cell64 ml_1 gate_way1_cell64 GND GND n1 W=1e-6 L=1e-6
mpway1_cell64 ml_1 gate_way1_cell64 GND ml_1 p1 W=2.4e-6 L=1e-6
mnway1_cell65 ml_1 gate_way1_cell65 GND GND n1 W=1e-6 L=1e-6
mpway1_cell65 ml_1 gate_way1_cell65 GND ml_1 p1 W=2.4e-6 L=1e-6
mnway1_cell66 ml_1 gate_way1_cell66 GND GND n1 W=1e-6 L=1e-6
mpway1_cell66 ml_1 gate_way1_cell66 GND ml_1 p1 W=2.4e-6 L=1e-6
mnway1_cell67 ml_1 gate_way1_cell67 GND GND n1 W=1e-6 L=1e-6
mpway1_cell67 ml_1 gate_way1_cell67 GND ml_1 p1 W=2.4e-6 L=1e-6
mnway1_cell68 ml_1 gate_way1_cell68 GND GND n1 W=1e-6 L=1e-6
mpway1_cell68 ml_1 gate_way1_cell68 GND ml_1 p1 W=2.4e-6 L=1e-6
mnway1_cell69 ml_1 gate_way1_cell69 GND GND n1 W=1e-6 L=1e-6
mpway1_cell69 ml_1 gate_way1_cell69 GND ml_1 p1 W=2.4e-6 L=1e-6
mnway1_cell70 ml_1 gate_way1_cell70 GND GND n1 W=1e-6 L=1e-6
mpway1_cell70 ml_1 gate_way1_cell70 GND ml_1 p1 W=2.4e-6 L=1e-6
mnway1_cell71 ml_1 gate_way1_cell71 GND GND n1 W=1e-6 L=1e-6
mpway1_cell71 ml_1 gate_way1_cell71 GND ml_1 p1 W=2.4e-6 L=1e-6
mnway1_cell72 ml_1 gate_way1_cell72 GND GND n1 W=1e-6 L=1e-6
mpway1_cell72 ml_1 gate_way1_cell72 GND ml_1 p1 W=2.4e-6 L=1e-6
mnway1_cell73 ml_1 gate_way1_cell73 GND GND n1 W=1e-6 L=1e-6
mpway1_cell73 ml_1 gate_way1_cell73 GND ml_1 p1 W=2.4e-6 L=1e-6
mnway1_cell74 ml_1 gate_way1_cell74 GND GND n1 W=1e-6 L=1e-6
mpway1_cell74 ml_1 gate_way1_cell74 GND ml_1 p1 W=2.4e-6 L=1e-6
mnway1_cell75 ml_1 gate_way1_cell75 GND GND n1 W=1e-6 L=1e-6
mpway1_cell75 ml_1 gate_way1_cell75 GND ml_1 p1 W=2.4e-6 L=1e-6
mnway1_cell76 ml_1 gate_way1_cell76 GND GND n1 W=1e-6 L=1e-6
mpway1_cell76 ml_1 gate_way1_cell76 GND ml_1 p1 W=2.4e-6 L=1e-6
mnway1_cell77 ml_1 gate_way1_cell77 GND GND n1 W=1e-6 L=1e-6
mpway1_cell77 ml_1 gate_way1_cell77 GND ml_1 p1 W=2.4e-6 L=1e-6
mnway1_cell78 ml_1 gate_way1_cell78 GND GND n1 W=1e-6 L=1e-6
mpway1_cell78 ml_1 gate_way1_cell78 GND ml_1 p1 W=2.4e-6 L=1e-6
mnway1_cell79 ml_1 gate_way1_cell79 GND GND n1 W=1e-6 L=1e-6
mpway1_cell79 ml_1 gate_way1_cell79 GND ml_1 p1 W=2.4e-6 L=1e-6
mnway1_cell80 ml_1 gate_way1_cell80 GND GND n1 W=1e-6 L=1e-6
mpway1_cell80 ml_1 gate_way1_cell80 GND ml_1 p1 W=2.4e-6 L=1e-6
mnway1_cell81 ml_1 gate_way1_cell81 GND GND n1 W=1e-6 L=1e-6
mpway1_cell81 ml_1 gate_way1_cell81 GND ml_1 p1 W=2.4e-6 L=1e-6
mnway1_cell82 ml_1 gate_way1_cell82 GND GND n1 W=1e-6 L=1e-6
mpway1_cell82 ml_1 gate_way1_cell82 GND ml_1 p1 W=2.4e-6 L=1e-6
mnway1_cell83 ml_1 gate_way1_cell83 GND GND n1 W=1e-6 L=1e-6
mpway1_cell83 ml_1 gate_way1_cell83 GND ml_1 p1 W=2.4e-6 L=1e-6
mnway1_cell84 ml_1 gate_way1_cell84 GND GND n1 W=1e-6 L=1e-6
mpway1_cell84 ml_1 gate_way1_cell84 GND ml_1 p1 W=2.4e-6 L=1e-6
mnway1_cell85 ml_1 gate_way1_cell85 GND GND n1 W=1e-6 L=1e-6
mpway1_cell85 ml_1 gate_way1_cell85 GND ml_1 p1 W=2.4e-6 L=1e-6
mnway1_cell86 ml_1 gate_way1_cell86 GND GND n1 W=1e-6 L=1e-6
mpway1_cell86 ml_1 gate_way1_cell86 GND ml_1 p1 W=2.4e-6 L=1e-6
mnway1_cell87 ml_1 gate_way1_cell87 GND GND n1 W=1e-6 L=1e-6
mpway1_cell87 ml_1 gate_way1_cell87 GND ml_1 p1 W=2.4e-6 L=1e-6
mnway1_cell88 ml_1 gate_way1_cell88 GND GND n1 W=1e-6 L=1e-6
mpway1_cell88 ml_1 gate_way1_cell88 GND ml_1 p1 W=2.4e-6 L=1e-6
mnway1_cell89 ml_1 gate_way1_cell89 GND GND n1 W=1e-6 L=1e-6
mpway1_cell89 ml_1 gate_way1_cell89 GND ml_1 p1 W=2.4e-6 L=1e-6
mnway1_cell90 ml_1 gate_way1_cell90 GND GND n1 W=1e-6 L=1e-6
mpway1_cell90 ml_1 gate_way1_cell90 GND ml_1 p1 W=2.4e-6 L=1e-6
mnway1_cell91 ml_1 gate_way1_cell91 GND GND n1 W=1e-6 L=1e-6
mpway1_cell91 ml_1 gate_way1_cell91 GND ml_1 p1 W=2.4e-6 L=1e-6
mnway1_cell92 ml_1 gate_way1_cell92 GND GND n1 W=1e-6 L=1e-6
mpway1_cell92 ml_1 gate_way1_cell92 GND ml_1 p1 W=2.4e-6 L=1e-6
mnway1_cell93 ml_1 gate_way1_cell93 GND GND n1 W=1e-6 L=1e-6
mpway1_cell93 ml_1 gate_way1_cell93 GND ml_1 p1 W=2.4e-6 L=1e-6
mnway1_cell94 ml_1 gate_way1_cell94 GND GND n1 W=1e-6 L=1e-6
mpway1_cell94 ml_1 gate_way1_cell94 GND ml_1 p1 W=2.4e-6 L=1e-6
mnway1_cell95 ml_1 gate_way1_cell95 GND GND n1 W=1e-6 L=1e-6
mpway1_cell95 ml_1 gate_way1_cell95 GND ml_1 p1 W=2.4e-6 L=1e-6
mnway1_cell96 ml_1 gate_way1_cell96 GND GND n1 W=1e-6 L=1e-6
mpway1_cell96 ml_1 gate_way1_cell96 GND ml_1 p1 W=2.4e-6 L=1e-6
mnway1_cell97 ml_1 gate_way1_cell97 GND GND n1 W=1e-6 L=1e-6
mpway1_cell97 ml_1 gate_way1_cell97 GND ml_1 p1 W=2.4e-6 L=1e-6
mnway1_cell98 ml_1 gate_way1_cell98 GND GND n1 W=1e-6 L=1e-6
mpway1_cell98 ml_1 gate_way1_cell98 GND ml_1 p1 W=2.4e-6 L=1e-6
mnway1_cell99 ml_1 gate_way1_cell99 GND GND n1 W=1e-6 L=1e-6
mpway1_cell99 ml_1 gate_way1_cell99 GND ml_1 p1 W=2.4e-6 L=1e-6
mnway2_cell0 ml_2 gate_way2_cell0 GND GND n1 W=1e-6 L=1e-6
mpway2_cell0 ml_2 gate_way2_cell0 GND ml_2 p1 W=2.4e-6 L=1e-6
mnway2_cell1 ml_2 gate_way2_cell1 GND GND n1 W=1e-6 L=1e-6
mpway2_cell1 ml_2 gate_way2_cell1 GND ml_2 p1 W=2.4e-6 L=1e-6
mnway2_cell2 ml_2 gate_way2_cell2 GND GND n1 W=1e-6 L=1e-6
mpway2_cell2 ml_2 gate_way2_cell2 GND ml_2 p1 W=2.4e-6 L=1e-6
mnway2_cell3 ml_2 gate_way2_cell3 GND GND n1 W=1e-6 L=1e-6
mpway2_cell3 ml_2 gate_way2_cell3 GND ml_2 p1 W=2.4e-6 L=1e-6
mnway2_cell4 ml_2 gate_way2_cell4 GND GND n1 W=1e-6 L=1e-6
mpway2_cell4 ml_2 gate_way2_cell4 GND ml_2 p1 W=2.4e-6 L=1e-6
mnway2_cell5 ml_2 gate_way2_cell5 GND GND n1 W=1e-6 L=1e-6
mpway2_cell5 ml_2 gate_way2_cell5 GND ml_2 p1 W=2.4e-6 L=1e-6
mnway2_cell6 ml_2 gate_way2_cell6 GND GND n1 W=1e-6 L=1e-6
mpway2_cell6 ml_2 gate_way2_cell6 GND ml_2 p1 W=2.4e-6 L=1e-6
mnway2_cell7 ml_2 gate_way2_cell7 GND GND n1 W=1e-6 L=1e-6
mpway2_cell7 ml_2 gate_way2_cell7 GND ml_2 p1 W=2.4e-6 L=1e-6
mnway2_cell8 ml_2 gate_way2_cell8 GND GND n1 W=1e-6 L=1e-6
mpway2_cell8 ml_2 gate_way2_cell8 GND ml_2 p1 W=2.4e-6 L=1e-6
mnway2_cell9 ml_2 gate_way2_cell9 GND GND n1 W=1e-6 L=1e-6
mpway2_cell9 ml_2 gate_way2_cell9 GND ml_2 p1 W=2.4e-6 L=1e-6
mnway2_cell10 ml_2 gate_way2_cell10 GND GND n1 W=1e-6 L=1e-6
mpway2_cell10 ml_2 gate_way2_cell10 GND ml_2 p1 W=2.4e-6 L=1e-6
mnway2_cell11 ml_2 gate_way2_cell11 GND GND n1 W=1e-6 L=1e-6
mpway2_cell11 ml_2 gate_way2_cell11 GND ml_2 p1 W=2.4e-6 L=1e-6
mnway2_cell12 ml_2 gate_way2_cell12 GND GND n1 W=1e-6 L=1e-6
mpway2_cell12 ml_2 gate_way2_cell12 GND ml_2 p1 W=2.4e-6 L=1e-6
mnway2_cell13 ml_2 gate_way2_cell13 GND GND n1 W=1e-6 L=1e-6
mpway2_cell13 ml_2 gate_way2_cell13 GND ml_2 p1 W=2.4e-6 L=1e-6
mnway2_cell14 ml_2 gate_way2_cell14 GND GND n1 W=1e-6 L=1e-6
mpway2_cell14 ml_2 gate_way2_cell14 GND ml_2 p1 W=2.4e-6 L=1e-6
mnway2_cell15 ml_2 gate_way2_cell15 GND GND n1 W=1e-6 L=1e-6
mpway2_cell15 ml_2 gate_way2_cell15 GND ml_2 p1 W=2.4e-6 L=1e-6
mnway2_cell16 ml_2 gate_way2_cell16 GND GND n1 W=1e-6 L=1e-6
mpway2_cell16 ml_2 gate_way2_cell16 GND ml_2 p1 W=2.4e-6 L=1e-6
mnway2_cell17 ml_2 gate_way2_cell17 GND GND n1 W=1e-6 L=1e-6
mpway2_cell17 ml_2 gate_way2_cell17 GND ml_2 p1 W=2.4e-6 L=1e-6
mnway2_cell18 ml_2 gate_way2_cell18 GND GND n1 W=1e-6 L=1e-6
mpway2_cell18 ml_2 gate_way2_cell18 GND ml_2 p1 W=2.4e-6 L=1e-6
mnway2_cell19 ml_2 gate_way2_cell19 GND GND n1 W=1e-6 L=1e-6
mpway2_cell19 ml_2 gate_way2_cell19 GND ml_2 p1 W=2.4e-6 L=1e-6
mnway2_cell20 ml_2 gate_way2_cell20 GND GND n1 W=1e-6 L=1e-6
mpway2_cell20 ml_2 gate_way2_cell20 GND ml_2 p1 W=2.4e-6 L=1e-6
mnway2_cell21 ml_2 gate_way2_cell21 GND GND n1 W=1e-6 L=1e-6
mpway2_cell21 ml_2 gate_way2_cell21 GND ml_2 p1 W=2.4e-6 L=1e-6
mnway2_cell22 ml_2 gate_way2_cell22 GND GND n1 W=1e-6 L=1e-6
mpway2_cell22 ml_2 gate_way2_cell22 GND ml_2 p1 W=2.4e-6 L=1e-6
mnway2_cell23 ml_2 gate_way2_cell23 GND GND n1 W=1e-6 L=1e-6
mpway2_cell23 ml_2 gate_way2_cell23 GND ml_2 p1 W=2.4e-6 L=1e-6
mnway2_cell24 ml_2 gate_way2_cell24 GND GND n1 W=1e-6 L=1e-6
mpway2_cell24 ml_2 gate_way2_cell24 GND ml_2 p1 W=2.4e-6 L=1e-6
mnway2_cell25 ml_2 gate_way2_cell25 GND GND n1 W=1e-6 L=1e-6
mpway2_cell25 ml_2 gate_way2_cell25 GND ml_2 p1 W=2.4e-6 L=1e-6
mnway2_cell26 ml_2 gate_way2_cell26 GND GND n1 W=1e-6 L=1e-6
mpway2_cell26 ml_2 gate_way2_cell26 GND ml_2 p1 W=2.4e-6 L=1e-6
mnway2_cell27 ml_2 gate_way2_cell27 GND GND n1 W=1e-6 L=1e-6
mpway2_cell27 ml_2 gate_way2_cell27 GND ml_2 p1 W=2.4e-6 L=1e-6
mnway2_cell28 ml_2 gate_way2_cell28 GND GND n1 W=1e-6 L=1e-6
mpway2_cell28 ml_2 gate_way2_cell28 GND ml_2 p1 W=2.4e-6 L=1e-6
mnway2_cell29 ml_2 gate_way2_cell29 GND GND n1 W=1e-6 L=1e-6
mpway2_cell29 ml_2 gate_way2_cell29 GND ml_2 p1 W=2.4e-6 L=1e-6
mnway2_cell30 ml_2 gate_way2_cell30 GND GND n1 W=1e-6 L=1e-6
mpway2_cell30 ml_2 gate_way2_cell30 GND ml_2 p1 W=2.4e-6 L=1e-6
mnway2_cell31 ml_2 gate_way2_cell31 GND GND n1 W=1e-6 L=1e-6
mpway2_cell31 ml_2 gate_way2_cell31 GND ml_2 p1 W=2.4e-6 L=1e-6
mnway2_cell32 ml_2 gate_way2_cell32 GND GND n1 W=1e-6 L=1e-6
mpway2_cell32 ml_2 gate_way2_cell32 GND ml_2 p1 W=2.4e-6 L=1e-6
mnway2_cell33 ml_2 gate_way2_cell33 GND GND n1 W=1e-6 L=1e-6
mpway2_cell33 ml_2 gate_way2_cell33 GND ml_2 p1 W=2.4e-6 L=1e-6
mnway2_cell34 ml_2 gate_way2_cell34 GND GND n1 W=1e-6 L=1e-6
mpway2_cell34 ml_2 gate_way2_cell34 GND ml_2 p1 W=2.4e-6 L=1e-6
mnway2_cell35 ml_2 gate_way2_cell35 GND GND n1 W=1e-6 L=1e-6
mpway2_cell35 ml_2 gate_way2_cell35 GND ml_2 p1 W=2.4e-6 L=1e-6
mnway2_cell36 ml_2 gate_way2_cell36 GND GND n1 W=1e-6 L=1e-6
mpway2_cell36 ml_2 gate_way2_cell36 GND ml_2 p1 W=2.4e-6 L=1e-6
mnway2_cell37 ml_2 gate_way2_cell37 GND GND n1 W=1e-6 L=1e-6
mpway2_cell37 ml_2 gate_way2_cell37 GND ml_2 p1 W=2.4e-6 L=1e-6
mnway2_cell38 ml_2 gate_way2_cell38 GND GND n1 W=1e-6 L=1e-6
mpway2_cell38 ml_2 gate_way2_cell38 GND ml_2 p1 W=2.4e-6 L=1e-6
mnway2_cell39 ml_2 gate_way2_cell39 GND GND n1 W=1e-6 L=1e-6
mpway2_cell39 ml_2 gate_way2_cell39 GND ml_2 p1 W=2.4e-6 L=1e-6
mnway2_cell40 ml_2 gate_way2_cell40 GND GND n1 W=1e-6 L=1e-6
mpway2_cell40 ml_2 gate_way2_cell40 GND ml_2 p1 W=2.4e-6 L=1e-6
mnway2_cell41 ml_2 gate_way2_cell41 GND GND n1 W=1e-6 L=1e-6
mpway2_cell41 ml_2 gate_way2_cell41 GND ml_2 p1 W=2.4e-6 L=1e-6
mnway2_cell42 ml_2 gate_way2_cell42 GND GND n1 W=1e-6 L=1e-6
mpway2_cell42 ml_2 gate_way2_cell42 GND ml_2 p1 W=2.4e-6 L=1e-6
mnway2_cell43 ml_2 gate_way2_cell43 GND GND n1 W=1e-6 L=1e-6
mpway2_cell43 ml_2 gate_way2_cell43 GND ml_2 p1 W=2.4e-6 L=1e-6
mnway2_cell44 ml_2 gate_way2_cell44 GND GND n1 W=1e-6 L=1e-6
mpway2_cell44 ml_2 gate_way2_cell44 GND ml_2 p1 W=2.4e-6 L=1e-6
mnway2_cell45 ml_2 gate_way2_cell45 GND GND n1 W=1e-6 L=1e-6
mpway2_cell45 ml_2 gate_way2_cell45 GND ml_2 p1 W=2.4e-6 L=1e-6
mnway2_cell46 ml_2 gate_way2_cell46 GND GND n1 W=1e-6 L=1e-6
mpway2_cell46 ml_2 gate_way2_cell46 GND ml_2 p1 W=2.4e-6 L=1e-6
mnway2_cell47 ml_2 gate_way2_cell47 GND GND n1 W=1e-6 L=1e-6
mpway2_cell47 ml_2 gate_way2_cell47 GND ml_2 p1 W=2.4e-6 L=1e-6
mnway2_cell48 ml_2 gate_way2_cell48 GND GND n1 W=1e-6 L=1e-6
mpway2_cell48 ml_2 gate_way2_cell48 GND ml_2 p1 W=2.4e-6 L=1e-6
mnway2_cell49 ml_2 gate_way2_cell49 GND GND n1 W=1e-6 L=1e-6
mpway2_cell49 ml_2 gate_way2_cell49 GND ml_2 p1 W=2.4e-6 L=1e-6
mnway2_cell50 ml_2 gate_way2_cell50 GND GND n1 W=1e-6 L=1e-6
mpway2_cell50 ml_2 gate_way2_cell50 GND ml_2 p1 W=2.4e-6 L=1e-6
mnway2_cell51 ml_2 gate_way2_cell51 GND GND n1 W=1e-6 L=1e-6
mpway2_cell51 ml_2 gate_way2_cell51 GND ml_2 p1 W=2.4e-6 L=1e-6
mnway2_cell52 ml_2 gate_way2_cell52 GND GND n1 W=1e-6 L=1e-6
mpway2_cell52 ml_2 gate_way2_cell52 GND ml_2 p1 W=2.4e-6 L=1e-6
mnway2_cell53 ml_2 gate_way2_cell53 GND GND n1 W=1e-6 L=1e-6
mpway2_cell53 ml_2 gate_way2_cell53 GND ml_2 p1 W=2.4e-6 L=1e-6
mnway2_cell54 ml_2 gate_way2_cell54 GND GND n1 W=1e-6 L=1e-6
mpway2_cell54 ml_2 gate_way2_cell54 GND ml_2 p1 W=2.4e-6 L=1e-6
mnway2_cell55 ml_2 gate_way2_cell55 GND GND n1 W=1e-6 L=1e-6
mpway2_cell55 ml_2 gate_way2_cell55 GND ml_2 p1 W=2.4e-6 L=1e-6
mnway2_cell56 ml_2 gate_way2_cell56 GND GND n1 W=1e-6 L=1e-6
mpway2_cell56 ml_2 gate_way2_cell56 GND ml_2 p1 W=2.4e-6 L=1e-6
mnway2_cell57 ml_2 gate_way2_cell57 GND GND n1 W=1e-6 L=1e-6
mpway2_cell57 ml_2 gate_way2_cell57 GND ml_2 p1 W=2.4e-6 L=1e-6
mnway2_cell58 ml_2 gate_way2_cell58 GND GND n1 W=1e-6 L=1e-6
mpway2_cell58 ml_2 gate_way2_cell58 GND ml_2 p1 W=2.4e-6 L=1e-6
mnway2_cell59 ml_2 gate_way2_cell59 GND GND n1 W=1e-6 L=1e-6
mpway2_cell59 ml_2 gate_way2_cell59 GND ml_2 p1 W=2.4e-6 L=1e-6
mnway2_cell60 ml_2 gate_way2_cell60 GND GND n1 W=1e-6 L=1e-6
mpway2_cell60 ml_2 gate_way2_cell60 GND ml_2 p1 W=2.4e-6 L=1e-6
mnway2_cell61 ml_2 gate_way2_cell61 GND GND n1 W=1e-6 L=1e-6
mpway2_cell61 ml_2 gate_way2_cell61 GND ml_2 p1 W=2.4e-6 L=1e-6
mnway2_cell62 ml_2 gate_way2_cell62 GND GND n1 W=1e-6 L=1e-6
mpway2_cell62 ml_2 gate_way2_cell62 GND ml_2 p1 W=2.4e-6 L=1e-6
mnway2_cell63 ml_2 gate_way2_cell63 GND GND n1 W=1e-6 L=1e-6
mpway2_cell63 ml_2 gate_way2_cell63 GND ml_2 p1 W=2.4e-6 L=1e-6
mnway2_cell64 ml_2 gate_way2_cell64 GND GND n1 W=1e-6 L=1e-6
mpway2_cell64 ml_2 gate_way2_cell64 GND ml_2 p1 W=2.4e-6 L=1e-6
mnway2_cell65 ml_2 gate_way2_cell65 GND GND n1 W=1e-6 L=1e-6
mpway2_cell65 ml_2 gate_way2_cell65 GND ml_2 p1 W=2.4e-6 L=1e-6
mnway2_cell66 ml_2 gate_way2_cell66 GND GND n1 W=1e-6 L=1e-6
mpway2_cell66 ml_2 gate_way2_cell66 GND ml_2 p1 W=2.4e-6 L=1e-6
mnway2_cell67 ml_2 gate_way2_cell67 GND GND n1 W=1e-6 L=1e-6
mpway2_cell67 ml_2 gate_way2_cell67 GND ml_2 p1 W=2.4e-6 L=1e-6
mnway2_cell68 ml_2 gate_way2_cell68 GND GND n1 W=1e-6 L=1e-6
mpway2_cell68 ml_2 gate_way2_cell68 GND ml_2 p1 W=2.4e-6 L=1e-6
mnway2_cell69 ml_2 gate_way2_cell69 GND GND n1 W=1e-6 L=1e-6
mpway2_cell69 ml_2 gate_way2_cell69 GND ml_2 p1 W=2.4e-6 L=1e-6
mnway2_cell70 ml_2 gate_way2_cell70 GND GND n1 W=1e-6 L=1e-6
mpway2_cell70 ml_2 gate_way2_cell70 GND ml_2 p1 W=2.4e-6 L=1e-6
mnway2_cell71 ml_2 gate_way2_cell71 GND GND n1 W=1e-6 L=1e-6
mpway2_cell71 ml_2 gate_way2_cell71 GND ml_2 p1 W=2.4e-6 L=1e-6
mnway2_cell72 ml_2 gate_way2_cell72 GND GND n1 W=1e-6 L=1e-6
mpway2_cell72 ml_2 gate_way2_cell72 GND ml_2 p1 W=2.4e-6 L=1e-6
mnway2_cell73 ml_2 gate_way2_cell73 GND GND n1 W=1e-6 L=1e-6
mpway2_cell73 ml_2 gate_way2_cell73 GND ml_2 p1 W=2.4e-6 L=1e-6
mnway2_cell74 ml_2 gate_way2_cell74 GND GND n1 W=1e-6 L=1e-6
mpway2_cell74 ml_2 gate_way2_cell74 GND ml_2 p1 W=2.4e-6 L=1e-6
mnway2_cell75 ml_2 gate_way2_cell75 GND GND n1 W=1e-6 L=1e-6
mpway2_cell75 ml_2 gate_way2_cell75 GND ml_2 p1 W=2.4e-6 L=1e-6
mnway2_cell76 ml_2 gate_way2_cell76 GND GND n1 W=1e-6 L=1e-6
mpway2_cell76 ml_2 gate_way2_cell76 GND ml_2 p1 W=2.4e-6 L=1e-6
mnway2_cell77 ml_2 gate_way2_cell77 GND GND n1 W=1e-6 L=1e-6
mpway2_cell77 ml_2 gate_way2_cell77 GND ml_2 p1 W=2.4e-6 L=1e-6
mnway2_cell78 ml_2 gate_way2_cell78 GND GND n1 W=1e-6 L=1e-6
mpway2_cell78 ml_2 gate_way2_cell78 GND ml_2 p1 W=2.4e-6 L=1e-6
mnway2_cell79 ml_2 gate_way2_cell79 GND GND n1 W=1e-6 L=1e-6
mpway2_cell79 ml_2 gate_way2_cell79 GND ml_2 p1 W=2.4e-6 L=1e-6
mnway2_cell80 ml_2 gate_way2_cell80 GND GND n1 W=1e-6 L=1e-6
mpway2_cell80 ml_2 gate_way2_cell80 GND ml_2 p1 W=2.4e-6 L=1e-6
mnway2_cell81 ml_2 gate_way2_cell81 GND GND n1 W=1e-6 L=1e-6
mpway2_cell81 ml_2 gate_way2_cell81 GND ml_2 p1 W=2.4e-6 L=1e-6
mnway2_cell82 ml_2 gate_way2_cell82 GND GND n1 W=1e-6 L=1e-6
mpway2_cell82 ml_2 gate_way2_cell82 GND ml_2 p1 W=2.4e-6 L=1e-6
mnway2_cell83 ml_2 gate_way2_cell83 GND GND n1 W=1e-6 L=1e-6
mpway2_cell83 ml_2 gate_way2_cell83 GND ml_2 p1 W=2.4e-6 L=1e-6
mnway2_cell84 ml_2 gate_way2_cell84 GND GND n1 W=1e-6 L=1e-6
mpway2_cell84 ml_2 gate_way2_cell84 GND ml_2 p1 W=2.4e-6 L=1e-6
mnway2_cell85 ml_2 gate_way2_cell85 GND GND n1 W=1e-6 L=1e-6
mpway2_cell85 ml_2 gate_way2_cell85 GND ml_2 p1 W=2.4e-6 L=1e-6
mnway2_cell86 ml_2 gate_way2_cell86 GND GND n1 W=1e-6 L=1e-6
mpway2_cell86 ml_2 gate_way2_cell86 GND ml_2 p1 W=2.4e-6 L=1e-6
mnway2_cell87 ml_2 gate_way2_cell87 GND GND n1 W=1e-6 L=1e-6
mpway2_cell87 ml_2 gate_way2_cell87 GND ml_2 p1 W=2.4e-6 L=1e-6
mnway2_cell88 ml_2 gate_way2_cell88 GND GND n1 W=1e-6 L=1e-6
mpway2_cell88 ml_2 gate_way2_cell88 GND ml_2 p1 W=2.4e-6 L=1e-6
mnway2_cell89 ml_2 gate_way2_cell89 GND GND n1 W=1e-6 L=1e-6
mpway2_cell89 ml_2 gate_way2_cell89 GND ml_2 p1 W=2.4e-6 L=1e-6
mnway2_cell90 ml_2 gate_way2_cell90 GND GND n1 W=1e-6 L=1e-6
mpway2_cell90 ml_2 gate_way2_cell90 GND ml_2 p1 W=2.4e-6 L=1e-6
mnway2_cell91 ml_2 gate_way2_cell91 GND GND n1 W=1e-6 L=1e-6
mpway2_cell91 ml_2 gate_way2_cell91 GND ml_2 p1 W=2.4e-6 L=1e-6
mnway2_cell92 ml_2 gate_way2_cell92 GND GND n1 W=1e-6 L=1e-6
mpway2_cell92 ml_2 gate_way2_cell92 GND ml_2 p1 W=2.4e-6 L=1e-6
mnway2_cell93 ml_2 gate_way2_cell93 GND GND n1 W=1e-6 L=1e-6
mpway2_cell93 ml_2 gate_way2_cell93 GND ml_2 p1 W=2.4e-6 L=1e-6
mnway2_cell94 ml_2 gate_way2_cell94 GND GND n1 W=1e-6 L=1e-6
mpway2_cell94 ml_2 gate_way2_cell94 GND ml_2 p1 W=2.4e-6 L=1e-6
mnway2_cell95 ml_2 gate_way2_cell95 GND GND n1 W=1e-6 L=1e-6
mpway2_cell95 ml_2 gate_way2_cell95 GND ml_2 p1 W=2.4e-6 L=1e-6
mnway2_cell96 ml_2 gate_way2_cell96 GND GND n1 W=1e-6 L=1e-6
mpway2_cell96 ml_2 gate_way2_cell96 GND ml_2 p1 W=2.4e-6 L=1e-6
mnway2_cell97 ml_2 gate_way2_cell97 GND GND n1 W=1e-6 L=1e-6
mpway2_cell97 ml_2 gate_way2_cell97 GND ml_2 p1 W=2.4e-6 L=1e-6
mnway2_cell98 ml_2 gate_way2_cell98 GND GND n1 W=1e-6 L=1e-6
mpway2_cell98 ml_2 gate_way2_cell98 GND ml_2 p1 W=2.4e-6 L=1e-6
mnway2_cell99 ml_2 gate_way2_cell99 GND GND n1 W=1e-6 L=1e-6
mpway2_cell99 ml_2 gate_way2_cell99 GND ml_2 p1 W=2.4e-6 L=1e-6
