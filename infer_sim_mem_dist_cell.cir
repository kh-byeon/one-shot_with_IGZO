*editor khb
mnway0_cell0 ML0 gate_way0_cell0 GND GND n1 W=1e-6 L=1e-6
mpway0_cell0 ML0 gate_way0_cell0 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell1 ML0 gate_way0_cell1 GND GND n1 W=1e-6 L=1e-6
mpway0_cell1 ML0 gate_way0_cell1 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell2 ML0 gate_way0_cell2 GND GND n1 W=1e-6 L=1e-6
mpway0_cell2 ML0 gate_way0_cell2 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell3 ML0 gate_way0_cell3 GND GND n1 W=1e-6 L=1e-6
mpway0_cell3 ML0 gate_way0_cell3 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell4 ML0 gate_way0_cell4 GND GND n1 W=1e-6 L=1e-6
mpway0_cell4 ML0 gate_way0_cell4 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell5 ML0 gate_way0_cell5 GND GND n1 W=1e-6 L=1e-6
mpway0_cell5 ML0 gate_way0_cell5 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell6 ML0 gate_way0_cell6 GND GND n1 W=1e-6 L=1e-6
mpway0_cell6 ML0 gate_way0_cell6 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell7 ML0 gate_way0_cell7 GND GND n1 W=1e-6 L=1e-6
mpway0_cell7 ML0 gate_way0_cell7 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell8 ML0 gate_way0_cell8 GND GND n1 W=1e-6 L=1e-6
mpway0_cell8 ML0 gate_way0_cell8 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell9 ML0 gate_way0_cell9 GND GND n1 W=1e-6 L=1e-6
mpway0_cell9 ML0 gate_way0_cell9 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell10 ML0 gate_way0_cell10 GND GND n1 W=1e-6 L=1e-6
mpway0_cell10 ML0 gate_way0_cell10 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell11 ML0 gate_way0_cell11 GND GND n1 W=1e-6 L=1e-6
mpway0_cell11 ML0 gate_way0_cell11 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell12 ML0 gate_way0_cell12 GND GND n1 W=1e-6 L=1e-6
mpway0_cell12 ML0 gate_way0_cell12 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell13 ML0 gate_way0_cell13 GND GND n1 W=1e-6 L=1e-6
mpway0_cell13 ML0 gate_way0_cell13 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell14 ML0 gate_way0_cell14 GND GND n1 W=1e-6 L=1e-6
mpway0_cell14 ML0 gate_way0_cell14 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell15 ML0 gate_way0_cell15 GND GND n1 W=1e-6 L=1e-6
mpway0_cell15 ML0 gate_way0_cell15 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell16 ML0 gate_way0_cell16 GND GND n1 W=1e-6 L=1e-6
mpway0_cell16 ML0 gate_way0_cell16 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell17 ML0 gate_way0_cell17 GND GND n1 W=1e-6 L=1e-6
mpway0_cell17 ML0 gate_way0_cell17 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell18 ML0 gate_way0_cell18 GND GND n1 W=1e-6 L=1e-6
mpway0_cell18 ML0 gate_way0_cell18 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell19 ML0 gate_way0_cell19 GND GND n1 W=1e-6 L=1e-6
mpway0_cell19 ML0 gate_way0_cell19 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell20 ML0 gate_way0_cell20 GND GND n1 W=1e-6 L=1e-6
mpway0_cell20 ML0 gate_way0_cell20 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell21 ML0 gate_way0_cell21 GND GND n1 W=1e-6 L=1e-6
mpway0_cell21 ML0 gate_way0_cell21 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell22 ML0 gate_way0_cell22 GND GND n1 W=1e-6 L=1e-6
mpway0_cell22 ML0 gate_way0_cell22 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell23 ML0 gate_way0_cell23 GND GND n1 W=1e-6 L=1e-6
mpway0_cell23 ML0 gate_way0_cell23 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell24 ML0 gate_way0_cell24 GND GND n1 W=1e-6 L=1e-6
mpway0_cell24 ML0 gate_way0_cell24 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell25 ML0 gate_way0_cell25 GND GND n1 W=1e-6 L=1e-6
mpway0_cell25 ML0 gate_way0_cell25 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell26 ML0 gate_way0_cell26 GND GND n1 W=1e-6 L=1e-6
mpway0_cell26 ML0 gate_way0_cell26 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell27 ML0 gate_way0_cell27 GND GND n1 W=1e-6 L=1e-6
mpway0_cell27 ML0 gate_way0_cell27 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell28 ML0 gate_way0_cell28 GND GND n1 W=1e-6 L=1e-6
mpway0_cell28 ML0 gate_way0_cell28 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell29 ML0 gate_way0_cell29 GND GND n1 W=1e-6 L=1e-6
mpway0_cell29 ML0 gate_way0_cell29 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell30 ML0 gate_way0_cell30 GND GND n1 W=1e-6 L=1e-6
mpway0_cell30 ML0 gate_way0_cell30 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell31 ML0 gate_way0_cell31 GND GND n1 W=1e-6 L=1e-6
mpway0_cell31 ML0 gate_way0_cell31 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell32 ML0 gate_way0_cell32 GND GND n1 W=1e-6 L=1e-6
mpway0_cell32 ML0 gate_way0_cell32 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell33 ML0 gate_way0_cell33 GND GND n1 W=1e-6 L=1e-6
mpway0_cell33 ML0 gate_way0_cell33 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell34 ML0 gate_way0_cell34 GND GND n1 W=1e-6 L=1e-6
mpway0_cell34 ML0 gate_way0_cell34 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell35 ML0 gate_way0_cell35 GND GND n1 W=1e-6 L=1e-6
mpway0_cell35 ML0 gate_way0_cell35 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell36 ML0 gate_way0_cell36 GND GND n1 W=1e-6 L=1e-6
mpway0_cell36 ML0 gate_way0_cell36 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell37 ML0 gate_way0_cell37 GND GND n1 W=1e-6 L=1e-6
mpway0_cell37 ML0 gate_way0_cell37 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell38 ML0 gate_way0_cell38 GND GND n1 W=1e-6 L=1e-6
mpway0_cell38 ML0 gate_way0_cell38 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell39 ML0 gate_way0_cell39 GND GND n1 W=1e-6 L=1e-6
mpway0_cell39 ML0 gate_way0_cell39 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell40 ML0 gate_way0_cell40 GND GND n1 W=1e-6 L=1e-6
mpway0_cell40 ML0 gate_way0_cell40 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell41 ML0 gate_way0_cell41 GND GND n1 W=1e-6 L=1e-6
mpway0_cell41 ML0 gate_way0_cell41 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell42 ML0 gate_way0_cell42 GND GND n1 W=1e-6 L=1e-6
mpway0_cell42 ML0 gate_way0_cell42 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell43 ML0 gate_way0_cell43 GND GND n1 W=1e-6 L=1e-6
mpway0_cell43 ML0 gate_way0_cell43 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell44 ML0 gate_way0_cell44 GND GND n1 W=1e-6 L=1e-6
mpway0_cell44 ML0 gate_way0_cell44 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell45 ML0 gate_way0_cell45 GND GND n1 W=1e-6 L=1e-6
mpway0_cell45 ML0 gate_way0_cell45 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell46 ML0 gate_way0_cell46 GND GND n1 W=1e-6 L=1e-6
mpway0_cell46 ML0 gate_way0_cell46 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell47 ML0 gate_way0_cell47 GND GND n1 W=1e-6 L=1e-6
mpway0_cell47 ML0 gate_way0_cell47 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell48 ML0 gate_way0_cell48 GND GND n1 W=1e-6 L=1e-6
mpway0_cell48 ML0 gate_way0_cell48 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell49 ML0 gate_way0_cell49 GND GND n1 W=1e-6 L=1e-6
mpway0_cell49 ML0 gate_way0_cell49 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell50 ML0 gate_way0_cell50 GND GND n1 W=1e-6 L=1e-6
mpway0_cell50 ML0 gate_way0_cell50 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell51 ML0 gate_way0_cell51 GND GND n1 W=1e-6 L=1e-6
mpway0_cell51 ML0 gate_way0_cell51 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell52 ML0 gate_way0_cell52 GND GND n1 W=1e-6 L=1e-6
mpway0_cell52 ML0 gate_way0_cell52 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell53 ML0 gate_way0_cell53 GND GND n1 W=1e-6 L=1e-6
mpway0_cell53 ML0 gate_way0_cell53 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell54 ML0 gate_way0_cell54 GND GND n1 W=1e-6 L=1e-6
mpway0_cell54 ML0 gate_way0_cell54 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell55 ML0 gate_way0_cell55 GND GND n1 W=1e-6 L=1e-6
mpway0_cell55 ML0 gate_way0_cell55 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell56 ML0 gate_way0_cell56 GND GND n1 W=1e-6 L=1e-6
mpway0_cell56 ML0 gate_way0_cell56 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell57 ML0 gate_way0_cell57 GND GND n1 W=1e-6 L=1e-6
mpway0_cell57 ML0 gate_way0_cell57 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell58 ML0 gate_way0_cell58 GND GND n1 W=1e-6 L=1e-6
mpway0_cell58 ML0 gate_way0_cell58 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell59 ML0 gate_way0_cell59 GND GND n1 W=1e-6 L=1e-6
mpway0_cell59 ML0 gate_way0_cell59 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell60 ML0 gate_way0_cell60 GND GND n1 W=1e-6 L=1e-6
mpway0_cell60 ML0 gate_way0_cell60 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell61 ML0 gate_way0_cell61 GND GND n1 W=1e-6 L=1e-6
mpway0_cell61 ML0 gate_way0_cell61 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell62 ML0 gate_way0_cell62 GND GND n1 W=1e-6 L=1e-6
mpway0_cell62 ML0 gate_way0_cell62 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell63 ML0 gate_way0_cell63 GND GND n1 W=1e-6 L=1e-6
mpway0_cell63 ML0 gate_way0_cell63 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell64 ML0 gate_way0_cell64 GND GND n1 W=1e-6 L=1e-6
mpway0_cell64 ML0 gate_way0_cell64 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell65 ML0 gate_way0_cell65 GND GND n1 W=1e-6 L=1e-6
mpway0_cell65 ML0 gate_way0_cell65 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell66 ML0 gate_way0_cell66 GND GND n1 W=1e-6 L=1e-6
mpway0_cell66 ML0 gate_way0_cell66 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell67 ML0 gate_way0_cell67 GND GND n1 W=1e-6 L=1e-6
mpway0_cell67 ML0 gate_way0_cell67 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell68 ML0 gate_way0_cell68 GND GND n1 W=1e-6 L=1e-6
mpway0_cell68 ML0 gate_way0_cell68 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell69 ML0 gate_way0_cell69 GND GND n1 W=1e-6 L=1e-6
mpway0_cell69 ML0 gate_way0_cell69 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell70 ML0 gate_way0_cell70 GND GND n1 W=1e-6 L=1e-6
mpway0_cell70 ML0 gate_way0_cell70 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell71 ML0 gate_way0_cell71 GND GND n1 W=1e-6 L=1e-6
mpway0_cell71 ML0 gate_way0_cell71 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell72 ML0 gate_way0_cell72 GND GND n1 W=1e-6 L=1e-6
mpway0_cell72 ML0 gate_way0_cell72 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell73 ML0 gate_way0_cell73 GND GND n1 W=1e-6 L=1e-6
mpway0_cell73 ML0 gate_way0_cell73 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell74 ML0 gate_way0_cell74 GND GND n1 W=1e-6 L=1e-6
mpway0_cell74 ML0 gate_way0_cell74 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell75 ML0 gate_way0_cell75 GND GND n1 W=1e-6 L=1e-6
mpway0_cell75 ML0 gate_way0_cell75 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell76 ML0 gate_way0_cell76 GND GND n1 W=1e-6 L=1e-6
mpway0_cell76 ML0 gate_way0_cell76 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell77 ML0 gate_way0_cell77 GND GND n1 W=1e-6 L=1e-6
mpway0_cell77 ML0 gate_way0_cell77 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell78 ML0 gate_way0_cell78 GND GND n1 W=1e-6 L=1e-6
mpway0_cell78 ML0 gate_way0_cell78 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell79 ML0 gate_way0_cell79 GND GND n1 W=1e-6 L=1e-6
mpway0_cell79 ML0 gate_way0_cell79 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell80 ML0 gate_way0_cell80 GND GND n1 W=1e-6 L=1e-6
mpway0_cell80 ML0 gate_way0_cell80 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell81 ML0 gate_way0_cell81 GND GND n1 W=1e-6 L=1e-6
mpway0_cell81 ML0 gate_way0_cell81 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell82 ML0 gate_way0_cell82 GND GND n1 W=1e-6 L=1e-6
mpway0_cell82 ML0 gate_way0_cell82 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell83 ML0 gate_way0_cell83 GND GND n1 W=1e-6 L=1e-6
mpway0_cell83 ML0 gate_way0_cell83 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell84 ML0 gate_way0_cell84 GND GND n1 W=1e-6 L=1e-6
mpway0_cell84 ML0 gate_way0_cell84 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell85 ML0 gate_way0_cell85 GND GND n1 W=1e-6 L=1e-6
mpway0_cell85 ML0 gate_way0_cell85 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell86 ML0 gate_way0_cell86 GND GND n1 W=1e-6 L=1e-6
mpway0_cell86 ML0 gate_way0_cell86 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell87 ML0 gate_way0_cell87 GND GND n1 W=1e-6 L=1e-6
mpway0_cell87 ML0 gate_way0_cell87 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell88 ML0 gate_way0_cell88 GND GND n1 W=1e-6 L=1e-6
mpway0_cell88 ML0 gate_way0_cell88 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell89 ML0 gate_way0_cell89 GND GND n1 W=1e-6 L=1e-6
mpway0_cell89 ML0 gate_way0_cell89 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell90 ML0 gate_way0_cell90 GND GND n1 W=1e-6 L=1e-6
mpway0_cell90 ML0 gate_way0_cell90 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell91 ML0 gate_way0_cell91 GND GND n1 W=1e-6 L=1e-6
mpway0_cell91 ML0 gate_way0_cell91 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell92 ML0 gate_way0_cell92 GND GND n1 W=1e-6 L=1e-6
mpway0_cell92 ML0 gate_way0_cell92 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell93 ML0 gate_way0_cell93 GND GND n1 W=1e-6 L=1e-6
mpway0_cell93 ML0 gate_way0_cell93 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell94 ML0 gate_way0_cell94 GND GND n1 W=1e-6 L=1e-6
mpway0_cell94 ML0 gate_way0_cell94 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell95 ML0 gate_way0_cell95 GND GND n1 W=1e-6 L=1e-6
mpway0_cell95 ML0 gate_way0_cell95 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell96 ML0 gate_way0_cell96 GND GND n1 W=1e-6 L=1e-6
mpway0_cell96 ML0 gate_way0_cell96 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell97 ML0 gate_way0_cell97 GND GND n1 W=1e-6 L=1e-6
mpway0_cell97 ML0 gate_way0_cell97 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell98 ML0 gate_way0_cell98 GND GND n1 W=1e-6 L=1e-6
mpway0_cell98 ML0 gate_way0_cell98 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell99 ML0 gate_way0_cell99 GND GND n1 W=1e-6 L=1e-6
mpway0_cell99 ML0 gate_way0_cell99 GND ML0 p1 W=2.4e-6 L=1e-6
mnway1_cell0 ML1 gate_way1_cell0 GND GND n1 W=1e-6 L=1e-6
mpway1_cell0 ML1 gate_way1_cell0 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell1 ML1 gate_way1_cell1 GND GND n1 W=1e-6 L=1e-6
mpway1_cell1 ML1 gate_way1_cell1 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell2 ML1 gate_way1_cell2 GND GND n1 W=1e-6 L=1e-6
mpway1_cell2 ML1 gate_way1_cell2 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell3 ML1 gate_way1_cell3 GND GND n1 W=1e-6 L=1e-6
mpway1_cell3 ML1 gate_way1_cell3 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell4 ML1 gate_way1_cell4 GND GND n1 W=1e-6 L=1e-6
mpway1_cell4 ML1 gate_way1_cell4 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell5 ML1 gate_way1_cell5 GND GND n1 W=1e-6 L=1e-6
mpway1_cell5 ML1 gate_way1_cell5 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell6 ML1 gate_way1_cell6 GND GND n1 W=1e-6 L=1e-6
mpway1_cell6 ML1 gate_way1_cell6 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell7 ML1 gate_way1_cell7 GND GND n1 W=1e-6 L=1e-6
mpway1_cell7 ML1 gate_way1_cell7 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell8 ML1 gate_way1_cell8 GND GND n1 W=1e-6 L=1e-6
mpway1_cell8 ML1 gate_way1_cell8 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell9 ML1 gate_way1_cell9 GND GND n1 W=1e-6 L=1e-6
mpway1_cell9 ML1 gate_way1_cell9 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell10 ML1 gate_way1_cell10 GND GND n1 W=1e-6 L=1e-6
mpway1_cell10 ML1 gate_way1_cell10 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell11 ML1 gate_way1_cell11 GND GND n1 W=1e-6 L=1e-6
mpway1_cell11 ML1 gate_way1_cell11 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell12 ML1 gate_way1_cell12 GND GND n1 W=1e-6 L=1e-6
mpway1_cell12 ML1 gate_way1_cell12 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell13 ML1 gate_way1_cell13 GND GND n1 W=1e-6 L=1e-6
mpway1_cell13 ML1 gate_way1_cell13 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell14 ML1 gate_way1_cell14 GND GND n1 W=1e-6 L=1e-6
mpway1_cell14 ML1 gate_way1_cell14 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell15 ML1 gate_way1_cell15 GND GND n1 W=1e-6 L=1e-6
mpway1_cell15 ML1 gate_way1_cell15 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell16 ML1 gate_way1_cell16 GND GND n1 W=1e-6 L=1e-6
mpway1_cell16 ML1 gate_way1_cell16 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell17 ML1 gate_way1_cell17 GND GND n1 W=1e-6 L=1e-6
mpway1_cell17 ML1 gate_way1_cell17 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell18 ML1 gate_way1_cell18 GND GND n1 W=1e-6 L=1e-6
mpway1_cell18 ML1 gate_way1_cell18 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell19 ML1 gate_way1_cell19 GND GND n1 W=1e-6 L=1e-6
mpway1_cell19 ML1 gate_way1_cell19 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell20 ML1 gate_way1_cell20 GND GND n1 W=1e-6 L=1e-6
mpway1_cell20 ML1 gate_way1_cell20 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell21 ML1 gate_way1_cell21 GND GND n1 W=1e-6 L=1e-6
mpway1_cell21 ML1 gate_way1_cell21 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell22 ML1 gate_way1_cell22 GND GND n1 W=1e-6 L=1e-6
mpway1_cell22 ML1 gate_way1_cell22 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell23 ML1 gate_way1_cell23 GND GND n1 W=1e-6 L=1e-6
mpway1_cell23 ML1 gate_way1_cell23 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell24 ML1 gate_way1_cell24 GND GND n1 W=1e-6 L=1e-6
mpway1_cell24 ML1 gate_way1_cell24 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell25 ML1 gate_way1_cell25 GND GND n1 W=1e-6 L=1e-6
mpway1_cell25 ML1 gate_way1_cell25 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell26 ML1 gate_way1_cell26 GND GND n1 W=1e-6 L=1e-6
mpway1_cell26 ML1 gate_way1_cell26 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell27 ML1 gate_way1_cell27 GND GND n1 W=1e-6 L=1e-6
mpway1_cell27 ML1 gate_way1_cell27 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell28 ML1 gate_way1_cell28 GND GND n1 W=1e-6 L=1e-6
mpway1_cell28 ML1 gate_way1_cell28 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell29 ML1 gate_way1_cell29 GND GND n1 W=1e-6 L=1e-6
mpway1_cell29 ML1 gate_way1_cell29 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell30 ML1 gate_way1_cell30 GND GND n1 W=1e-6 L=1e-6
mpway1_cell30 ML1 gate_way1_cell30 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell31 ML1 gate_way1_cell31 GND GND n1 W=1e-6 L=1e-6
mpway1_cell31 ML1 gate_way1_cell31 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell32 ML1 gate_way1_cell32 GND GND n1 W=1e-6 L=1e-6
mpway1_cell32 ML1 gate_way1_cell32 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell33 ML1 gate_way1_cell33 GND GND n1 W=1e-6 L=1e-6
mpway1_cell33 ML1 gate_way1_cell33 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell34 ML1 gate_way1_cell34 GND GND n1 W=1e-6 L=1e-6
mpway1_cell34 ML1 gate_way1_cell34 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell35 ML1 gate_way1_cell35 GND GND n1 W=1e-6 L=1e-6
mpway1_cell35 ML1 gate_way1_cell35 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell36 ML1 gate_way1_cell36 GND GND n1 W=1e-6 L=1e-6
mpway1_cell36 ML1 gate_way1_cell36 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell37 ML1 gate_way1_cell37 GND GND n1 W=1e-6 L=1e-6
mpway1_cell37 ML1 gate_way1_cell37 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell38 ML1 gate_way1_cell38 GND GND n1 W=1e-6 L=1e-6
mpway1_cell38 ML1 gate_way1_cell38 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell39 ML1 gate_way1_cell39 GND GND n1 W=1e-6 L=1e-6
mpway1_cell39 ML1 gate_way1_cell39 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell40 ML1 gate_way1_cell40 GND GND n1 W=1e-6 L=1e-6
mpway1_cell40 ML1 gate_way1_cell40 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell41 ML1 gate_way1_cell41 GND GND n1 W=1e-6 L=1e-6
mpway1_cell41 ML1 gate_way1_cell41 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell42 ML1 gate_way1_cell42 GND GND n1 W=1e-6 L=1e-6
mpway1_cell42 ML1 gate_way1_cell42 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell43 ML1 gate_way1_cell43 GND GND n1 W=1e-6 L=1e-6
mpway1_cell43 ML1 gate_way1_cell43 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell44 ML1 gate_way1_cell44 GND GND n1 W=1e-6 L=1e-6
mpway1_cell44 ML1 gate_way1_cell44 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell45 ML1 gate_way1_cell45 GND GND n1 W=1e-6 L=1e-6
mpway1_cell45 ML1 gate_way1_cell45 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell46 ML1 gate_way1_cell46 GND GND n1 W=1e-6 L=1e-6
mpway1_cell46 ML1 gate_way1_cell46 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell47 ML1 gate_way1_cell47 GND GND n1 W=1e-6 L=1e-6
mpway1_cell47 ML1 gate_way1_cell47 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell48 ML1 gate_way1_cell48 GND GND n1 W=1e-6 L=1e-6
mpway1_cell48 ML1 gate_way1_cell48 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell49 ML1 gate_way1_cell49 GND GND n1 W=1e-6 L=1e-6
mpway1_cell49 ML1 gate_way1_cell49 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell50 ML1 gate_way1_cell50 GND GND n1 W=1e-6 L=1e-6
mpway1_cell50 ML1 gate_way1_cell50 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell51 ML1 gate_way1_cell51 GND GND n1 W=1e-6 L=1e-6
mpway1_cell51 ML1 gate_way1_cell51 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell52 ML1 gate_way1_cell52 GND GND n1 W=1e-6 L=1e-6
mpway1_cell52 ML1 gate_way1_cell52 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell53 ML1 gate_way1_cell53 GND GND n1 W=1e-6 L=1e-6
mpway1_cell53 ML1 gate_way1_cell53 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell54 ML1 gate_way1_cell54 GND GND n1 W=1e-6 L=1e-6
mpway1_cell54 ML1 gate_way1_cell54 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell55 ML1 gate_way1_cell55 GND GND n1 W=1e-6 L=1e-6
mpway1_cell55 ML1 gate_way1_cell55 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell56 ML1 gate_way1_cell56 GND GND n1 W=1e-6 L=1e-6
mpway1_cell56 ML1 gate_way1_cell56 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell57 ML1 gate_way1_cell57 GND GND n1 W=1e-6 L=1e-6
mpway1_cell57 ML1 gate_way1_cell57 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell58 ML1 gate_way1_cell58 GND GND n1 W=1e-6 L=1e-6
mpway1_cell58 ML1 gate_way1_cell58 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell59 ML1 gate_way1_cell59 GND GND n1 W=1e-6 L=1e-6
mpway1_cell59 ML1 gate_way1_cell59 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell60 ML1 gate_way1_cell60 GND GND n1 W=1e-6 L=1e-6
mpway1_cell60 ML1 gate_way1_cell60 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell61 ML1 gate_way1_cell61 GND GND n1 W=1e-6 L=1e-6
mpway1_cell61 ML1 gate_way1_cell61 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell62 ML1 gate_way1_cell62 GND GND n1 W=1e-6 L=1e-6
mpway1_cell62 ML1 gate_way1_cell62 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell63 ML1 gate_way1_cell63 GND GND n1 W=1e-6 L=1e-6
mpway1_cell63 ML1 gate_way1_cell63 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell64 ML1 gate_way1_cell64 GND GND n1 W=1e-6 L=1e-6
mpway1_cell64 ML1 gate_way1_cell64 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell65 ML1 gate_way1_cell65 GND GND n1 W=1e-6 L=1e-6
mpway1_cell65 ML1 gate_way1_cell65 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell66 ML1 gate_way1_cell66 GND GND n1 W=1e-6 L=1e-6
mpway1_cell66 ML1 gate_way1_cell66 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell67 ML1 gate_way1_cell67 GND GND n1 W=1e-6 L=1e-6
mpway1_cell67 ML1 gate_way1_cell67 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell68 ML1 gate_way1_cell68 GND GND n1 W=1e-6 L=1e-6
mpway1_cell68 ML1 gate_way1_cell68 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell69 ML1 gate_way1_cell69 GND GND n1 W=1e-6 L=1e-6
mpway1_cell69 ML1 gate_way1_cell69 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell70 ML1 gate_way1_cell70 GND GND n1 W=1e-6 L=1e-6
mpway1_cell70 ML1 gate_way1_cell70 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell71 ML1 gate_way1_cell71 GND GND n1 W=1e-6 L=1e-6
mpway1_cell71 ML1 gate_way1_cell71 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell72 ML1 gate_way1_cell72 GND GND n1 W=1e-6 L=1e-6
mpway1_cell72 ML1 gate_way1_cell72 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell73 ML1 gate_way1_cell73 GND GND n1 W=1e-6 L=1e-6
mpway1_cell73 ML1 gate_way1_cell73 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell74 ML1 gate_way1_cell74 GND GND n1 W=1e-6 L=1e-6
mpway1_cell74 ML1 gate_way1_cell74 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell75 ML1 gate_way1_cell75 GND GND n1 W=1e-6 L=1e-6
mpway1_cell75 ML1 gate_way1_cell75 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell76 ML1 gate_way1_cell76 GND GND n1 W=1e-6 L=1e-6
mpway1_cell76 ML1 gate_way1_cell76 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell77 ML1 gate_way1_cell77 GND GND n1 W=1e-6 L=1e-6
mpway1_cell77 ML1 gate_way1_cell77 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell78 ML1 gate_way1_cell78 GND GND n1 W=1e-6 L=1e-6
mpway1_cell78 ML1 gate_way1_cell78 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell79 ML1 gate_way1_cell79 GND GND n1 W=1e-6 L=1e-6
mpway1_cell79 ML1 gate_way1_cell79 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell80 ML1 gate_way1_cell80 GND GND n1 W=1e-6 L=1e-6
mpway1_cell80 ML1 gate_way1_cell80 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell81 ML1 gate_way1_cell81 GND GND n1 W=1e-6 L=1e-6
mpway1_cell81 ML1 gate_way1_cell81 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell82 ML1 gate_way1_cell82 GND GND n1 W=1e-6 L=1e-6
mpway1_cell82 ML1 gate_way1_cell82 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell83 ML1 gate_way1_cell83 GND GND n1 W=1e-6 L=1e-6
mpway1_cell83 ML1 gate_way1_cell83 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell84 ML1 gate_way1_cell84 GND GND n1 W=1e-6 L=1e-6
mpway1_cell84 ML1 gate_way1_cell84 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell85 ML1 gate_way1_cell85 GND GND n1 W=1e-6 L=1e-6
mpway1_cell85 ML1 gate_way1_cell85 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell86 ML1 gate_way1_cell86 GND GND n1 W=1e-6 L=1e-6
mpway1_cell86 ML1 gate_way1_cell86 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell87 ML1 gate_way1_cell87 GND GND n1 W=1e-6 L=1e-6
mpway1_cell87 ML1 gate_way1_cell87 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell88 ML1 gate_way1_cell88 GND GND n1 W=1e-6 L=1e-6
mpway1_cell88 ML1 gate_way1_cell88 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell89 ML1 gate_way1_cell89 GND GND n1 W=1e-6 L=1e-6
mpway1_cell89 ML1 gate_way1_cell89 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell90 ML1 gate_way1_cell90 GND GND n1 W=1e-6 L=1e-6
mpway1_cell90 ML1 gate_way1_cell90 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell91 ML1 gate_way1_cell91 GND GND n1 W=1e-6 L=1e-6
mpway1_cell91 ML1 gate_way1_cell91 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell92 ML1 gate_way1_cell92 GND GND n1 W=1e-6 L=1e-6
mpway1_cell92 ML1 gate_way1_cell92 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell93 ML1 gate_way1_cell93 GND GND n1 W=1e-6 L=1e-6
mpway1_cell93 ML1 gate_way1_cell93 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell94 ML1 gate_way1_cell94 GND GND n1 W=1e-6 L=1e-6
mpway1_cell94 ML1 gate_way1_cell94 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell95 ML1 gate_way1_cell95 GND GND n1 W=1e-6 L=1e-6
mpway1_cell95 ML1 gate_way1_cell95 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell96 ML1 gate_way1_cell96 GND GND n1 W=1e-6 L=1e-6
mpway1_cell96 ML1 gate_way1_cell96 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell97 ML1 gate_way1_cell97 GND GND n1 W=1e-6 L=1e-6
mpway1_cell97 ML1 gate_way1_cell97 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell98 ML1 gate_way1_cell98 GND GND n1 W=1e-6 L=1e-6
mpway1_cell98 ML1 gate_way1_cell98 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell99 ML1 gate_way1_cell99 GND GND n1 W=1e-6 L=1e-6
mpway1_cell99 ML1 gate_way1_cell99 GND ML1 p1 W=2.4e-6 L=1e-6
mnway2_cell0 ML2 gate_way2_cell0 GND GND n1 W=1e-6 L=1e-6
mpway2_cell0 ML2 gate_way2_cell0 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell1 ML2 gate_way2_cell1 GND GND n1 W=1e-6 L=1e-6
mpway2_cell1 ML2 gate_way2_cell1 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell2 ML2 gate_way2_cell2 GND GND n1 W=1e-6 L=1e-6
mpway2_cell2 ML2 gate_way2_cell2 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell3 ML2 gate_way2_cell3 GND GND n1 W=1e-6 L=1e-6
mpway2_cell3 ML2 gate_way2_cell3 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell4 ML2 gate_way2_cell4 GND GND n1 W=1e-6 L=1e-6
mpway2_cell4 ML2 gate_way2_cell4 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell5 ML2 gate_way2_cell5 GND GND n1 W=1e-6 L=1e-6
mpway2_cell5 ML2 gate_way2_cell5 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell6 ML2 gate_way2_cell6 GND GND n1 W=1e-6 L=1e-6
mpway2_cell6 ML2 gate_way2_cell6 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell7 ML2 gate_way2_cell7 GND GND n1 W=1e-6 L=1e-6
mpway2_cell7 ML2 gate_way2_cell7 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell8 ML2 gate_way2_cell8 GND GND n1 W=1e-6 L=1e-6
mpway2_cell8 ML2 gate_way2_cell8 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell9 ML2 gate_way2_cell9 GND GND n1 W=1e-6 L=1e-6
mpway2_cell9 ML2 gate_way2_cell9 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell10 ML2 gate_way2_cell10 GND GND n1 W=1e-6 L=1e-6
mpway2_cell10 ML2 gate_way2_cell10 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell11 ML2 gate_way2_cell11 GND GND n1 W=1e-6 L=1e-6
mpway2_cell11 ML2 gate_way2_cell11 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell12 ML2 gate_way2_cell12 GND GND n1 W=1e-6 L=1e-6
mpway2_cell12 ML2 gate_way2_cell12 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell13 ML2 gate_way2_cell13 GND GND n1 W=1e-6 L=1e-6
mpway2_cell13 ML2 gate_way2_cell13 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell14 ML2 gate_way2_cell14 GND GND n1 W=1e-6 L=1e-6
mpway2_cell14 ML2 gate_way2_cell14 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell15 ML2 gate_way2_cell15 GND GND n1 W=1e-6 L=1e-6
mpway2_cell15 ML2 gate_way2_cell15 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell16 ML2 gate_way2_cell16 GND GND n1 W=1e-6 L=1e-6
mpway2_cell16 ML2 gate_way2_cell16 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell17 ML2 gate_way2_cell17 GND GND n1 W=1e-6 L=1e-6
mpway2_cell17 ML2 gate_way2_cell17 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell18 ML2 gate_way2_cell18 GND GND n1 W=1e-6 L=1e-6
mpway2_cell18 ML2 gate_way2_cell18 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell19 ML2 gate_way2_cell19 GND GND n1 W=1e-6 L=1e-6
mpway2_cell19 ML2 gate_way2_cell19 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell20 ML2 gate_way2_cell20 GND GND n1 W=1e-6 L=1e-6
mpway2_cell20 ML2 gate_way2_cell20 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell21 ML2 gate_way2_cell21 GND GND n1 W=1e-6 L=1e-6
mpway2_cell21 ML2 gate_way2_cell21 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell22 ML2 gate_way2_cell22 GND GND n1 W=1e-6 L=1e-6
mpway2_cell22 ML2 gate_way2_cell22 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell23 ML2 gate_way2_cell23 GND GND n1 W=1e-6 L=1e-6
mpway2_cell23 ML2 gate_way2_cell23 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell24 ML2 gate_way2_cell24 GND GND n1 W=1e-6 L=1e-6
mpway2_cell24 ML2 gate_way2_cell24 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell25 ML2 gate_way2_cell25 GND GND n1 W=1e-6 L=1e-6
mpway2_cell25 ML2 gate_way2_cell25 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell26 ML2 gate_way2_cell26 GND GND n1 W=1e-6 L=1e-6
mpway2_cell26 ML2 gate_way2_cell26 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell27 ML2 gate_way2_cell27 GND GND n1 W=1e-6 L=1e-6
mpway2_cell27 ML2 gate_way2_cell27 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell28 ML2 gate_way2_cell28 GND GND n1 W=1e-6 L=1e-6
mpway2_cell28 ML2 gate_way2_cell28 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell29 ML2 gate_way2_cell29 GND GND n1 W=1e-6 L=1e-6
mpway2_cell29 ML2 gate_way2_cell29 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell30 ML2 gate_way2_cell30 GND GND n1 W=1e-6 L=1e-6
mpway2_cell30 ML2 gate_way2_cell30 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell31 ML2 gate_way2_cell31 GND GND n1 W=1e-6 L=1e-6
mpway2_cell31 ML2 gate_way2_cell31 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell32 ML2 gate_way2_cell32 GND GND n1 W=1e-6 L=1e-6
mpway2_cell32 ML2 gate_way2_cell32 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell33 ML2 gate_way2_cell33 GND GND n1 W=1e-6 L=1e-6
mpway2_cell33 ML2 gate_way2_cell33 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell34 ML2 gate_way2_cell34 GND GND n1 W=1e-6 L=1e-6
mpway2_cell34 ML2 gate_way2_cell34 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell35 ML2 gate_way2_cell35 GND GND n1 W=1e-6 L=1e-6
mpway2_cell35 ML2 gate_way2_cell35 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell36 ML2 gate_way2_cell36 GND GND n1 W=1e-6 L=1e-6
mpway2_cell36 ML2 gate_way2_cell36 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell37 ML2 gate_way2_cell37 GND GND n1 W=1e-6 L=1e-6
mpway2_cell37 ML2 gate_way2_cell37 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell38 ML2 gate_way2_cell38 GND GND n1 W=1e-6 L=1e-6
mpway2_cell38 ML2 gate_way2_cell38 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell39 ML2 gate_way2_cell39 GND GND n1 W=1e-6 L=1e-6
mpway2_cell39 ML2 gate_way2_cell39 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell40 ML2 gate_way2_cell40 GND GND n1 W=1e-6 L=1e-6
mpway2_cell40 ML2 gate_way2_cell40 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell41 ML2 gate_way2_cell41 GND GND n1 W=1e-6 L=1e-6
mpway2_cell41 ML2 gate_way2_cell41 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell42 ML2 gate_way2_cell42 GND GND n1 W=1e-6 L=1e-6
mpway2_cell42 ML2 gate_way2_cell42 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell43 ML2 gate_way2_cell43 GND GND n1 W=1e-6 L=1e-6
mpway2_cell43 ML2 gate_way2_cell43 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell44 ML2 gate_way2_cell44 GND GND n1 W=1e-6 L=1e-6
mpway2_cell44 ML2 gate_way2_cell44 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell45 ML2 gate_way2_cell45 GND GND n1 W=1e-6 L=1e-6
mpway2_cell45 ML2 gate_way2_cell45 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell46 ML2 gate_way2_cell46 GND GND n1 W=1e-6 L=1e-6
mpway2_cell46 ML2 gate_way2_cell46 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell47 ML2 gate_way2_cell47 GND GND n1 W=1e-6 L=1e-6
mpway2_cell47 ML2 gate_way2_cell47 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell48 ML2 gate_way2_cell48 GND GND n1 W=1e-6 L=1e-6
mpway2_cell48 ML2 gate_way2_cell48 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell49 ML2 gate_way2_cell49 GND GND n1 W=1e-6 L=1e-6
mpway2_cell49 ML2 gate_way2_cell49 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell50 ML2 gate_way2_cell50 GND GND n1 W=1e-6 L=1e-6
mpway2_cell50 ML2 gate_way2_cell50 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell51 ML2 gate_way2_cell51 GND GND n1 W=1e-6 L=1e-6
mpway2_cell51 ML2 gate_way2_cell51 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell52 ML2 gate_way2_cell52 GND GND n1 W=1e-6 L=1e-6
mpway2_cell52 ML2 gate_way2_cell52 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell53 ML2 gate_way2_cell53 GND GND n1 W=1e-6 L=1e-6
mpway2_cell53 ML2 gate_way2_cell53 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell54 ML2 gate_way2_cell54 GND GND n1 W=1e-6 L=1e-6
mpway2_cell54 ML2 gate_way2_cell54 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell55 ML2 gate_way2_cell55 GND GND n1 W=1e-6 L=1e-6
mpway2_cell55 ML2 gate_way2_cell55 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell56 ML2 gate_way2_cell56 GND GND n1 W=1e-6 L=1e-6
mpway2_cell56 ML2 gate_way2_cell56 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell57 ML2 gate_way2_cell57 GND GND n1 W=1e-6 L=1e-6
mpway2_cell57 ML2 gate_way2_cell57 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell58 ML2 gate_way2_cell58 GND GND n1 W=1e-6 L=1e-6
mpway2_cell58 ML2 gate_way2_cell58 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell59 ML2 gate_way2_cell59 GND GND n1 W=1e-6 L=1e-6
mpway2_cell59 ML2 gate_way2_cell59 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell60 ML2 gate_way2_cell60 GND GND n1 W=1e-6 L=1e-6
mpway2_cell60 ML2 gate_way2_cell60 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell61 ML2 gate_way2_cell61 GND GND n1 W=1e-6 L=1e-6
mpway2_cell61 ML2 gate_way2_cell61 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell62 ML2 gate_way2_cell62 GND GND n1 W=1e-6 L=1e-6
mpway2_cell62 ML2 gate_way2_cell62 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell63 ML2 gate_way2_cell63 GND GND n1 W=1e-6 L=1e-6
mpway2_cell63 ML2 gate_way2_cell63 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell64 ML2 gate_way2_cell64 GND GND n1 W=1e-6 L=1e-6
mpway2_cell64 ML2 gate_way2_cell64 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell65 ML2 gate_way2_cell65 GND GND n1 W=1e-6 L=1e-6
mpway2_cell65 ML2 gate_way2_cell65 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell66 ML2 gate_way2_cell66 GND GND n1 W=1e-6 L=1e-6
mpway2_cell66 ML2 gate_way2_cell66 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell67 ML2 gate_way2_cell67 GND GND n1 W=1e-6 L=1e-6
mpway2_cell67 ML2 gate_way2_cell67 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell68 ML2 gate_way2_cell68 GND GND n1 W=1e-6 L=1e-6
mpway2_cell68 ML2 gate_way2_cell68 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell69 ML2 gate_way2_cell69 GND GND n1 W=1e-6 L=1e-6
mpway2_cell69 ML2 gate_way2_cell69 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell70 ML2 gate_way2_cell70 GND GND n1 W=1e-6 L=1e-6
mpway2_cell70 ML2 gate_way2_cell70 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell71 ML2 gate_way2_cell71 GND GND n1 W=1e-6 L=1e-6
mpway2_cell71 ML2 gate_way2_cell71 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell72 ML2 gate_way2_cell72 GND GND n1 W=1e-6 L=1e-6
mpway2_cell72 ML2 gate_way2_cell72 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell73 ML2 gate_way2_cell73 GND GND n1 W=1e-6 L=1e-6
mpway2_cell73 ML2 gate_way2_cell73 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell74 ML2 gate_way2_cell74 GND GND n1 W=1e-6 L=1e-6
mpway2_cell74 ML2 gate_way2_cell74 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell75 ML2 gate_way2_cell75 GND GND n1 W=1e-6 L=1e-6
mpway2_cell75 ML2 gate_way2_cell75 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell76 ML2 gate_way2_cell76 GND GND n1 W=1e-6 L=1e-6
mpway2_cell76 ML2 gate_way2_cell76 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell77 ML2 gate_way2_cell77 GND GND n1 W=1e-6 L=1e-6
mpway2_cell77 ML2 gate_way2_cell77 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell78 ML2 gate_way2_cell78 GND GND n1 W=1e-6 L=1e-6
mpway2_cell78 ML2 gate_way2_cell78 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell79 ML2 gate_way2_cell79 GND GND n1 W=1e-6 L=1e-6
mpway2_cell79 ML2 gate_way2_cell79 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell80 ML2 gate_way2_cell80 GND GND n1 W=1e-6 L=1e-6
mpway2_cell80 ML2 gate_way2_cell80 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell81 ML2 gate_way2_cell81 GND GND n1 W=1e-6 L=1e-6
mpway2_cell81 ML2 gate_way2_cell81 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell82 ML2 gate_way2_cell82 GND GND n1 W=1e-6 L=1e-6
mpway2_cell82 ML2 gate_way2_cell82 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell83 ML2 gate_way2_cell83 GND GND n1 W=1e-6 L=1e-6
mpway2_cell83 ML2 gate_way2_cell83 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell84 ML2 gate_way2_cell84 GND GND n1 W=1e-6 L=1e-6
mpway2_cell84 ML2 gate_way2_cell84 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell85 ML2 gate_way2_cell85 GND GND n1 W=1e-6 L=1e-6
mpway2_cell85 ML2 gate_way2_cell85 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell86 ML2 gate_way2_cell86 GND GND n1 W=1e-6 L=1e-6
mpway2_cell86 ML2 gate_way2_cell86 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell87 ML2 gate_way2_cell87 GND GND n1 W=1e-6 L=1e-6
mpway2_cell87 ML2 gate_way2_cell87 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell88 ML2 gate_way2_cell88 GND GND n1 W=1e-6 L=1e-6
mpway2_cell88 ML2 gate_way2_cell88 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell89 ML2 gate_way2_cell89 GND GND n1 W=1e-6 L=1e-6
mpway2_cell89 ML2 gate_way2_cell89 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell90 ML2 gate_way2_cell90 GND GND n1 W=1e-6 L=1e-6
mpway2_cell90 ML2 gate_way2_cell90 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell91 ML2 gate_way2_cell91 GND GND n1 W=1e-6 L=1e-6
mpway2_cell91 ML2 gate_way2_cell91 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell92 ML2 gate_way2_cell92 GND GND n1 W=1e-6 L=1e-6
mpway2_cell92 ML2 gate_way2_cell92 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell93 ML2 gate_way2_cell93 GND GND n1 W=1e-6 L=1e-6
mpway2_cell93 ML2 gate_way2_cell93 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell94 ML2 gate_way2_cell94 GND GND n1 W=1e-6 L=1e-6
mpway2_cell94 ML2 gate_way2_cell94 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell95 ML2 gate_way2_cell95 GND GND n1 W=1e-6 L=1e-6
mpway2_cell95 ML2 gate_way2_cell95 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell96 ML2 gate_way2_cell96 GND GND n1 W=1e-6 L=1e-6
mpway2_cell96 ML2 gate_way2_cell96 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell97 ML2 gate_way2_cell97 GND GND n1 W=1e-6 L=1e-6
mpway2_cell97 ML2 gate_way2_cell97 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell98 ML2 gate_way2_cell98 GND GND n1 W=1e-6 L=1e-6
mpway2_cell98 ML2 gate_way2_cell98 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell99 ML2 gate_way2_cell99 GND GND n1 W=1e-6 L=1e-6
mpway2_cell99 ML2 gate_way2_cell99 GND ML2 p1 W=2.4e-6 L=1e-6
mnway3_cell0 ML3 gate_way3_cell0 GND GND n1 W=1e-6 L=1e-6
mpway3_cell0 ML3 gate_way3_cell0 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell1 ML3 gate_way3_cell1 GND GND n1 W=1e-6 L=1e-6
mpway3_cell1 ML3 gate_way3_cell1 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell2 ML3 gate_way3_cell2 GND GND n1 W=1e-6 L=1e-6
mpway3_cell2 ML3 gate_way3_cell2 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell3 ML3 gate_way3_cell3 GND GND n1 W=1e-6 L=1e-6
mpway3_cell3 ML3 gate_way3_cell3 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell4 ML3 gate_way3_cell4 GND GND n1 W=1e-6 L=1e-6
mpway3_cell4 ML3 gate_way3_cell4 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell5 ML3 gate_way3_cell5 GND GND n1 W=1e-6 L=1e-6
mpway3_cell5 ML3 gate_way3_cell5 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell6 ML3 gate_way3_cell6 GND GND n1 W=1e-6 L=1e-6
mpway3_cell6 ML3 gate_way3_cell6 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell7 ML3 gate_way3_cell7 GND GND n1 W=1e-6 L=1e-6
mpway3_cell7 ML3 gate_way3_cell7 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell8 ML3 gate_way3_cell8 GND GND n1 W=1e-6 L=1e-6
mpway3_cell8 ML3 gate_way3_cell8 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell9 ML3 gate_way3_cell9 GND GND n1 W=1e-6 L=1e-6
mpway3_cell9 ML3 gate_way3_cell9 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell10 ML3 gate_way3_cell10 GND GND n1 W=1e-6 L=1e-6
mpway3_cell10 ML3 gate_way3_cell10 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell11 ML3 gate_way3_cell11 GND GND n1 W=1e-6 L=1e-6
mpway3_cell11 ML3 gate_way3_cell11 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell12 ML3 gate_way3_cell12 GND GND n1 W=1e-6 L=1e-6
mpway3_cell12 ML3 gate_way3_cell12 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell13 ML3 gate_way3_cell13 GND GND n1 W=1e-6 L=1e-6
mpway3_cell13 ML3 gate_way3_cell13 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell14 ML3 gate_way3_cell14 GND GND n1 W=1e-6 L=1e-6
mpway3_cell14 ML3 gate_way3_cell14 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell15 ML3 gate_way3_cell15 GND GND n1 W=1e-6 L=1e-6
mpway3_cell15 ML3 gate_way3_cell15 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell16 ML3 gate_way3_cell16 GND GND n1 W=1e-6 L=1e-6
mpway3_cell16 ML3 gate_way3_cell16 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell17 ML3 gate_way3_cell17 GND GND n1 W=1e-6 L=1e-6
mpway3_cell17 ML3 gate_way3_cell17 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell18 ML3 gate_way3_cell18 GND GND n1 W=1e-6 L=1e-6
mpway3_cell18 ML3 gate_way3_cell18 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell19 ML3 gate_way3_cell19 GND GND n1 W=1e-6 L=1e-6
mpway3_cell19 ML3 gate_way3_cell19 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell20 ML3 gate_way3_cell20 GND GND n1 W=1e-6 L=1e-6
mpway3_cell20 ML3 gate_way3_cell20 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell21 ML3 gate_way3_cell21 GND GND n1 W=1e-6 L=1e-6
mpway3_cell21 ML3 gate_way3_cell21 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell22 ML3 gate_way3_cell22 GND GND n1 W=1e-6 L=1e-6
mpway3_cell22 ML3 gate_way3_cell22 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell23 ML3 gate_way3_cell23 GND GND n1 W=1e-6 L=1e-6
mpway3_cell23 ML3 gate_way3_cell23 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell24 ML3 gate_way3_cell24 GND GND n1 W=1e-6 L=1e-6
mpway3_cell24 ML3 gate_way3_cell24 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell25 ML3 gate_way3_cell25 GND GND n1 W=1e-6 L=1e-6
mpway3_cell25 ML3 gate_way3_cell25 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell26 ML3 gate_way3_cell26 GND GND n1 W=1e-6 L=1e-6
mpway3_cell26 ML3 gate_way3_cell26 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell27 ML3 gate_way3_cell27 GND GND n1 W=1e-6 L=1e-6
mpway3_cell27 ML3 gate_way3_cell27 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell28 ML3 gate_way3_cell28 GND GND n1 W=1e-6 L=1e-6
mpway3_cell28 ML3 gate_way3_cell28 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell29 ML3 gate_way3_cell29 GND GND n1 W=1e-6 L=1e-6
mpway3_cell29 ML3 gate_way3_cell29 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell30 ML3 gate_way3_cell30 GND GND n1 W=1e-6 L=1e-6
mpway3_cell30 ML3 gate_way3_cell30 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell31 ML3 gate_way3_cell31 GND GND n1 W=1e-6 L=1e-6
mpway3_cell31 ML3 gate_way3_cell31 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell32 ML3 gate_way3_cell32 GND GND n1 W=1e-6 L=1e-6
mpway3_cell32 ML3 gate_way3_cell32 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell33 ML3 gate_way3_cell33 GND GND n1 W=1e-6 L=1e-6
mpway3_cell33 ML3 gate_way3_cell33 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell34 ML3 gate_way3_cell34 GND GND n1 W=1e-6 L=1e-6
mpway3_cell34 ML3 gate_way3_cell34 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell35 ML3 gate_way3_cell35 GND GND n1 W=1e-6 L=1e-6
mpway3_cell35 ML3 gate_way3_cell35 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell36 ML3 gate_way3_cell36 GND GND n1 W=1e-6 L=1e-6
mpway3_cell36 ML3 gate_way3_cell36 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell37 ML3 gate_way3_cell37 GND GND n1 W=1e-6 L=1e-6
mpway3_cell37 ML3 gate_way3_cell37 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell38 ML3 gate_way3_cell38 GND GND n1 W=1e-6 L=1e-6
mpway3_cell38 ML3 gate_way3_cell38 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell39 ML3 gate_way3_cell39 GND GND n1 W=1e-6 L=1e-6
mpway3_cell39 ML3 gate_way3_cell39 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell40 ML3 gate_way3_cell40 GND GND n1 W=1e-6 L=1e-6
mpway3_cell40 ML3 gate_way3_cell40 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell41 ML3 gate_way3_cell41 GND GND n1 W=1e-6 L=1e-6
mpway3_cell41 ML3 gate_way3_cell41 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell42 ML3 gate_way3_cell42 GND GND n1 W=1e-6 L=1e-6
mpway3_cell42 ML3 gate_way3_cell42 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell43 ML3 gate_way3_cell43 GND GND n1 W=1e-6 L=1e-6
mpway3_cell43 ML3 gate_way3_cell43 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell44 ML3 gate_way3_cell44 GND GND n1 W=1e-6 L=1e-6
mpway3_cell44 ML3 gate_way3_cell44 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell45 ML3 gate_way3_cell45 GND GND n1 W=1e-6 L=1e-6
mpway3_cell45 ML3 gate_way3_cell45 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell46 ML3 gate_way3_cell46 GND GND n1 W=1e-6 L=1e-6
mpway3_cell46 ML3 gate_way3_cell46 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell47 ML3 gate_way3_cell47 GND GND n1 W=1e-6 L=1e-6
mpway3_cell47 ML3 gate_way3_cell47 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell48 ML3 gate_way3_cell48 GND GND n1 W=1e-6 L=1e-6
mpway3_cell48 ML3 gate_way3_cell48 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell49 ML3 gate_way3_cell49 GND GND n1 W=1e-6 L=1e-6
mpway3_cell49 ML3 gate_way3_cell49 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell50 ML3 gate_way3_cell50 GND GND n1 W=1e-6 L=1e-6
mpway3_cell50 ML3 gate_way3_cell50 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell51 ML3 gate_way3_cell51 GND GND n1 W=1e-6 L=1e-6
mpway3_cell51 ML3 gate_way3_cell51 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell52 ML3 gate_way3_cell52 GND GND n1 W=1e-6 L=1e-6
mpway3_cell52 ML3 gate_way3_cell52 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell53 ML3 gate_way3_cell53 GND GND n1 W=1e-6 L=1e-6
mpway3_cell53 ML3 gate_way3_cell53 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell54 ML3 gate_way3_cell54 GND GND n1 W=1e-6 L=1e-6
mpway3_cell54 ML3 gate_way3_cell54 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell55 ML3 gate_way3_cell55 GND GND n1 W=1e-6 L=1e-6
mpway3_cell55 ML3 gate_way3_cell55 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell56 ML3 gate_way3_cell56 GND GND n1 W=1e-6 L=1e-6
mpway3_cell56 ML3 gate_way3_cell56 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell57 ML3 gate_way3_cell57 GND GND n1 W=1e-6 L=1e-6
mpway3_cell57 ML3 gate_way3_cell57 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell58 ML3 gate_way3_cell58 GND GND n1 W=1e-6 L=1e-6
mpway3_cell58 ML3 gate_way3_cell58 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell59 ML3 gate_way3_cell59 GND GND n1 W=1e-6 L=1e-6
mpway3_cell59 ML3 gate_way3_cell59 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell60 ML3 gate_way3_cell60 GND GND n1 W=1e-6 L=1e-6
mpway3_cell60 ML3 gate_way3_cell60 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell61 ML3 gate_way3_cell61 GND GND n1 W=1e-6 L=1e-6
mpway3_cell61 ML3 gate_way3_cell61 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell62 ML3 gate_way3_cell62 GND GND n1 W=1e-6 L=1e-6
mpway3_cell62 ML3 gate_way3_cell62 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell63 ML3 gate_way3_cell63 GND GND n1 W=1e-6 L=1e-6
mpway3_cell63 ML3 gate_way3_cell63 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell64 ML3 gate_way3_cell64 GND GND n1 W=1e-6 L=1e-6
mpway3_cell64 ML3 gate_way3_cell64 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell65 ML3 gate_way3_cell65 GND GND n1 W=1e-6 L=1e-6
mpway3_cell65 ML3 gate_way3_cell65 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell66 ML3 gate_way3_cell66 GND GND n1 W=1e-6 L=1e-6
mpway3_cell66 ML3 gate_way3_cell66 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell67 ML3 gate_way3_cell67 GND GND n1 W=1e-6 L=1e-6
mpway3_cell67 ML3 gate_way3_cell67 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell68 ML3 gate_way3_cell68 GND GND n1 W=1e-6 L=1e-6
mpway3_cell68 ML3 gate_way3_cell68 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell69 ML3 gate_way3_cell69 GND GND n1 W=1e-6 L=1e-6
mpway3_cell69 ML3 gate_way3_cell69 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell70 ML3 gate_way3_cell70 GND GND n1 W=1e-6 L=1e-6
mpway3_cell70 ML3 gate_way3_cell70 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell71 ML3 gate_way3_cell71 GND GND n1 W=1e-6 L=1e-6
mpway3_cell71 ML3 gate_way3_cell71 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell72 ML3 gate_way3_cell72 GND GND n1 W=1e-6 L=1e-6
mpway3_cell72 ML3 gate_way3_cell72 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell73 ML3 gate_way3_cell73 GND GND n1 W=1e-6 L=1e-6
mpway3_cell73 ML3 gate_way3_cell73 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell74 ML3 gate_way3_cell74 GND GND n1 W=1e-6 L=1e-6
mpway3_cell74 ML3 gate_way3_cell74 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell75 ML3 gate_way3_cell75 GND GND n1 W=1e-6 L=1e-6
mpway3_cell75 ML3 gate_way3_cell75 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell76 ML3 gate_way3_cell76 GND GND n1 W=1e-6 L=1e-6
mpway3_cell76 ML3 gate_way3_cell76 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell77 ML3 gate_way3_cell77 GND GND n1 W=1e-6 L=1e-6
mpway3_cell77 ML3 gate_way3_cell77 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell78 ML3 gate_way3_cell78 GND GND n1 W=1e-6 L=1e-6
mpway3_cell78 ML3 gate_way3_cell78 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell79 ML3 gate_way3_cell79 GND GND n1 W=1e-6 L=1e-6
mpway3_cell79 ML3 gate_way3_cell79 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell80 ML3 gate_way3_cell80 GND GND n1 W=1e-6 L=1e-6
mpway3_cell80 ML3 gate_way3_cell80 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell81 ML3 gate_way3_cell81 GND GND n1 W=1e-6 L=1e-6
mpway3_cell81 ML3 gate_way3_cell81 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell82 ML3 gate_way3_cell82 GND GND n1 W=1e-6 L=1e-6
mpway3_cell82 ML3 gate_way3_cell82 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell83 ML3 gate_way3_cell83 GND GND n1 W=1e-6 L=1e-6
mpway3_cell83 ML3 gate_way3_cell83 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell84 ML3 gate_way3_cell84 GND GND n1 W=1e-6 L=1e-6
mpway3_cell84 ML3 gate_way3_cell84 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell85 ML3 gate_way3_cell85 GND GND n1 W=1e-6 L=1e-6
mpway3_cell85 ML3 gate_way3_cell85 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell86 ML3 gate_way3_cell86 GND GND n1 W=1e-6 L=1e-6
mpway3_cell86 ML3 gate_way3_cell86 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell87 ML3 gate_way3_cell87 GND GND n1 W=1e-6 L=1e-6
mpway3_cell87 ML3 gate_way3_cell87 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell88 ML3 gate_way3_cell88 GND GND n1 W=1e-6 L=1e-6
mpway3_cell88 ML3 gate_way3_cell88 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell89 ML3 gate_way3_cell89 GND GND n1 W=1e-6 L=1e-6
mpway3_cell89 ML3 gate_way3_cell89 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell90 ML3 gate_way3_cell90 GND GND n1 W=1e-6 L=1e-6
mpway3_cell90 ML3 gate_way3_cell90 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell91 ML3 gate_way3_cell91 GND GND n1 W=1e-6 L=1e-6
mpway3_cell91 ML3 gate_way3_cell91 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell92 ML3 gate_way3_cell92 GND GND n1 W=1e-6 L=1e-6
mpway3_cell92 ML3 gate_way3_cell92 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell93 ML3 gate_way3_cell93 GND GND n1 W=1e-6 L=1e-6
mpway3_cell93 ML3 gate_way3_cell93 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell94 ML3 gate_way3_cell94 GND GND n1 W=1e-6 L=1e-6
mpway3_cell94 ML3 gate_way3_cell94 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell95 ML3 gate_way3_cell95 GND GND n1 W=1e-6 L=1e-6
mpway3_cell95 ML3 gate_way3_cell95 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell96 ML3 gate_way3_cell96 GND GND n1 W=1e-6 L=1e-6
mpway3_cell96 ML3 gate_way3_cell96 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell97 ML3 gate_way3_cell97 GND GND n1 W=1e-6 L=1e-6
mpway3_cell97 ML3 gate_way3_cell97 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell98 ML3 gate_way3_cell98 GND GND n1 W=1e-6 L=1e-6
mpway3_cell98 ML3 gate_way3_cell98 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell99 ML3 gate_way3_cell99 GND GND n1 W=1e-6 L=1e-6
mpway3_cell99 ML3 gate_way3_cell99 GND ML3 p1 W=2.4e-6 L=1e-6
mnway4_cell0 ML4 gate_way4_cell0 GND GND n1 W=1e-6 L=1e-6
mpway4_cell0 ML4 gate_way4_cell0 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell1 ML4 gate_way4_cell1 GND GND n1 W=1e-6 L=1e-6
mpway4_cell1 ML4 gate_way4_cell1 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell2 ML4 gate_way4_cell2 GND GND n1 W=1e-6 L=1e-6
mpway4_cell2 ML4 gate_way4_cell2 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell3 ML4 gate_way4_cell3 GND GND n1 W=1e-6 L=1e-6
mpway4_cell3 ML4 gate_way4_cell3 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell4 ML4 gate_way4_cell4 GND GND n1 W=1e-6 L=1e-6
mpway4_cell4 ML4 gate_way4_cell4 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell5 ML4 gate_way4_cell5 GND GND n1 W=1e-6 L=1e-6
mpway4_cell5 ML4 gate_way4_cell5 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell6 ML4 gate_way4_cell6 GND GND n1 W=1e-6 L=1e-6
mpway4_cell6 ML4 gate_way4_cell6 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell7 ML4 gate_way4_cell7 GND GND n1 W=1e-6 L=1e-6
mpway4_cell7 ML4 gate_way4_cell7 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell8 ML4 gate_way4_cell8 GND GND n1 W=1e-6 L=1e-6
mpway4_cell8 ML4 gate_way4_cell8 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell9 ML4 gate_way4_cell9 GND GND n1 W=1e-6 L=1e-6
mpway4_cell9 ML4 gate_way4_cell9 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell10 ML4 gate_way4_cell10 GND GND n1 W=1e-6 L=1e-6
mpway4_cell10 ML4 gate_way4_cell10 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell11 ML4 gate_way4_cell11 GND GND n1 W=1e-6 L=1e-6
mpway4_cell11 ML4 gate_way4_cell11 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell12 ML4 gate_way4_cell12 GND GND n1 W=1e-6 L=1e-6
mpway4_cell12 ML4 gate_way4_cell12 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell13 ML4 gate_way4_cell13 GND GND n1 W=1e-6 L=1e-6
mpway4_cell13 ML4 gate_way4_cell13 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell14 ML4 gate_way4_cell14 GND GND n1 W=1e-6 L=1e-6
mpway4_cell14 ML4 gate_way4_cell14 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell15 ML4 gate_way4_cell15 GND GND n1 W=1e-6 L=1e-6
mpway4_cell15 ML4 gate_way4_cell15 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell16 ML4 gate_way4_cell16 GND GND n1 W=1e-6 L=1e-6
mpway4_cell16 ML4 gate_way4_cell16 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell17 ML4 gate_way4_cell17 GND GND n1 W=1e-6 L=1e-6
mpway4_cell17 ML4 gate_way4_cell17 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell18 ML4 gate_way4_cell18 GND GND n1 W=1e-6 L=1e-6
mpway4_cell18 ML4 gate_way4_cell18 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell19 ML4 gate_way4_cell19 GND GND n1 W=1e-6 L=1e-6
mpway4_cell19 ML4 gate_way4_cell19 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell20 ML4 gate_way4_cell20 GND GND n1 W=1e-6 L=1e-6
mpway4_cell20 ML4 gate_way4_cell20 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell21 ML4 gate_way4_cell21 GND GND n1 W=1e-6 L=1e-6
mpway4_cell21 ML4 gate_way4_cell21 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell22 ML4 gate_way4_cell22 GND GND n1 W=1e-6 L=1e-6
mpway4_cell22 ML4 gate_way4_cell22 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell23 ML4 gate_way4_cell23 GND GND n1 W=1e-6 L=1e-6
mpway4_cell23 ML4 gate_way4_cell23 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell24 ML4 gate_way4_cell24 GND GND n1 W=1e-6 L=1e-6
mpway4_cell24 ML4 gate_way4_cell24 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell25 ML4 gate_way4_cell25 GND GND n1 W=1e-6 L=1e-6
mpway4_cell25 ML4 gate_way4_cell25 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell26 ML4 gate_way4_cell26 GND GND n1 W=1e-6 L=1e-6
mpway4_cell26 ML4 gate_way4_cell26 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell27 ML4 gate_way4_cell27 GND GND n1 W=1e-6 L=1e-6
mpway4_cell27 ML4 gate_way4_cell27 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell28 ML4 gate_way4_cell28 GND GND n1 W=1e-6 L=1e-6
mpway4_cell28 ML4 gate_way4_cell28 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell29 ML4 gate_way4_cell29 GND GND n1 W=1e-6 L=1e-6
mpway4_cell29 ML4 gate_way4_cell29 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell30 ML4 gate_way4_cell30 GND GND n1 W=1e-6 L=1e-6
mpway4_cell30 ML4 gate_way4_cell30 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell31 ML4 gate_way4_cell31 GND GND n1 W=1e-6 L=1e-6
mpway4_cell31 ML4 gate_way4_cell31 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell32 ML4 gate_way4_cell32 GND GND n1 W=1e-6 L=1e-6
mpway4_cell32 ML4 gate_way4_cell32 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell33 ML4 gate_way4_cell33 GND GND n1 W=1e-6 L=1e-6
mpway4_cell33 ML4 gate_way4_cell33 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell34 ML4 gate_way4_cell34 GND GND n1 W=1e-6 L=1e-6
mpway4_cell34 ML4 gate_way4_cell34 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell35 ML4 gate_way4_cell35 GND GND n1 W=1e-6 L=1e-6
mpway4_cell35 ML4 gate_way4_cell35 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell36 ML4 gate_way4_cell36 GND GND n1 W=1e-6 L=1e-6
mpway4_cell36 ML4 gate_way4_cell36 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell37 ML4 gate_way4_cell37 GND GND n1 W=1e-6 L=1e-6
mpway4_cell37 ML4 gate_way4_cell37 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell38 ML4 gate_way4_cell38 GND GND n1 W=1e-6 L=1e-6
mpway4_cell38 ML4 gate_way4_cell38 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell39 ML4 gate_way4_cell39 GND GND n1 W=1e-6 L=1e-6
mpway4_cell39 ML4 gate_way4_cell39 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell40 ML4 gate_way4_cell40 GND GND n1 W=1e-6 L=1e-6
mpway4_cell40 ML4 gate_way4_cell40 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell41 ML4 gate_way4_cell41 GND GND n1 W=1e-6 L=1e-6
mpway4_cell41 ML4 gate_way4_cell41 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell42 ML4 gate_way4_cell42 GND GND n1 W=1e-6 L=1e-6
mpway4_cell42 ML4 gate_way4_cell42 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell43 ML4 gate_way4_cell43 GND GND n1 W=1e-6 L=1e-6
mpway4_cell43 ML4 gate_way4_cell43 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell44 ML4 gate_way4_cell44 GND GND n1 W=1e-6 L=1e-6
mpway4_cell44 ML4 gate_way4_cell44 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell45 ML4 gate_way4_cell45 GND GND n1 W=1e-6 L=1e-6
mpway4_cell45 ML4 gate_way4_cell45 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell46 ML4 gate_way4_cell46 GND GND n1 W=1e-6 L=1e-6
mpway4_cell46 ML4 gate_way4_cell46 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell47 ML4 gate_way4_cell47 GND GND n1 W=1e-6 L=1e-6
mpway4_cell47 ML4 gate_way4_cell47 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell48 ML4 gate_way4_cell48 GND GND n1 W=1e-6 L=1e-6
mpway4_cell48 ML4 gate_way4_cell48 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell49 ML4 gate_way4_cell49 GND GND n1 W=1e-6 L=1e-6
mpway4_cell49 ML4 gate_way4_cell49 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell50 ML4 gate_way4_cell50 GND GND n1 W=1e-6 L=1e-6
mpway4_cell50 ML4 gate_way4_cell50 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell51 ML4 gate_way4_cell51 GND GND n1 W=1e-6 L=1e-6
mpway4_cell51 ML4 gate_way4_cell51 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell52 ML4 gate_way4_cell52 GND GND n1 W=1e-6 L=1e-6
mpway4_cell52 ML4 gate_way4_cell52 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell53 ML4 gate_way4_cell53 GND GND n1 W=1e-6 L=1e-6
mpway4_cell53 ML4 gate_way4_cell53 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell54 ML4 gate_way4_cell54 GND GND n1 W=1e-6 L=1e-6
mpway4_cell54 ML4 gate_way4_cell54 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell55 ML4 gate_way4_cell55 GND GND n1 W=1e-6 L=1e-6
mpway4_cell55 ML4 gate_way4_cell55 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell56 ML4 gate_way4_cell56 GND GND n1 W=1e-6 L=1e-6
mpway4_cell56 ML4 gate_way4_cell56 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell57 ML4 gate_way4_cell57 GND GND n1 W=1e-6 L=1e-6
mpway4_cell57 ML4 gate_way4_cell57 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell58 ML4 gate_way4_cell58 GND GND n1 W=1e-6 L=1e-6
mpway4_cell58 ML4 gate_way4_cell58 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell59 ML4 gate_way4_cell59 GND GND n1 W=1e-6 L=1e-6
mpway4_cell59 ML4 gate_way4_cell59 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell60 ML4 gate_way4_cell60 GND GND n1 W=1e-6 L=1e-6
mpway4_cell60 ML4 gate_way4_cell60 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell61 ML4 gate_way4_cell61 GND GND n1 W=1e-6 L=1e-6
mpway4_cell61 ML4 gate_way4_cell61 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell62 ML4 gate_way4_cell62 GND GND n1 W=1e-6 L=1e-6
mpway4_cell62 ML4 gate_way4_cell62 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell63 ML4 gate_way4_cell63 GND GND n1 W=1e-6 L=1e-6
mpway4_cell63 ML4 gate_way4_cell63 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell64 ML4 gate_way4_cell64 GND GND n1 W=1e-6 L=1e-6
mpway4_cell64 ML4 gate_way4_cell64 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell65 ML4 gate_way4_cell65 GND GND n1 W=1e-6 L=1e-6
mpway4_cell65 ML4 gate_way4_cell65 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell66 ML4 gate_way4_cell66 GND GND n1 W=1e-6 L=1e-6
mpway4_cell66 ML4 gate_way4_cell66 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell67 ML4 gate_way4_cell67 GND GND n1 W=1e-6 L=1e-6
mpway4_cell67 ML4 gate_way4_cell67 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell68 ML4 gate_way4_cell68 GND GND n1 W=1e-6 L=1e-6
mpway4_cell68 ML4 gate_way4_cell68 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell69 ML4 gate_way4_cell69 GND GND n1 W=1e-6 L=1e-6
mpway4_cell69 ML4 gate_way4_cell69 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell70 ML4 gate_way4_cell70 GND GND n1 W=1e-6 L=1e-6
mpway4_cell70 ML4 gate_way4_cell70 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell71 ML4 gate_way4_cell71 GND GND n1 W=1e-6 L=1e-6
mpway4_cell71 ML4 gate_way4_cell71 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell72 ML4 gate_way4_cell72 GND GND n1 W=1e-6 L=1e-6
mpway4_cell72 ML4 gate_way4_cell72 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell73 ML4 gate_way4_cell73 GND GND n1 W=1e-6 L=1e-6
mpway4_cell73 ML4 gate_way4_cell73 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell74 ML4 gate_way4_cell74 GND GND n1 W=1e-6 L=1e-6
mpway4_cell74 ML4 gate_way4_cell74 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell75 ML4 gate_way4_cell75 GND GND n1 W=1e-6 L=1e-6
mpway4_cell75 ML4 gate_way4_cell75 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell76 ML4 gate_way4_cell76 GND GND n1 W=1e-6 L=1e-6
mpway4_cell76 ML4 gate_way4_cell76 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell77 ML4 gate_way4_cell77 GND GND n1 W=1e-6 L=1e-6
mpway4_cell77 ML4 gate_way4_cell77 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell78 ML4 gate_way4_cell78 GND GND n1 W=1e-6 L=1e-6
mpway4_cell78 ML4 gate_way4_cell78 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell79 ML4 gate_way4_cell79 GND GND n1 W=1e-6 L=1e-6
mpway4_cell79 ML4 gate_way4_cell79 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell80 ML4 gate_way4_cell80 GND GND n1 W=1e-6 L=1e-6
mpway4_cell80 ML4 gate_way4_cell80 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell81 ML4 gate_way4_cell81 GND GND n1 W=1e-6 L=1e-6
mpway4_cell81 ML4 gate_way4_cell81 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell82 ML4 gate_way4_cell82 GND GND n1 W=1e-6 L=1e-6
mpway4_cell82 ML4 gate_way4_cell82 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell83 ML4 gate_way4_cell83 GND GND n1 W=1e-6 L=1e-6
mpway4_cell83 ML4 gate_way4_cell83 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell84 ML4 gate_way4_cell84 GND GND n1 W=1e-6 L=1e-6
mpway4_cell84 ML4 gate_way4_cell84 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell85 ML4 gate_way4_cell85 GND GND n1 W=1e-6 L=1e-6
mpway4_cell85 ML4 gate_way4_cell85 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell86 ML4 gate_way4_cell86 GND GND n1 W=1e-6 L=1e-6
mpway4_cell86 ML4 gate_way4_cell86 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell87 ML4 gate_way4_cell87 GND GND n1 W=1e-6 L=1e-6
mpway4_cell87 ML4 gate_way4_cell87 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell88 ML4 gate_way4_cell88 GND GND n1 W=1e-6 L=1e-6
mpway4_cell88 ML4 gate_way4_cell88 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell89 ML4 gate_way4_cell89 GND GND n1 W=1e-6 L=1e-6
mpway4_cell89 ML4 gate_way4_cell89 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell90 ML4 gate_way4_cell90 GND GND n1 W=1e-6 L=1e-6
mpway4_cell90 ML4 gate_way4_cell90 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell91 ML4 gate_way4_cell91 GND GND n1 W=1e-6 L=1e-6
mpway4_cell91 ML4 gate_way4_cell91 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell92 ML4 gate_way4_cell92 GND GND n1 W=1e-6 L=1e-6
mpway4_cell92 ML4 gate_way4_cell92 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell93 ML4 gate_way4_cell93 GND GND n1 W=1e-6 L=1e-6
mpway4_cell93 ML4 gate_way4_cell93 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell94 ML4 gate_way4_cell94 GND GND n1 W=1e-6 L=1e-6
mpway4_cell94 ML4 gate_way4_cell94 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell95 ML4 gate_way4_cell95 GND GND n1 W=1e-6 L=1e-6
mpway4_cell95 ML4 gate_way4_cell95 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell96 ML4 gate_way4_cell96 GND GND n1 W=1e-6 L=1e-6
mpway4_cell96 ML4 gate_way4_cell96 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell97 ML4 gate_way4_cell97 GND GND n1 W=1e-6 L=1e-6
mpway4_cell97 ML4 gate_way4_cell97 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell98 ML4 gate_way4_cell98 GND GND n1 W=1e-6 L=1e-6
mpway4_cell98 ML4 gate_way4_cell98 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell99 ML4 gate_way4_cell99 GND GND n1 W=1e-6 L=1e-6
mpway4_cell99 ML4 gate_way4_cell99 GND ML4 p1 W=2.4e-6 L=1e-6
