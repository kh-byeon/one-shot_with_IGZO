*editor khb
mnway0_cell0 ML0 gate_way0_cell0 GND GND n1 W=1e-6 L=1e-6
mpway0_cell0 ML0 gate_way0_cell0 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell1 ML0 gate_way0_cell1 GND GND n1 W=1e-6 L=1e-6
mpway0_cell1 ML0 gate_way0_cell1 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell2 ML0 gate_way0_cell2 GND GND n1 W=1e-6 L=1e-6
mpway0_cell2 ML0 gate_way0_cell2 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell3 ML0 gate_way0_cell3 GND GND n1 W=1e-6 L=1e-6
mpway0_cell3 ML0 gate_way0_cell3 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell4 ML0 gate_way0_cell4 GND GND n1 W=1e-6 L=1e-6
mpway0_cell4 ML0 gate_way0_cell4 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell5 ML0 gate_way0_cell5 GND GND n1 W=1e-6 L=1e-6
mpway0_cell5 ML0 gate_way0_cell5 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell6 ML0 gate_way0_cell6 GND GND n1 W=1e-6 L=1e-6
mpway0_cell6 ML0 gate_way0_cell6 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell7 ML0 gate_way0_cell7 GND GND n1 W=1e-6 L=1e-6
mpway0_cell7 ML0 gate_way0_cell7 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell8 ML0 gate_way0_cell8 GND GND n1 W=1e-6 L=1e-6
mpway0_cell8 ML0 gate_way0_cell8 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell9 ML0 gate_way0_cell9 GND GND n1 W=1e-6 L=1e-6
mpway0_cell9 ML0 gate_way0_cell9 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell10 ML0 gate_way0_cell10 GND GND n1 W=1e-6 L=1e-6
mpway0_cell10 ML0 gate_way0_cell10 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell11 ML0 gate_way0_cell11 GND GND n1 W=1e-6 L=1e-6
mpway0_cell11 ML0 gate_way0_cell11 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell12 ML0 gate_way0_cell12 GND GND n1 W=1e-6 L=1e-6
mpway0_cell12 ML0 gate_way0_cell12 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell13 ML0 gate_way0_cell13 GND GND n1 W=1e-6 L=1e-6
mpway0_cell13 ML0 gate_way0_cell13 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell14 ML0 gate_way0_cell14 GND GND n1 W=1e-6 L=1e-6
mpway0_cell14 ML0 gate_way0_cell14 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell15 ML0 gate_way0_cell15 GND GND n1 W=1e-6 L=1e-6
mpway0_cell15 ML0 gate_way0_cell15 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell16 ML0 gate_way0_cell16 GND GND n1 W=1e-6 L=1e-6
mpway0_cell16 ML0 gate_way0_cell16 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell17 ML0 gate_way0_cell17 GND GND n1 W=1e-6 L=1e-6
mpway0_cell17 ML0 gate_way0_cell17 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell18 ML0 gate_way0_cell18 GND GND n1 W=1e-6 L=1e-6
mpway0_cell18 ML0 gate_way0_cell18 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell19 ML0 gate_way0_cell19 GND GND n1 W=1e-6 L=1e-6
mpway0_cell19 ML0 gate_way0_cell19 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell20 ML0 gate_way0_cell20 GND GND n1 W=1e-6 L=1e-6
mpway0_cell20 ML0 gate_way0_cell20 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell21 ML0 gate_way0_cell21 GND GND n1 W=1e-6 L=1e-6
mpway0_cell21 ML0 gate_way0_cell21 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell22 ML0 gate_way0_cell22 GND GND n1 W=1e-6 L=1e-6
mpway0_cell22 ML0 gate_way0_cell22 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell23 ML0 gate_way0_cell23 GND GND n1 W=1e-6 L=1e-6
mpway0_cell23 ML0 gate_way0_cell23 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell24 ML0 gate_way0_cell24 GND GND n1 W=1e-6 L=1e-6
mpway0_cell24 ML0 gate_way0_cell24 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell25 ML0 gate_way0_cell25 GND GND n1 W=1e-6 L=1e-6
mpway0_cell25 ML0 gate_way0_cell25 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell26 ML0 gate_way0_cell26 GND GND n1 W=1e-6 L=1e-6
mpway0_cell26 ML0 gate_way0_cell26 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell27 ML0 gate_way0_cell27 GND GND n1 W=1e-6 L=1e-6
mpway0_cell27 ML0 gate_way0_cell27 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell28 ML0 gate_way0_cell28 GND GND n1 W=1e-6 L=1e-6
mpway0_cell28 ML0 gate_way0_cell28 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell29 ML0 gate_way0_cell29 GND GND n1 W=1e-6 L=1e-6
mpway0_cell29 ML0 gate_way0_cell29 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell30 ML0 gate_way0_cell30 GND GND n1 W=1e-6 L=1e-6
mpway0_cell30 ML0 gate_way0_cell30 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell31 ML0 gate_way0_cell31 GND GND n1 W=1e-6 L=1e-6
mpway0_cell31 ML0 gate_way0_cell31 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell32 ML0 gate_way0_cell32 GND GND n1 W=1e-6 L=1e-6
mpway0_cell32 ML0 gate_way0_cell32 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell33 ML0 gate_way0_cell33 GND GND n1 W=1e-6 L=1e-6
mpway0_cell33 ML0 gate_way0_cell33 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell34 ML0 gate_way0_cell34 GND GND n1 W=1e-6 L=1e-6
mpway0_cell34 ML0 gate_way0_cell34 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell35 ML0 gate_way0_cell35 GND GND n1 W=1e-6 L=1e-6
mpway0_cell35 ML0 gate_way0_cell35 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell36 ML0 gate_way0_cell36 GND GND n1 W=1e-6 L=1e-6
mpway0_cell36 ML0 gate_way0_cell36 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell37 ML0 gate_way0_cell37 GND GND n1 W=1e-6 L=1e-6
mpway0_cell37 ML0 gate_way0_cell37 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell38 ML0 gate_way0_cell38 GND GND n1 W=1e-6 L=1e-6
mpway0_cell38 ML0 gate_way0_cell38 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell39 ML0 gate_way0_cell39 GND GND n1 W=1e-6 L=1e-6
mpway0_cell39 ML0 gate_way0_cell39 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell40 ML0 gate_way0_cell40 GND GND n1 W=1e-6 L=1e-6
mpway0_cell40 ML0 gate_way0_cell40 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell41 ML0 gate_way0_cell41 GND GND n1 W=1e-6 L=1e-6
mpway0_cell41 ML0 gate_way0_cell41 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell42 ML0 gate_way0_cell42 GND GND n1 W=1e-6 L=1e-6
mpway0_cell42 ML0 gate_way0_cell42 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell43 ML0 gate_way0_cell43 GND GND n1 W=1e-6 L=1e-6
mpway0_cell43 ML0 gate_way0_cell43 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell44 ML0 gate_way0_cell44 GND GND n1 W=1e-6 L=1e-6
mpway0_cell44 ML0 gate_way0_cell44 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell45 ML0 gate_way0_cell45 GND GND n1 W=1e-6 L=1e-6
mpway0_cell45 ML0 gate_way0_cell45 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell46 ML0 gate_way0_cell46 GND GND n1 W=1e-6 L=1e-6
mpway0_cell46 ML0 gate_way0_cell46 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell47 ML0 gate_way0_cell47 GND GND n1 W=1e-6 L=1e-6
mpway0_cell47 ML0 gate_way0_cell47 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell48 ML0 gate_way0_cell48 GND GND n1 W=1e-6 L=1e-6
mpway0_cell48 ML0 gate_way0_cell48 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell49 ML0 gate_way0_cell49 GND GND n1 W=1e-6 L=1e-6
mpway0_cell49 ML0 gate_way0_cell49 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell50 ML0 gate_way0_cell50 GND GND n1 W=1e-6 L=1e-6
mpway0_cell50 ML0 gate_way0_cell50 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell51 ML0 gate_way0_cell51 GND GND n1 W=1e-6 L=1e-6
mpway0_cell51 ML0 gate_way0_cell51 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell52 ML0 gate_way0_cell52 GND GND n1 W=1e-6 L=1e-6
mpway0_cell52 ML0 gate_way0_cell52 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell53 ML0 gate_way0_cell53 GND GND n1 W=1e-6 L=1e-6
mpway0_cell53 ML0 gate_way0_cell53 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell54 ML0 gate_way0_cell54 GND GND n1 W=1e-6 L=1e-6
mpway0_cell54 ML0 gate_way0_cell54 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell55 ML0 gate_way0_cell55 GND GND n1 W=1e-6 L=1e-6
mpway0_cell55 ML0 gate_way0_cell55 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell56 ML0 gate_way0_cell56 GND GND n1 W=1e-6 L=1e-6
mpway0_cell56 ML0 gate_way0_cell56 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell57 ML0 gate_way0_cell57 GND GND n1 W=1e-6 L=1e-6
mpway0_cell57 ML0 gate_way0_cell57 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell58 ML0 gate_way0_cell58 GND GND n1 W=1e-6 L=1e-6
mpway0_cell58 ML0 gate_way0_cell58 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell59 ML0 gate_way0_cell59 GND GND n1 W=1e-6 L=1e-6
mpway0_cell59 ML0 gate_way0_cell59 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell60 ML0 gate_way0_cell60 GND GND n1 W=1e-6 L=1e-6
mpway0_cell60 ML0 gate_way0_cell60 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell61 ML0 gate_way0_cell61 GND GND n1 W=1e-6 L=1e-6
mpway0_cell61 ML0 gate_way0_cell61 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell62 ML0 gate_way0_cell62 GND GND n1 W=1e-6 L=1e-6
mpway0_cell62 ML0 gate_way0_cell62 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell63 ML0 gate_way0_cell63 GND GND n1 W=1e-6 L=1e-6
mpway0_cell63 ML0 gate_way0_cell63 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell64 ML0 gate_way0_cell64 GND GND n1 W=1e-6 L=1e-6
mpway0_cell64 ML0 gate_way0_cell64 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell65 ML0 gate_way0_cell65 GND GND n1 W=1e-6 L=1e-6
mpway0_cell65 ML0 gate_way0_cell65 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell66 ML0 gate_way0_cell66 GND GND n1 W=1e-6 L=1e-6
mpway0_cell66 ML0 gate_way0_cell66 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell67 ML0 gate_way0_cell67 GND GND n1 W=1e-6 L=1e-6
mpway0_cell67 ML0 gate_way0_cell67 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell68 ML0 gate_way0_cell68 GND GND n1 W=1e-6 L=1e-6
mpway0_cell68 ML0 gate_way0_cell68 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell69 ML0 gate_way0_cell69 GND GND n1 W=1e-6 L=1e-6
mpway0_cell69 ML0 gate_way0_cell69 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell70 ML0 gate_way0_cell70 GND GND n1 W=1e-6 L=1e-6
mpway0_cell70 ML0 gate_way0_cell70 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell71 ML0 gate_way0_cell71 GND GND n1 W=1e-6 L=1e-6
mpway0_cell71 ML0 gate_way0_cell71 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell72 ML0 gate_way0_cell72 GND GND n1 W=1e-6 L=1e-6
mpway0_cell72 ML0 gate_way0_cell72 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell73 ML0 gate_way0_cell73 GND GND n1 W=1e-6 L=1e-6
mpway0_cell73 ML0 gate_way0_cell73 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell74 ML0 gate_way0_cell74 GND GND n1 W=1e-6 L=1e-6
mpway0_cell74 ML0 gate_way0_cell74 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell75 ML0 gate_way0_cell75 GND GND n1 W=1e-6 L=1e-6
mpway0_cell75 ML0 gate_way0_cell75 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell76 ML0 gate_way0_cell76 GND GND n1 W=1e-6 L=1e-6
mpway0_cell76 ML0 gate_way0_cell76 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell77 ML0 gate_way0_cell77 GND GND n1 W=1e-6 L=1e-6
mpway0_cell77 ML0 gate_way0_cell77 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell78 ML0 gate_way0_cell78 GND GND n1 W=1e-6 L=1e-6
mpway0_cell78 ML0 gate_way0_cell78 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell79 ML0 gate_way0_cell79 GND GND n1 W=1e-6 L=1e-6
mpway0_cell79 ML0 gate_way0_cell79 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell80 ML0 gate_way0_cell80 GND GND n1 W=1e-6 L=1e-6
mpway0_cell80 ML0 gate_way0_cell80 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell81 ML0 gate_way0_cell81 GND GND n1 W=1e-6 L=1e-6
mpway0_cell81 ML0 gate_way0_cell81 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell82 ML0 gate_way0_cell82 GND GND n1 W=1e-6 L=1e-6
mpway0_cell82 ML0 gate_way0_cell82 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell83 ML0 gate_way0_cell83 GND GND n1 W=1e-6 L=1e-6
mpway0_cell83 ML0 gate_way0_cell83 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell84 ML0 gate_way0_cell84 GND GND n1 W=1e-6 L=1e-6
mpway0_cell84 ML0 gate_way0_cell84 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell85 ML0 gate_way0_cell85 GND GND n1 W=1e-6 L=1e-6
mpway0_cell85 ML0 gate_way0_cell85 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell86 ML0 gate_way0_cell86 GND GND n1 W=1e-6 L=1e-6
mpway0_cell86 ML0 gate_way0_cell86 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell87 ML0 gate_way0_cell87 GND GND n1 W=1e-6 L=1e-6
mpway0_cell87 ML0 gate_way0_cell87 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell88 ML0 gate_way0_cell88 GND GND n1 W=1e-6 L=1e-6
mpway0_cell88 ML0 gate_way0_cell88 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell89 ML0 gate_way0_cell89 GND GND n1 W=1e-6 L=1e-6
mpway0_cell89 ML0 gate_way0_cell89 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell90 ML0 gate_way0_cell90 GND GND n1 W=1e-6 L=1e-6
mpway0_cell90 ML0 gate_way0_cell90 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell91 ML0 gate_way0_cell91 GND GND n1 W=1e-6 L=1e-6
mpway0_cell91 ML0 gate_way0_cell91 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell92 ML0 gate_way0_cell92 GND GND n1 W=1e-6 L=1e-6
mpway0_cell92 ML0 gate_way0_cell92 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell93 ML0 gate_way0_cell93 GND GND n1 W=1e-6 L=1e-6
mpway0_cell93 ML0 gate_way0_cell93 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell94 ML0 gate_way0_cell94 GND GND n1 W=1e-6 L=1e-6
mpway0_cell94 ML0 gate_way0_cell94 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell95 ML0 gate_way0_cell95 GND GND n1 W=1e-6 L=1e-6
mpway0_cell95 ML0 gate_way0_cell95 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell96 ML0 gate_way0_cell96 GND GND n1 W=1e-6 L=1e-6
mpway0_cell96 ML0 gate_way0_cell96 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell97 ML0 gate_way0_cell97 GND GND n1 W=1e-6 L=1e-6
mpway0_cell97 ML0 gate_way0_cell97 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell98 ML0 gate_way0_cell98 GND GND n1 W=1e-6 L=1e-6
mpway0_cell98 ML0 gate_way0_cell98 GND ML0 p1 W=2.4e-6 L=1e-6
mnway0_cell99 ML0 gate_way0_cell99 GND GND n1 W=1e-6 L=1e-6
mpway0_cell99 ML0 gate_way0_cell99 GND ML0 p1 W=2.4e-6 L=1e-6
mnway1_cell0 ML1 gate_way1_cell0 GND GND n1 W=1e-6 L=1e-6
mpway1_cell0 ML1 gate_way1_cell0 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell1 ML1 gate_way1_cell1 GND GND n1 W=1e-6 L=1e-6
mpway1_cell1 ML1 gate_way1_cell1 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell2 ML1 gate_way1_cell2 GND GND n1 W=1e-6 L=1e-6
mpway1_cell2 ML1 gate_way1_cell2 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell3 ML1 gate_way1_cell3 GND GND n1 W=1e-6 L=1e-6
mpway1_cell3 ML1 gate_way1_cell3 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell4 ML1 gate_way1_cell4 GND GND n1 W=1e-6 L=1e-6
mpway1_cell4 ML1 gate_way1_cell4 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell5 ML1 gate_way1_cell5 GND GND n1 W=1e-6 L=1e-6
mpway1_cell5 ML1 gate_way1_cell5 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell6 ML1 gate_way1_cell6 GND GND n1 W=1e-6 L=1e-6
mpway1_cell6 ML1 gate_way1_cell6 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell7 ML1 gate_way1_cell7 GND GND n1 W=1e-6 L=1e-6
mpway1_cell7 ML1 gate_way1_cell7 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell8 ML1 gate_way1_cell8 GND GND n1 W=1e-6 L=1e-6
mpway1_cell8 ML1 gate_way1_cell8 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell9 ML1 gate_way1_cell9 GND GND n1 W=1e-6 L=1e-6
mpway1_cell9 ML1 gate_way1_cell9 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell10 ML1 gate_way1_cell10 GND GND n1 W=1e-6 L=1e-6
mpway1_cell10 ML1 gate_way1_cell10 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell11 ML1 gate_way1_cell11 GND GND n1 W=1e-6 L=1e-6
mpway1_cell11 ML1 gate_way1_cell11 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell12 ML1 gate_way1_cell12 GND GND n1 W=1e-6 L=1e-6
mpway1_cell12 ML1 gate_way1_cell12 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell13 ML1 gate_way1_cell13 GND GND n1 W=1e-6 L=1e-6
mpway1_cell13 ML1 gate_way1_cell13 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell14 ML1 gate_way1_cell14 GND GND n1 W=1e-6 L=1e-6
mpway1_cell14 ML1 gate_way1_cell14 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell15 ML1 gate_way1_cell15 GND GND n1 W=1e-6 L=1e-6
mpway1_cell15 ML1 gate_way1_cell15 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell16 ML1 gate_way1_cell16 GND GND n1 W=1e-6 L=1e-6
mpway1_cell16 ML1 gate_way1_cell16 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell17 ML1 gate_way1_cell17 GND GND n1 W=1e-6 L=1e-6
mpway1_cell17 ML1 gate_way1_cell17 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell18 ML1 gate_way1_cell18 GND GND n1 W=1e-6 L=1e-6
mpway1_cell18 ML1 gate_way1_cell18 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell19 ML1 gate_way1_cell19 GND GND n1 W=1e-6 L=1e-6
mpway1_cell19 ML1 gate_way1_cell19 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell20 ML1 gate_way1_cell20 GND GND n1 W=1e-6 L=1e-6
mpway1_cell20 ML1 gate_way1_cell20 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell21 ML1 gate_way1_cell21 GND GND n1 W=1e-6 L=1e-6
mpway1_cell21 ML1 gate_way1_cell21 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell22 ML1 gate_way1_cell22 GND GND n1 W=1e-6 L=1e-6
mpway1_cell22 ML1 gate_way1_cell22 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell23 ML1 gate_way1_cell23 GND GND n1 W=1e-6 L=1e-6
mpway1_cell23 ML1 gate_way1_cell23 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell24 ML1 gate_way1_cell24 GND GND n1 W=1e-6 L=1e-6
mpway1_cell24 ML1 gate_way1_cell24 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell25 ML1 gate_way1_cell25 GND GND n1 W=1e-6 L=1e-6
mpway1_cell25 ML1 gate_way1_cell25 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell26 ML1 gate_way1_cell26 GND GND n1 W=1e-6 L=1e-6
mpway1_cell26 ML1 gate_way1_cell26 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell27 ML1 gate_way1_cell27 GND GND n1 W=1e-6 L=1e-6
mpway1_cell27 ML1 gate_way1_cell27 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell28 ML1 gate_way1_cell28 GND GND n1 W=1e-6 L=1e-6
mpway1_cell28 ML1 gate_way1_cell28 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell29 ML1 gate_way1_cell29 GND GND n1 W=1e-6 L=1e-6
mpway1_cell29 ML1 gate_way1_cell29 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell30 ML1 gate_way1_cell30 GND GND n1 W=1e-6 L=1e-6
mpway1_cell30 ML1 gate_way1_cell30 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell31 ML1 gate_way1_cell31 GND GND n1 W=1e-6 L=1e-6
mpway1_cell31 ML1 gate_way1_cell31 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell32 ML1 gate_way1_cell32 GND GND n1 W=1e-6 L=1e-6
mpway1_cell32 ML1 gate_way1_cell32 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell33 ML1 gate_way1_cell33 GND GND n1 W=1e-6 L=1e-6
mpway1_cell33 ML1 gate_way1_cell33 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell34 ML1 gate_way1_cell34 GND GND n1 W=1e-6 L=1e-6
mpway1_cell34 ML1 gate_way1_cell34 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell35 ML1 gate_way1_cell35 GND GND n1 W=1e-6 L=1e-6
mpway1_cell35 ML1 gate_way1_cell35 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell36 ML1 gate_way1_cell36 GND GND n1 W=1e-6 L=1e-6
mpway1_cell36 ML1 gate_way1_cell36 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell37 ML1 gate_way1_cell37 GND GND n1 W=1e-6 L=1e-6
mpway1_cell37 ML1 gate_way1_cell37 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell38 ML1 gate_way1_cell38 GND GND n1 W=1e-6 L=1e-6
mpway1_cell38 ML1 gate_way1_cell38 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell39 ML1 gate_way1_cell39 GND GND n1 W=1e-6 L=1e-6
mpway1_cell39 ML1 gate_way1_cell39 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell40 ML1 gate_way1_cell40 GND GND n1 W=1e-6 L=1e-6
mpway1_cell40 ML1 gate_way1_cell40 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell41 ML1 gate_way1_cell41 GND GND n1 W=1e-6 L=1e-6
mpway1_cell41 ML1 gate_way1_cell41 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell42 ML1 gate_way1_cell42 GND GND n1 W=1e-6 L=1e-6
mpway1_cell42 ML1 gate_way1_cell42 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell43 ML1 gate_way1_cell43 GND GND n1 W=1e-6 L=1e-6
mpway1_cell43 ML1 gate_way1_cell43 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell44 ML1 gate_way1_cell44 GND GND n1 W=1e-6 L=1e-6
mpway1_cell44 ML1 gate_way1_cell44 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell45 ML1 gate_way1_cell45 GND GND n1 W=1e-6 L=1e-6
mpway1_cell45 ML1 gate_way1_cell45 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell46 ML1 gate_way1_cell46 GND GND n1 W=1e-6 L=1e-6
mpway1_cell46 ML1 gate_way1_cell46 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell47 ML1 gate_way1_cell47 GND GND n1 W=1e-6 L=1e-6
mpway1_cell47 ML1 gate_way1_cell47 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell48 ML1 gate_way1_cell48 GND GND n1 W=1e-6 L=1e-6
mpway1_cell48 ML1 gate_way1_cell48 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell49 ML1 gate_way1_cell49 GND GND n1 W=1e-6 L=1e-6
mpway1_cell49 ML1 gate_way1_cell49 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell50 ML1 gate_way1_cell50 GND GND n1 W=1e-6 L=1e-6
mpway1_cell50 ML1 gate_way1_cell50 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell51 ML1 gate_way1_cell51 GND GND n1 W=1e-6 L=1e-6
mpway1_cell51 ML1 gate_way1_cell51 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell52 ML1 gate_way1_cell52 GND GND n1 W=1e-6 L=1e-6
mpway1_cell52 ML1 gate_way1_cell52 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell53 ML1 gate_way1_cell53 GND GND n1 W=1e-6 L=1e-6
mpway1_cell53 ML1 gate_way1_cell53 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell54 ML1 gate_way1_cell54 GND GND n1 W=1e-6 L=1e-6
mpway1_cell54 ML1 gate_way1_cell54 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell55 ML1 gate_way1_cell55 GND GND n1 W=1e-6 L=1e-6
mpway1_cell55 ML1 gate_way1_cell55 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell56 ML1 gate_way1_cell56 GND GND n1 W=1e-6 L=1e-6
mpway1_cell56 ML1 gate_way1_cell56 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell57 ML1 gate_way1_cell57 GND GND n1 W=1e-6 L=1e-6
mpway1_cell57 ML1 gate_way1_cell57 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell58 ML1 gate_way1_cell58 GND GND n1 W=1e-6 L=1e-6
mpway1_cell58 ML1 gate_way1_cell58 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell59 ML1 gate_way1_cell59 GND GND n1 W=1e-6 L=1e-6
mpway1_cell59 ML1 gate_way1_cell59 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell60 ML1 gate_way1_cell60 GND GND n1 W=1e-6 L=1e-6
mpway1_cell60 ML1 gate_way1_cell60 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell61 ML1 gate_way1_cell61 GND GND n1 W=1e-6 L=1e-6
mpway1_cell61 ML1 gate_way1_cell61 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell62 ML1 gate_way1_cell62 GND GND n1 W=1e-6 L=1e-6
mpway1_cell62 ML1 gate_way1_cell62 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell63 ML1 gate_way1_cell63 GND GND n1 W=1e-6 L=1e-6
mpway1_cell63 ML1 gate_way1_cell63 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell64 ML1 gate_way1_cell64 GND GND n1 W=1e-6 L=1e-6
mpway1_cell64 ML1 gate_way1_cell64 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell65 ML1 gate_way1_cell65 GND GND n1 W=1e-6 L=1e-6
mpway1_cell65 ML1 gate_way1_cell65 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell66 ML1 gate_way1_cell66 GND GND n1 W=1e-6 L=1e-6
mpway1_cell66 ML1 gate_way1_cell66 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell67 ML1 gate_way1_cell67 GND GND n1 W=1e-6 L=1e-6
mpway1_cell67 ML1 gate_way1_cell67 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell68 ML1 gate_way1_cell68 GND GND n1 W=1e-6 L=1e-6
mpway1_cell68 ML1 gate_way1_cell68 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell69 ML1 gate_way1_cell69 GND GND n1 W=1e-6 L=1e-6
mpway1_cell69 ML1 gate_way1_cell69 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell70 ML1 gate_way1_cell70 GND GND n1 W=1e-6 L=1e-6
mpway1_cell70 ML1 gate_way1_cell70 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell71 ML1 gate_way1_cell71 GND GND n1 W=1e-6 L=1e-6
mpway1_cell71 ML1 gate_way1_cell71 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell72 ML1 gate_way1_cell72 GND GND n1 W=1e-6 L=1e-6
mpway1_cell72 ML1 gate_way1_cell72 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell73 ML1 gate_way1_cell73 GND GND n1 W=1e-6 L=1e-6
mpway1_cell73 ML1 gate_way1_cell73 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell74 ML1 gate_way1_cell74 GND GND n1 W=1e-6 L=1e-6
mpway1_cell74 ML1 gate_way1_cell74 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell75 ML1 gate_way1_cell75 GND GND n1 W=1e-6 L=1e-6
mpway1_cell75 ML1 gate_way1_cell75 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell76 ML1 gate_way1_cell76 GND GND n1 W=1e-6 L=1e-6
mpway1_cell76 ML1 gate_way1_cell76 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell77 ML1 gate_way1_cell77 GND GND n1 W=1e-6 L=1e-6
mpway1_cell77 ML1 gate_way1_cell77 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell78 ML1 gate_way1_cell78 GND GND n1 W=1e-6 L=1e-6
mpway1_cell78 ML1 gate_way1_cell78 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell79 ML1 gate_way1_cell79 GND GND n1 W=1e-6 L=1e-6
mpway1_cell79 ML1 gate_way1_cell79 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell80 ML1 gate_way1_cell80 GND GND n1 W=1e-6 L=1e-6
mpway1_cell80 ML1 gate_way1_cell80 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell81 ML1 gate_way1_cell81 GND GND n1 W=1e-6 L=1e-6
mpway1_cell81 ML1 gate_way1_cell81 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell82 ML1 gate_way1_cell82 GND GND n1 W=1e-6 L=1e-6
mpway1_cell82 ML1 gate_way1_cell82 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell83 ML1 gate_way1_cell83 GND GND n1 W=1e-6 L=1e-6
mpway1_cell83 ML1 gate_way1_cell83 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell84 ML1 gate_way1_cell84 GND GND n1 W=1e-6 L=1e-6
mpway1_cell84 ML1 gate_way1_cell84 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell85 ML1 gate_way1_cell85 GND GND n1 W=1e-6 L=1e-6
mpway1_cell85 ML1 gate_way1_cell85 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell86 ML1 gate_way1_cell86 GND GND n1 W=1e-6 L=1e-6
mpway1_cell86 ML1 gate_way1_cell86 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell87 ML1 gate_way1_cell87 GND GND n1 W=1e-6 L=1e-6
mpway1_cell87 ML1 gate_way1_cell87 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell88 ML1 gate_way1_cell88 GND GND n1 W=1e-6 L=1e-6
mpway1_cell88 ML1 gate_way1_cell88 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell89 ML1 gate_way1_cell89 GND GND n1 W=1e-6 L=1e-6
mpway1_cell89 ML1 gate_way1_cell89 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell90 ML1 gate_way1_cell90 GND GND n1 W=1e-6 L=1e-6
mpway1_cell90 ML1 gate_way1_cell90 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell91 ML1 gate_way1_cell91 GND GND n1 W=1e-6 L=1e-6
mpway1_cell91 ML1 gate_way1_cell91 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell92 ML1 gate_way1_cell92 GND GND n1 W=1e-6 L=1e-6
mpway1_cell92 ML1 gate_way1_cell92 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell93 ML1 gate_way1_cell93 GND GND n1 W=1e-6 L=1e-6
mpway1_cell93 ML1 gate_way1_cell93 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell94 ML1 gate_way1_cell94 GND GND n1 W=1e-6 L=1e-6
mpway1_cell94 ML1 gate_way1_cell94 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell95 ML1 gate_way1_cell95 GND GND n1 W=1e-6 L=1e-6
mpway1_cell95 ML1 gate_way1_cell95 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell96 ML1 gate_way1_cell96 GND GND n1 W=1e-6 L=1e-6
mpway1_cell96 ML1 gate_way1_cell96 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell97 ML1 gate_way1_cell97 GND GND n1 W=1e-6 L=1e-6
mpway1_cell97 ML1 gate_way1_cell97 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell98 ML1 gate_way1_cell98 GND GND n1 W=1e-6 L=1e-6
mpway1_cell98 ML1 gate_way1_cell98 GND ML1 p1 W=2.4e-6 L=1e-6
mnway1_cell99 ML1 gate_way1_cell99 GND GND n1 W=1e-6 L=1e-6
mpway1_cell99 ML1 gate_way1_cell99 GND ML1 p1 W=2.4e-6 L=1e-6
mnway2_cell0 ML2 gate_way2_cell0 GND GND n1 W=1e-6 L=1e-6
mpway2_cell0 ML2 gate_way2_cell0 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell1 ML2 gate_way2_cell1 GND GND n1 W=1e-6 L=1e-6
mpway2_cell1 ML2 gate_way2_cell1 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell2 ML2 gate_way2_cell2 GND GND n1 W=1e-6 L=1e-6
mpway2_cell2 ML2 gate_way2_cell2 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell3 ML2 gate_way2_cell3 GND GND n1 W=1e-6 L=1e-6
mpway2_cell3 ML2 gate_way2_cell3 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell4 ML2 gate_way2_cell4 GND GND n1 W=1e-6 L=1e-6
mpway2_cell4 ML2 gate_way2_cell4 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell5 ML2 gate_way2_cell5 GND GND n1 W=1e-6 L=1e-6
mpway2_cell5 ML2 gate_way2_cell5 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell6 ML2 gate_way2_cell6 GND GND n1 W=1e-6 L=1e-6
mpway2_cell6 ML2 gate_way2_cell6 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell7 ML2 gate_way2_cell7 GND GND n1 W=1e-6 L=1e-6
mpway2_cell7 ML2 gate_way2_cell7 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell8 ML2 gate_way2_cell8 GND GND n1 W=1e-6 L=1e-6
mpway2_cell8 ML2 gate_way2_cell8 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell9 ML2 gate_way2_cell9 GND GND n1 W=1e-6 L=1e-6
mpway2_cell9 ML2 gate_way2_cell9 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell10 ML2 gate_way2_cell10 GND GND n1 W=1e-6 L=1e-6
mpway2_cell10 ML2 gate_way2_cell10 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell11 ML2 gate_way2_cell11 GND GND n1 W=1e-6 L=1e-6
mpway2_cell11 ML2 gate_way2_cell11 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell12 ML2 gate_way2_cell12 GND GND n1 W=1e-6 L=1e-6
mpway2_cell12 ML2 gate_way2_cell12 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell13 ML2 gate_way2_cell13 GND GND n1 W=1e-6 L=1e-6
mpway2_cell13 ML2 gate_way2_cell13 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell14 ML2 gate_way2_cell14 GND GND n1 W=1e-6 L=1e-6
mpway2_cell14 ML2 gate_way2_cell14 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell15 ML2 gate_way2_cell15 GND GND n1 W=1e-6 L=1e-6
mpway2_cell15 ML2 gate_way2_cell15 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell16 ML2 gate_way2_cell16 GND GND n1 W=1e-6 L=1e-6
mpway2_cell16 ML2 gate_way2_cell16 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell17 ML2 gate_way2_cell17 GND GND n1 W=1e-6 L=1e-6
mpway2_cell17 ML2 gate_way2_cell17 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell18 ML2 gate_way2_cell18 GND GND n1 W=1e-6 L=1e-6
mpway2_cell18 ML2 gate_way2_cell18 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell19 ML2 gate_way2_cell19 GND GND n1 W=1e-6 L=1e-6
mpway2_cell19 ML2 gate_way2_cell19 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell20 ML2 gate_way2_cell20 GND GND n1 W=1e-6 L=1e-6
mpway2_cell20 ML2 gate_way2_cell20 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell21 ML2 gate_way2_cell21 GND GND n1 W=1e-6 L=1e-6
mpway2_cell21 ML2 gate_way2_cell21 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell22 ML2 gate_way2_cell22 GND GND n1 W=1e-6 L=1e-6
mpway2_cell22 ML2 gate_way2_cell22 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell23 ML2 gate_way2_cell23 GND GND n1 W=1e-6 L=1e-6
mpway2_cell23 ML2 gate_way2_cell23 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell24 ML2 gate_way2_cell24 GND GND n1 W=1e-6 L=1e-6
mpway2_cell24 ML2 gate_way2_cell24 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell25 ML2 gate_way2_cell25 GND GND n1 W=1e-6 L=1e-6
mpway2_cell25 ML2 gate_way2_cell25 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell26 ML2 gate_way2_cell26 GND GND n1 W=1e-6 L=1e-6
mpway2_cell26 ML2 gate_way2_cell26 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell27 ML2 gate_way2_cell27 GND GND n1 W=1e-6 L=1e-6
mpway2_cell27 ML2 gate_way2_cell27 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell28 ML2 gate_way2_cell28 GND GND n1 W=1e-6 L=1e-6
mpway2_cell28 ML2 gate_way2_cell28 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell29 ML2 gate_way2_cell29 GND GND n1 W=1e-6 L=1e-6
mpway2_cell29 ML2 gate_way2_cell29 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell30 ML2 gate_way2_cell30 GND GND n1 W=1e-6 L=1e-6
mpway2_cell30 ML2 gate_way2_cell30 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell31 ML2 gate_way2_cell31 GND GND n1 W=1e-6 L=1e-6
mpway2_cell31 ML2 gate_way2_cell31 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell32 ML2 gate_way2_cell32 GND GND n1 W=1e-6 L=1e-6
mpway2_cell32 ML2 gate_way2_cell32 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell33 ML2 gate_way2_cell33 GND GND n1 W=1e-6 L=1e-6
mpway2_cell33 ML2 gate_way2_cell33 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell34 ML2 gate_way2_cell34 GND GND n1 W=1e-6 L=1e-6
mpway2_cell34 ML2 gate_way2_cell34 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell35 ML2 gate_way2_cell35 GND GND n1 W=1e-6 L=1e-6
mpway2_cell35 ML2 gate_way2_cell35 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell36 ML2 gate_way2_cell36 GND GND n1 W=1e-6 L=1e-6
mpway2_cell36 ML2 gate_way2_cell36 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell37 ML2 gate_way2_cell37 GND GND n1 W=1e-6 L=1e-6
mpway2_cell37 ML2 gate_way2_cell37 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell38 ML2 gate_way2_cell38 GND GND n1 W=1e-6 L=1e-6
mpway2_cell38 ML2 gate_way2_cell38 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell39 ML2 gate_way2_cell39 GND GND n1 W=1e-6 L=1e-6
mpway2_cell39 ML2 gate_way2_cell39 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell40 ML2 gate_way2_cell40 GND GND n1 W=1e-6 L=1e-6
mpway2_cell40 ML2 gate_way2_cell40 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell41 ML2 gate_way2_cell41 GND GND n1 W=1e-6 L=1e-6
mpway2_cell41 ML2 gate_way2_cell41 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell42 ML2 gate_way2_cell42 GND GND n1 W=1e-6 L=1e-6
mpway2_cell42 ML2 gate_way2_cell42 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell43 ML2 gate_way2_cell43 GND GND n1 W=1e-6 L=1e-6
mpway2_cell43 ML2 gate_way2_cell43 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell44 ML2 gate_way2_cell44 GND GND n1 W=1e-6 L=1e-6
mpway2_cell44 ML2 gate_way2_cell44 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell45 ML2 gate_way2_cell45 GND GND n1 W=1e-6 L=1e-6
mpway2_cell45 ML2 gate_way2_cell45 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell46 ML2 gate_way2_cell46 GND GND n1 W=1e-6 L=1e-6
mpway2_cell46 ML2 gate_way2_cell46 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell47 ML2 gate_way2_cell47 GND GND n1 W=1e-6 L=1e-6
mpway2_cell47 ML2 gate_way2_cell47 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell48 ML2 gate_way2_cell48 GND GND n1 W=1e-6 L=1e-6
mpway2_cell48 ML2 gate_way2_cell48 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell49 ML2 gate_way2_cell49 GND GND n1 W=1e-6 L=1e-6
mpway2_cell49 ML2 gate_way2_cell49 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell50 ML2 gate_way2_cell50 GND GND n1 W=1e-6 L=1e-6
mpway2_cell50 ML2 gate_way2_cell50 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell51 ML2 gate_way2_cell51 GND GND n1 W=1e-6 L=1e-6
mpway2_cell51 ML2 gate_way2_cell51 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell52 ML2 gate_way2_cell52 GND GND n1 W=1e-6 L=1e-6
mpway2_cell52 ML2 gate_way2_cell52 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell53 ML2 gate_way2_cell53 GND GND n1 W=1e-6 L=1e-6
mpway2_cell53 ML2 gate_way2_cell53 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell54 ML2 gate_way2_cell54 GND GND n1 W=1e-6 L=1e-6
mpway2_cell54 ML2 gate_way2_cell54 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell55 ML2 gate_way2_cell55 GND GND n1 W=1e-6 L=1e-6
mpway2_cell55 ML2 gate_way2_cell55 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell56 ML2 gate_way2_cell56 GND GND n1 W=1e-6 L=1e-6
mpway2_cell56 ML2 gate_way2_cell56 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell57 ML2 gate_way2_cell57 GND GND n1 W=1e-6 L=1e-6
mpway2_cell57 ML2 gate_way2_cell57 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell58 ML2 gate_way2_cell58 GND GND n1 W=1e-6 L=1e-6
mpway2_cell58 ML2 gate_way2_cell58 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell59 ML2 gate_way2_cell59 GND GND n1 W=1e-6 L=1e-6
mpway2_cell59 ML2 gate_way2_cell59 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell60 ML2 gate_way2_cell60 GND GND n1 W=1e-6 L=1e-6
mpway2_cell60 ML2 gate_way2_cell60 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell61 ML2 gate_way2_cell61 GND GND n1 W=1e-6 L=1e-6
mpway2_cell61 ML2 gate_way2_cell61 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell62 ML2 gate_way2_cell62 GND GND n1 W=1e-6 L=1e-6
mpway2_cell62 ML2 gate_way2_cell62 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell63 ML2 gate_way2_cell63 GND GND n1 W=1e-6 L=1e-6
mpway2_cell63 ML2 gate_way2_cell63 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell64 ML2 gate_way2_cell64 GND GND n1 W=1e-6 L=1e-6
mpway2_cell64 ML2 gate_way2_cell64 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell65 ML2 gate_way2_cell65 GND GND n1 W=1e-6 L=1e-6
mpway2_cell65 ML2 gate_way2_cell65 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell66 ML2 gate_way2_cell66 GND GND n1 W=1e-6 L=1e-6
mpway2_cell66 ML2 gate_way2_cell66 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell67 ML2 gate_way2_cell67 GND GND n1 W=1e-6 L=1e-6
mpway2_cell67 ML2 gate_way2_cell67 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell68 ML2 gate_way2_cell68 GND GND n1 W=1e-6 L=1e-6
mpway2_cell68 ML2 gate_way2_cell68 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell69 ML2 gate_way2_cell69 GND GND n1 W=1e-6 L=1e-6
mpway2_cell69 ML2 gate_way2_cell69 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell70 ML2 gate_way2_cell70 GND GND n1 W=1e-6 L=1e-6
mpway2_cell70 ML2 gate_way2_cell70 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell71 ML2 gate_way2_cell71 GND GND n1 W=1e-6 L=1e-6
mpway2_cell71 ML2 gate_way2_cell71 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell72 ML2 gate_way2_cell72 GND GND n1 W=1e-6 L=1e-6
mpway2_cell72 ML2 gate_way2_cell72 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell73 ML2 gate_way2_cell73 GND GND n1 W=1e-6 L=1e-6
mpway2_cell73 ML2 gate_way2_cell73 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell74 ML2 gate_way2_cell74 GND GND n1 W=1e-6 L=1e-6
mpway2_cell74 ML2 gate_way2_cell74 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell75 ML2 gate_way2_cell75 GND GND n1 W=1e-6 L=1e-6
mpway2_cell75 ML2 gate_way2_cell75 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell76 ML2 gate_way2_cell76 GND GND n1 W=1e-6 L=1e-6
mpway2_cell76 ML2 gate_way2_cell76 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell77 ML2 gate_way2_cell77 GND GND n1 W=1e-6 L=1e-6
mpway2_cell77 ML2 gate_way2_cell77 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell78 ML2 gate_way2_cell78 GND GND n1 W=1e-6 L=1e-6
mpway2_cell78 ML2 gate_way2_cell78 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell79 ML2 gate_way2_cell79 GND GND n1 W=1e-6 L=1e-6
mpway2_cell79 ML2 gate_way2_cell79 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell80 ML2 gate_way2_cell80 GND GND n1 W=1e-6 L=1e-6
mpway2_cell80 ML2 gate_way2_cell80 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell81 ML2 gate_way2_cell81 GND GND n1 W=1e-6 L=1e-6
mpway2_cell81 ML2 gate_way2_cell81 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell82 ML2 gate_way2_cell82 GND GND n1 W=1e-6 L=1e-6
mpway2_cell82 ML2 gate_way2_cell82 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell83 ML2 gate_way2_cell83 GND GND n1 W=1e-6 L=1e-6
mpway2_cell83 ML2 gate_way2_cell83 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell84 ML2 gate_way2_cell84 GND GND n1 W=1e-6 L=1e-6
mpway2_cell84 ML2 gate_way2_cell84 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell85 ML2 gate_way2_cell85 GND GND n1 W=1e-6 L=1e-6
mpway2_cell85 ML2 gate_way2_cell85 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell86 ML2 gate_way2_cell86 GND GND n1 W=1e-6 L=1e-6
mpway2_cell86 ML2 gate_way2_cell86 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell87 ML2 gate_way2_cell87 GND GND n1 W=1e-6 L=1e-6
mpway2_cell87 ML2 gate_way2_cell87 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell88 ML2 gate_way2_cell88 GND GND n1 W=1e-6 L=1e-6
mpway2_cell88 ML2 gate_way2_cell88 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell89 ML2 gate_way2_cell89 GND GND n1 W=1e-6 L=1e-6
mpway2_cell89 ML2 gate_way2_cell89 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell90 ML2 gate_way2_cell90 GND GND n1 W=1e-6 L=1e-6
mpway2_cell90 ML2 gate_way2_cell90 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell91 ML2 gate_way2_cell91 GND GND n1 W=1e-6 L=1e-6
mpway2_cell91 ML2 gate_way2_cell91 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell92 ML2 gate_way2_cell92 GND GND n1 W=1e-6 L=1e-6
mpway2_cell92 ML2 gate_way2_cell92 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell93 ML2 gate_way2_cell93 GND GND n1 W=1e-6 L=1e-6
mpway2_cell93 ML2 gate_way2_cell93 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell94 ML2 gate_way2_cell94 GND GND n1 W=1e-6 L=1e-6
mpway2_cell94 ML2 gate_way2_cell94 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell95 ML2 gate_way2_cell95 GND GND n1 W=1e-6 L=1e-6
mpway2_cell95 ML2 gate_way2_cell95 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell96 ML2 gate_way2_cell96 GND GND n1 W=1e-6 L=1e-6
mpway2_cell96 ML2 gate_way2_cell96 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell97 ML2 gate_way2_cell97 GND GND n1 W=1e-6 L=1e-6
mpway2_cell97 ML2 gate_way2_cell97 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell98 ML2 gate_way2_cell98 GND GND n1 W=1e-6 L=1e-6
mpway2_cell98 ML2 gate_way2_cell98 GND ML2 p1 W=2.4e-6 L=1e-6
mnway2_cell99 ML2 gate_way2_cell99 GND GND n1 W=1e-6 L=1e-6
mpway2_cell99 ML2 gate_way2_cell99 GND ML2 p1 W=2.4e-6 L=1e-6
mnway3_cell0 ML3 gate_way3_cell0 GND GND n1 W=1e-6 L=1e-6
mpway3_cell0 ML3 gate_way3_cell0 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell1 ML3 gate_way3_cell1 GND GND n1 W=1e-6 L=1e-6
mpway3_cell1 ML3 gate_way3_cell1 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell2 ML3 gate_way3_cell2 GND GND n1 W=1e-6 L=1e-6
mpway3_cell2 ML3 gate_way3_cell2 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell3 ML3 gate_way3_cell3 GND GND n1 W=1e-6 L=1e-6
mpway3_cell3 ML3 gate_way3_cell3 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell4 ML3 gate_way3_cell4 GND GND n1 W=1e-6 L=1e-6
mpway3_cell4 ML3 gate_way3_cell4 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell5 ML3 gate_way3_cell5 GND GND n1 W=1e-6 L=1e-6
mpway3_cell5 ML3 gate_way3_cell5 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell6 ML3 gate_way3_cell6 GND GND n1 W=1e-6 L=1e-6
mpway3_cell6 ML3 gate_way3_cell6 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell7 ML3 gate_way3_cell7 GND GND n1 W=1e-6 L=1e-6
mpway3_cell7 ML3 gate_way3_cell7 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell8 ML3 gate_way3_cell8 GND GND n1 W=1e-6 L=1e-6
mpway3_cell8 ML3 gate_way3_cell8 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell9 ML3 gate_way3_cell9 GND GND n1 W=1e-6 L=1e-6
mpway3_cell9 ML3 gate_way3_cell9 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell10 ML3 gate_way3_cell10 GND GND n1 W=1e-6 L=1e-6
mpway3_cell10 ML3 gate_way3_cell10 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell11 ML3 gate_way3_cell11 GND GND n1 W=1e-6 L=1e-6
mpway3_cell11 ML3 gate_way3_cell11 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell12 ML3 gate_way3_cell12 GND GND n1 W=1e-6 L=1e-6
mpway3_cell12 ML3 gate_way3_cell12 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell13 ML3 gate_way3_cell13 GND GND n1 W=1e-6 L=1e-6
mpway3_cell13 ML3 gate_way3_cell13 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell14 ML3 gate_way3_cell14 GND GND n1 W=1e-6 L=1e-6
mpway3_cell14 ML3 gate_way3_cell14 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell15 ML3 gate_way3_cell15 GND GND n1 W=1e-6 L=1e-6
mpway3_cell15 ML3 gate_way3_cell15 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell16 ML3 gate_way3_cell16 GND GND n1 W=1e-6 L=1e-6
mpway3_cell16 ML3 gate_way3_cell16 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell17 ML3 gate_way3_cell17 GND GND n1 W=1e-6 L=1e-6
mpway3_cell17 ML3 gate_way3_cell17 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell18 ML3 gate_way3_cell18 GND GND n1 W=1e-6 L=1e-6
mpway3_cell18 ML3 gate_way3_cell18 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell19 ML3 gate_way3_cell19 GND GND n1 W=1e-6 L=1e-6
mpway3_cell19 ML3 gate_way3_cell19 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell20 ML3 gate_way3_cell20 GND GND n1 W=1e-6 L=1e-6
mpway3_cell20 ML3 gate_way3_cell20 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell21 ML3 gate_way3_cell21 GND GND n1 W=1e-6 L=1e-6
mpway3_cell21 ML3 gate_way3_cell21 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell22 ML3 gate_way3_cell22 GND GND n1 W=1e-6 L=1e-6
mpway3_cell22 ML3 gate_way3_cell22 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell23 ML3 gate_way3_cell23 GND GND n1 W=1e-6 L=1e-6
mpway3_cell23 ML3 gate_way3_cell23 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell24 ML3 gate_way3_cell24 GND GND n1 W=1e-6 L=1e-6
mpway3_cell24 ML3 gate_way3_cell24 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell25 ML3 gate_way3_cell25 GND GND n1 W=1e-6 L=1e-6
mpway3_cell25 ML3 gate_way3_cell25 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell26 ML3 gate_way3_cell26 GND GND n1 W=1e-6 L=1e-6
mpway3_cell26 ML3 gate_way3_cell26 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell27 ML3 gate_way3_cell27 GND GND n1 W=1e-6 L=1e-6
mpway3_cell27 ML3 gate_way3_cell27 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell28 ML3 gate_way3_cell28 GND GND n1 W=1e-6 L=1e-6
mpway3_cell28 ML3 gate_way3_cell28 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell29 ML3 gate_way3_cell29 GND GND n1 W=1e-6 L=1e-6
mpway3_cell29 ML3 gate_way3_cell29 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell30 ML3 gate_way3_cell30 GND GND n1 W=1e-6 L=1e-6
mpway3_cell30 ML3 gate_way3_cell30 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell31 ML3 gate_way3_cell31 GND GND n1 W=1e-6 L=1e-6
mpway3_cell31 ML3 gate_way3_cell31 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell32 ML3 gate_way3_cell32 GND GND n1 W=1e-6 L=1e-6
mpway3_cell32 ML3 gate_way3_cell32 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell33 ML3 gate_way3_cell33 GND GND n1 W=1e-6 L=1e-6
mpway3_cell33 ML3 gate_way3_cell33 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell34 ML3 gate_way3_cell34 GND GND n1 W=1e-6 L=1e-6
mpway3_cell34 ML3 gate_way3_cell34 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell35 ML3 gate_way3_cell35 GND GND n1 W=1e-6 L=1e-6
mpway3_cell35 ML3 gate_way3_cell35 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell36 ML3 gate_way3_cell36 GND GND n1 W=1e-6 L=1e-6
mpway3_cell36 ML3 gate_way3_cell36 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell37 ML3 gate_way3_cell37 GND GND n1 W=1e-6 L=1e-6
mpway3_cell37 ML3 gate_way3_cell37 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell38 ML3 gate_way3_cell38 GND GND n1 W=1e-6 L=1e-6
mpway3_cell38 ML3 gate_way3_cell38 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell39 ML3 gate_way3_cell39 GND GND n1 W=1e-6 L=1e-6
mpway3_cell39 ML3 gate_way3_cell39 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell40 ML3 gate_way3_cell40 GND GND n1 W=1e-6 L=1e-6
mpway3_cell40 ML3 gate_way3_cell40 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell41 ML3 gate_way3_cell41 GND GND n1 W=1e-6 L=1e-6
mpway3_cell41 ML3 gate_way3_cell41 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell42 ML3 gate_way3_cell42 GND GND n1 W=1e-6 L=1e-6
mpway3_cell42 ML3 gate_way3_cell42 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell43 ML3 gate_way3_cell43 GND GND n1 W=1e-6 L=1e-6
mpway3_cell43 ML3 gate_way3_cell43 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell44 ML3 gate_way3_cell44 GND GND n1 W=1e-6 L=1e-6
mpway3_cell44 ML3 gate_way3_cell44 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell45 ML3 gate_way3_cell45 GND GND n1 W=1e-6 L=1e-6
mpway3_cell45 ML3 gate_way3_cell45 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell46 ML3 gate_way3_cell46 GND GND n1 W=1e-6 L=1e-6
mpway3_cell46 ML3 gate_way3_cell46 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell47 ML3 gate_way3_cell47 GND GND n1 W=1e-6 L=1e-6
mpway3_cell47 ML3 gate_way3_cell47 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell48 ML3 gate_way3_cell48 GND GND n1 W=1e-6 L=1e-6
mpway3_cell48 ML3 gate_way3_cell48 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell49 ML3 gate_way3_cell49 GND GND n1 W=1e-6 L=1e-6
mpway3_cell49 ML3 gate_way3_cell49 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell50 ML3 gate_way3_cell50 GND GND n1 W=1e-6 L=1e-6
mpway3_cell50 ML3 gate_way3_cell50 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell51 ML3 gate_way3_cell51 GND GND n1 W=1e-6 L=1e-6
mpway3_cell51 ML3 gate_way3_cell51 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell52 ML3 gate_way3_cell52 GND GND n1 W=1e-6 L=1e-6
mpway3_cell52 ML3 gate_way3_cell52 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell53 ML3 gate_way3_cell53 GND GND n1 W=1e-6 L=1e-6
mpway3_cell53 ML3 gate_way3_cell53 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell54 ML3 gate_way3_cell54 GND GND n1 W=1e-6 L=1e-6
mpway3_cell54 ML3 gate_way3_cell54 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell55 ML3 gate_way3_cell55 GND GND n1 W=1e-6 L=1e-6
mpway3_cell55 ML3 gate_way3_cell55 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell56 ML3 gate_way3_cell56 GND GND n1 W=1e-6 L=1e-6
mpway3_cell56 ML3 gate_way3_cell56 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell57 ML3 gate_way3_cell57 GND GND n1 W=1e-6 L=1e-6
mpway3_cell57 ML3 gate_way3_cell57 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell58 ML3 gate_way3_cell58 GND GND n1 W=1e-6 L=1e-6
mpway3_cell58 ML3 gate_way3_cell58 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell59 ML3 gate_way3_cell59 GND GND n1 W=1e-6 L=1e-6
mpway3_cell59 ML3 gate_way3_cell59 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell60 ML3 gate_way3_cell60 GND GND n1 W=1e-6 L=1e-6
mpway3_cell60 ML3 gate_way3_cell60 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell61 ML3 gate_way3_cell61 GND GND n1 W=1e-6 L=1e-6
mpway3_cell61 ML3 gate_way3_cell61 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell62 ML3 gate_way3_cell62 GND GND n1 W=1e-6 L=1e-6
mpway3_cell62 ML3 gate_way3_cell62 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell63 ML3 gate_way3_cell63 GND GND n1 W=1e-6 L=1e-6
mpway3_cell63 ML3 gate_way3_cell63 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell64 ML3 gate_way3_cell64 GND GND n1 W=1e-6 L=1e-6
mpway3_cell64 ML3 gate_way3_cell64 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell65 ML3 gate_way3_cell65 GND GND n1 W=1e-6 L=1e-6
mpway3_cell65 ML3 gate_way3_cell65 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell66 ML3 gate_way3_cell66 GND GND n1 W=1e-6 L=1e-6
mpway3_cell66 ML3 gate_way3_cell66 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell67 ML3 gate_way3_cell67 GND GND n1 W=1e-6 L=1e-6
mpway3_cell67 ML3 gate_way3_cell67 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell68 ML3 gate_way3_cell68 GND GND n1 W=1e-6 L=1e-6
mpway3_cell68 ML3 gate_way3_cell68 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell69 ML3 gate_way3_cell69 GND GND n1 W=1e-6 L=1e-6
mpway3_cell69 ML3 gate_way3_cell69 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell70 ML3 gate_way3_cell70 GND GND n1 W=1e-6 L=1e-6
mpway3_cell70 ML3 gate_way3_cell70 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell71 ML3 gate_way3_cell71 GND GND n1 W=1e-6 L=1e-6
mpway3_cell71 ML3 gate_way3_cell71 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell72 ML3 gate_way3_cell72 GND GND n1 W=1e-6 L=1e-6
mpway3_cell72 ML3 gate_way3_cell72 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell73 ML3 gate_way3_cell73 GND GND n1 W=1e-6 L=1e-6
mpway3_cell73 ML3 gate_way3_cell73 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell74 ML3 gate_way3_cell74 GND GND n1 W=1e-6 L=1e-6
mpway3_cell74 ML3 gate_way3_cell74 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell75 ML3 gate_way3_cell75 GND GND n1 W=1e-6 L=1e-6
mpway3_cell75 ML3 gate_way3_cell75 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell76 ML3 gate_way3_cell76 GND GND n1 W=1e-6 L=1e-6
mpway3_cell76 ML3 gate_way3_cell76 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell77 ML3 gate_way3_cell77 GND GND n1 W=1e-6 L=1e-6
mpway3_cell77 ML3 gate_way3_cell77 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell78 ML3 gate_way3_cell78 GND GND n1 W=1e-6 L=1e-6
mpway3_cell78 ML3 gate_way3_cell78 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell79 ML3 gate_way3_cell79 GND GND n1 W=1e-6 L=1e-6
mpway3_cell79 ML3 gate_way3_cell79 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell80 ML3 gate_way3_cell80 GND GND n1 W=1e-6 L=1e-6
mpway3_cell80 ML3 gate_way3_cell80 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell81 ML3 gate_way3_cell81 GND GND n1 W=1e-6 L=1e-6
mpway3_cell81 ML3 gate_way3_cell81 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell82 ML3 gate_way3_cell82 GND GND n1 W=1e-6 L=1e-6
mpway3_cell82 ML3 gate_way3_cell82 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell83 ML3 gate_way3_cell83 GND GND n1 W=1e-6 L=1e-6
mpway3_cell83 ML3 gate_way3_cell83 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell84 ML3 gate_way3_cell84 GND GND n1 W=1e-6 L=1e-6
mpway3_cell84 ML3 gate_way3_cell84 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell85 ML3 gate_way3_cell85 GND GND n1 W=1e-6 L=1e-6
mpway3_cell85 ML3 gate_way3_cell85 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell86 ML3 gate_way3_cell86 GND GND n1 W=1e-6 L=1e-6
mpway3_cell86 ML3 gate_way3_cell86 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell87 ML3 gate_way3_cell87 GND GND n1 W=1e-6 L=1e-6
mpway3_cell87 ML3 gate_way3_cell87 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell88 ML3 gate_way3_cell88 GND GND n1 W=1e-6 L=1e-6
mpway3_cell88 ML3 gate_way3_cell88 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell89 ML3 gate_way3_cell89 GND GND n1 W=1e-6 L=1e-6
mpway3_cell89 ML3 gate_way3_cell89 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell90 ML3 gate_way3_cell90 GND GND n1 W=1e-6 L=1e-6
mpway3_cell90 ML3 gate_way3_cell90 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell91 ML3 gate_way3_cell91 GND GND n1 W=1e-6 L=1e-6
mpway3_cell91 ML3 gate_way3_cell91 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell92 ML3 gate_way3_cell92 GND GND n1 W=1e-6 L=1e-6
mpway3_cell92 ML3 gate_way3_cell92 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell93 ML3 gate_way3_cell93 GND GND n1 W=1e-6 L=1e-6
mpway3_cell93 ML3 gate_way3_cell93 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell94 ML3 gate_way3_cell94 GND GND n1 W=1e-6 L=1e-6
mpway3_cell94 ML3 gate_way3_cell94 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell95 ML3 gate_way3_cell95 GND GND n1 W=1e-6 L=1e-6
mpway3_cell95 ML3 gate_way3_cell95 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell96 ML3 gate_way3_cell96 GND GND n1 W=1e-6 L=1e-6
mpway3_cell96 ML3 gate_way3_cell96 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell97 ML3 gate_way3_cell97 GND GND n1 W=1e-6 L=1e-6
mpway3_cell97 ML3 gate_way3_cell97 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell98 ML3 gate_way3_cell98 GND GND n1 W=1e-6 L=1e-6
mpway3_cell98 ML3 gate_way3_cell98 GND ML3 p1 W=2.4e-6 L=1e-6
mnway3_cell99 ML3 gate_way3_cell99 GND GND n1 W=1e-6 L=1e-6
mpway3_cell99 ML3 gate_way3_cell99 GND ML3 p1 W=2.4e-6 L=1e-6
mnway4_cell0 ML4 gate_way4_cell0 GND GND n1 W=1e-6 L=1e-6
mpway4_cell0 ML4 gate_way4_cell0 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell1 ML4 gate_way4_cell1 GND GND n1 W=1e-6 L=1e-6
mpway4_cell1 ML4 gate_way4_cell1 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell2 ML4 gate_way4_cell2 GND GND n1 W=1e-6 L=1e-6
mpway4_cell2 ML4 gate_way4_cell2 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell3 ML4 gate_way4_cell3 GND GND n1 W=1e-6 L=1e-6
mpway4_cell3 ML4 gate_way4_cell3 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell4 ML4 gate_way4_cell4 GND GND n1 W=1e-6 L=1e-6
mpway4_cell4 ML4 gate_way4_cell4 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell5 ML4 gate_way4_cell5 GND GND n1 W=1e-6 L=1e-6
mpway4_cell5 ML4 gate_way4_cell5 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell6 ML4 gate_way4_cell6 GND GND n1 W=1e-6 L=1e-6
mpway4_cell6 ML4 gate_way4_cell6 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell7 ML4 gate_way4_cell7 GND GND n1 W=1e-6 L=1e-6
mpway4_cell7 ML4 gate_way4_cell7 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell8 ML4 gate_way4_cell8 GND GND n1 W=1e-6 L=1e-6
mpway4_cell8 ML4 gate_way4_cell8 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell9 ML4 gate_way4_cell9 GND GND n1 W=1e-6 L=1e-6
mpway4_cell9 ML4 gate_way4_cell9 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell10 ML4 gate_way4_cell10 GND GND n1 W=1e-6 L=1e-6
mpway4_cell10 ML4 gate_way4_cell10 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell11 ML4 gate_way4_cell11 GND GND n1 W=1e-6 L=1e-6
mpway4_cell11 ML4 gate_way4_cell11 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell12 ML4 gate_way4_cell12 GND GND n1 W=1e-6 L=1e-6
mpway4_cell12 ML4 gate_way4_cell12 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell13 ML4 gate_way4_cell13 GND GND n1 W=1e-6 L=1e-6
mpway4_cell13 ML4 gate_way4_cell13 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell14 ML4 gate_way4_cell14 GND GND n1 W=1e-6 L=1e-6
mpway4_cell14 ML4 gate_way4_cell14 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell15 ML4 gate_way4_cell15 GND GND n1 W=1e-6 L=1e-6
mpway4_cell15 ML4 gate_way4_cell15 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell16 ML4 gate_way4_cell16 GND GND n1 W=1e-6 L=1e-6
mpway4_cell16 ML4 gate_way4_cell16 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell17 ML4 gate_way4_cell17 GND GND n1 W=1e-6 L=1e-6
mpway4_cell17 ML4 gate_way4_cell17 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell18 ML4 gate_way4_cell18 GND GND n1 W=1e-6 L=1e-6
mpway4_cell18 ML4 gate_way4_cell18 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell19 ML4 gate_way4_cell19 GND GND n1 W=1e-6 L=1e-6
mpway4_cell19 ML4 gate_way4_cell19 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell20 ML4 gate_way4_cell20 GND GND n1 W=1e-6 L=1e-6
mpway4_cell20 ML4 gate_way4_cell20 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell21 ML4 gate_way4_cell21 GND GND n1 W=1e-6 L=1e-6
mpway4_cell21 ML4 gate_way4_cell21 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell22 ML4 gate_way4_cell22 GND GND n1 W=1e-6 L=1e-6
mpway4_cell22 ML4 gate_way4_cell22 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell23 ML4 gate_way4_cell23 GND GND n1 W=1e-6 L=1e-6
mpway4_cell23 ML4 gate_way4_cell23 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell24 ML4 gate_way4_cell24 GND GND n1 W=1e-6 L=1e-6
mpway4_cell24 ML4 gate_way4_cell24 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell25 ML4 gate_way4_cell25 GND GND n1 W=1e-6 L=1e-6
mpway4_cell25 ML4 gate_way4_cell25 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell26 ML4 gate_way4_cell26 GND GND n1 W=1e-6 L=1e-6
mpway4_cell26 ML4 gate_way4_cell26 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell27 ML4 gate_way4_cell27 GND GND n1 W=1e-6 L=1e-6
mpway4_cell27 ML4 gate_way4_cell27 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell28 ML4 gate_way4_cell28 GND GND n1 W=1e-6 L=1e-6
mpway4_cell28 ML4 gate_way4_cell28 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell29 ML4 gate_way4_cell29 GND GND n1 W=1e-6 L=1e-6
mpway4_cell29 ML4 gate_way4_cell29 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell30 ML4 gate_way4_cell30 GND GND n1 W=1e-6 L=1e-6
mpway4_cell30 ML4 gate_way4_cell30 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell31 ML4 gate_way4_cell31 GND GND n1 W=1e-6 L=1e-6
mpway4_cell31 ML4 gate_way4_cell31 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell32 ML4 gate_way4_cell32 GND GND n1 W=1e-6 L=1e-6
mpway4_cell32 ML4 gate_way4_cell32 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell33 ML4 gate_way4_cell33 GND GND n1 W=1e-6 L=1e-6
mpway4_cell33 ML4 gate_way4_cell33 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell34 ML4 gate_way4_cell34 GND GND n1 W=1e-6 L=1e-6
mpway4_cell34 ML4 gate_way4_cell34 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell35 ML4 gate_way4_cell35 GND GND n1 W=1e-6 L=1e-6
mpway4_cell35 ML4 gate_way4_cell35 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell36 ML4 gate_way4_cell36 GND GND n1 W=1e-6 L=1e-6
mpway4_cell36 ML4 gate_way4_cell36 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell37 ML4 gate_way4_cell37 GND GND n1 W=1e-6 L=1e-6
mpway4_cell37 ML4 gate_way4_cell37 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell38 ML4 gate_way4_cell38 GND GND n1 W=1e-6 L=1e-6
mpway4_cell38 ML4 gate_way4_cell38 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell39 ML4 gate_way4_cell39 GND GND n1 W=1e-6 L=1e-6
mpway4_cell39 ML4 gate_way4_cell39 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell40 ML4 gate_way4_cell40 GND GND n1 W=1e-6 L=1e-6
mpway4_cell40 ML4 gate_way4_cell40 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell41 ML4 gate_way4_cell41 GND GND n1 W=1e-6 L=1e-6
mpway4_cell41 ML4 gate_way4_cell41 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell42 ML4 gate_way4_cell42 GND GND n1 W=1e-6 L=1e-6
mpway4_cell42 ML4 gate_way4_cell42 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell43 ML4 gate_way4_cell43 GND GND n1 W=1e-6 L=1e-6
mpway4_cell43 ML4 gate_way4_cell43 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell44 ML4 gate_way4_cell44 GND GND n1 W=1e-6 L=1e-6
mpway4_cell44 ML4 gate_way4_cell44 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell45 ML4 gate_way4_cell45 GND GND n1 W=1e-6 L=1e-6
mpway4_cell45 ML4 gate_way4_cell45 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell46 ML4 gate_way4_cell46 GND GND n1 W=1e-6 L=1e-6
mpway4_cell46 ML4 gate_way4_cell46 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell47 ML4 gate_way4_cell47 GND GND n1 W=1e-6 L=1e-6
mpway4_cell47 ML4 gate_way4_cell47 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell48 ML4 gate_way4_cell48 GND GND n1 W=1e-6 L=1e-6
mpway4_cell48 ML4 gate_way4_cell48 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell49 ML4 gate_way4_cell49 GND GND n1 W=1e-6 L=1e-6
mpway4_cell49 ML4 gate_way4_cell49 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell50 ML4 gate_way4_cell50 GND GND n1 W=1e-6 L=1e-6
mpway4_cell50 ML4 gate_way4_cell50 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell51 ML4 gate_way4_cell51 GND GND n1 W=1e-6 L=1e-6
mpway4_cell51 ML4 gate_way4_cell51 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell52 ML4 gate_way4_cell52 GND GND n1 W=1e-6 L=1e-6
mpway4_cell52 ML4 gate_way4_cell52 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell53 ML4 gate_way4_cell53 GND GND n1 W=1e-6 L=1e-6
mpway4_cell53 ML4 gate_way4_cell53 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell54 ML4 gate_way4_cell54 GND GND n1 W=1e-6 L=1e-6
mpway4_cell54 ML4 gate_way4_cell54 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell55 ML4 gate_way4_cell55 GND GND n1 W=1e-6 L=1e-6
mpway4_cell55 ML4 gate_way4_cell55 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell56 ML4 gate_way4_cell56 GND GND n1 W=1e-6 L=1e-6
mpway4_cell56 ML4 gate_way4_cell56 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell57 ML4 gate_way4_cell57 GND GND n1 W=1e-6 L=1e-6
mpway4_cell57 ML4 gate_way4_cell57 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell58 ML4 gate_way4_cell58 GND GND n1 W=1e-6 L=1e-6
mpway4_cell58 ML4 gate_way4_cell58 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell59 ML4 gate_way4_cell59 GND GND n1 W=1e-6 L=1e-6
mpway4_cell59 ML4 gate_way4_cell59 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell60 ML4 gate_way4_cell60 GND GND n1 W=1e-6 L=1e-6
mpway4_cell60 ML4 gate_way4_cell60 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell61 ML4 gate_way4_cell61 GND GND n1 W=1e-6 L=1e-6
mpway4_cell61 ML4 gate_way4_cell61 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell62 ML4 gate_way4_cell62 GND GND n1 W=1e-6 L=1e-6
mpway4_cell62 ML4 gate_way4_cell62 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell63 ML4 gate_way4_cell63 GND GND n1 W=1e-6 L=1e-6
mpway4_cell63 ML4 gate_way4_cell63 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell64 ML4 gate_way4_cell64 GND GND n1 W=1e-6 L=1e-6
mpway4_cell64 ML4 gate_way4_cell64 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell65 ML4 gate_way4_cell65 GND GND n1 W=1e-6 L=1e-6
mpway4_cell65 ML4 gate_way4_cell65 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell66 ML4 gate_way4_cell66 GND GND n1 W=1e-6 L=1e-6
mpway4_cell66 ML4 gate_way4_cell66 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell67 ML4 gate_way4_cell67 GND GND n1 W=1e-6 L=1e-6
mpway4_cell67 ML4 gate_way4_cell67 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell68 ML4 gate_way4_cell68 GND GND n1 W=1e-6 L=1e-6
mpway4_cell68 ML4 gate_way4_cell68 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell69 ML4 gate_way4_cell69 GND GND n1 W=1e-6 L=1e-6
mpway4_cell69 ML4 gate_way4_cell69 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell70 ML4 gate_way4_cell70 GND GND n1 W=1e-6 L=1e-6
mpway4_cell70 ML4 gate_way4_cell70 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell71 ML4 gate_way4_cell71 GND GND n1 W=1e-6 L=1e-6
mpway4_cell71 ML4 gate_way4_cell71 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell72 ML4 gate_way4_cell72 GND GND n1 W=1e-6 L=1e-6
mpway4_cell72 ML4 gate_way4_cell72 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell73 ML4 gate_way4_cell73 GND GND n1 W=1e-6 L=1e-6
mpway4_cell73 ML4 gate_way4_cell73 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell74 ML4 gate_way4_cell74 GND GND n1 W=1e-6 L=1e-6
mpway4_cell74 ML4 gate_way4_cell74 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell75 ML4 gate_way4_cell75 GND GND n1 W=1e-6 L=1e-6
mpway4_cell75 ML4 gate_way4_cell75 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell76 ML4 gate_way4_cell76 GND GND n1 W=1e-6 L=1e-6
mpway4_cell76 ML4 gate_way4_cell76 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell77 ML4 gate_way4_cell77 GND GND n1 W=1e-6 L=1e-6
mpway4_cell77 ML4 gate_way4_cell77 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell78 ML4 gate_way4_cell78 GND GND n1 W=1e-6 L=1e-6
mpway4_cell78 ML4 gate_way4_cell78 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell79 ML4 gate_way4_cell79 GND GND n1 W=1e-6 L=1e-6
mpway4_cell79 ML4 gate_way4_cell79 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell80 ML4 gate_way4_cell80 GND GND n1 W=1e-6 L=1e-6
mpway4_cell80 ML4 gate_way4_cell80 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell81 ML4 gate_way4_cell81 GND GND n1 W=1e-6 L=1e-6
mpway4_cell81 ML4 gate_way4_cell81 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell82 ML4 gate_way4_cell82 GND GND n1 W=1e-6 L=1e-6
mpway4_cell82 ML4 gate_way4_cell82 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell83 ML4 gate_way4_cell83 GND GND n1 W=1e-6 L=1e-6
mpway4_cell83 ML4 gate_way4_cell83 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell84 ML4 gate_way4_cell84 GND GND n1 W=1e-6 L=1e-6
mpway4_cell84 ML4 gate_way4_cell84 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell85 ML4 gate_way4_cell85 GND GND n1 W=1e-6 L=1e-6
mpway4_cell85 ML4 gate_way4_cell85 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell86 ML4 gate_way4_cell86 GND GND n1 W=1e-6 L=1e-6
mpway4_cell86 ML4 gate_way4_cell86 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell87 ML4 gate_way4_cell87 GND GND n1 W=1e-6 L=1e-6
mpway4_cell87 ML4 gate_way4_cell87 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell88 ML4 gate_way4_cell88 GND GND n1 W=1e-6 L=1e-6
mpway4_cell88 ML4 gate_way4_cell88 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell89 ML4 gate_way4_cell89 GND GND n1 W=1e-6 L=1e-6
mpway4_cell89 ML4 gate_way4_cell89 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell90 ML4 gate_way4_cell90 GND GND n1 W=1e-6 L=1e-6
mpway4_cell90 ML4 gate_way4_cell90 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell91 ML4 gate_way4_cell91 GND GND n1 W=1e-6 L=1e-6
mpway4_cell91 ML4 gate_way4_cell91 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell92 ML4 gate_way4_cell92 GND GND n1 W=1e-6 L=1e-6
mpway4_cell92 ML4 gate_way4_cell92 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell93 ML4 gate_way4_cell93 GND GND n1 W=1e-6 L=1e-6
mpway4_cell93 ML4 gate_way4_cell93 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell94 ML4 gate_way4_cell94 GND GND n1 W=1e-6 L=1e-6
mpway4_cell94 ML4 gate_way4_cell94 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell95 ML4 gate_way4_cell95 GND GND n1 W=1e-6 L=1e-6
mpway4_cell95 ML4 gate_way4_cell95 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell96 ML4 gate_way4_cell96 GND GND n1 W=1e-6 L=1e-6
mpway4_cell96 ML4 gate_way4_cell96 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell97 ML4 gate_way4_cell97 GND GND n1 W=1e-6 L=1e-6
mpway4_cell97 ML4 gate_way4_cell97 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell98 ML4 gate_way4_cell98 GND GND n1 W=1e-6 L=1e-6
mpway4_cell98 ML4 gate_way4_cell98 GND ML4 p1 W=2.4e-6 L=1e-6
mnway4_cell99 ML4 gate_way4_cell99 GND GND n1 W=1e-6 L=1e-6
mpway4_cell99 ML4 gate_way4_cell99 GND ML4 p1 W=2.4e-6 L=1e-6
mnway5_cell0 ML5 gate_way5_cell0 GND GND n1 W=1e-6 L=1e-6
mpway5_cell0 ML5 gate_way5_cell0 GND ML5 p1 W=2.4e-6 L=1e-6
mnway5_cell1 ML5 gate_way5_cell1 GND GND n1 W=1e-6 L=1e-6
mpway5_cell1 ML5 gate_way5_cell1 GND ML5 p1 W=2.4e-6 L=1e-6
mnway5_cell2 ML5 gate_way5_cell2 GND GND n1 W=1e-6 L=1e-6
mpway5_cell2 ML5 gate_way5_cell2 GND ML5 p1 W=2.4e-6 L=1e-6
mnway5_cell3 ML5 gate_way5_cell3 GND GND n1 W=1e-6 L=1e-6
mpway5_cell3 ML5 gate_way5_cell3 GND ML5 p1 W=2.4e-6 L=1e-6
mnway5_cell4 ML5 gate_way5_cell4 GND GND n1 W=1e-6 L=1e-6
mpway5_cell4 ML5 gate_way5_cell4 GND ML5 p1 W=2.4e-6 L=1e-6
mnway5_cell5 ML5 gate_way5_cell5 GND GND n1 W=1e-6 L=1e-6
mpway5_cell5 ML5 gate_way5_cell5 GND ML5 p1 W=2.4e-6 L=1e-6
mnway5_cell6 ML5 gate_way5_cell6 GND GND n1 W=1e-6 L=1e-6
mpway5_cell6 ML5 gate_way5_cell6 GND ML5 p1 W=2.4e-6 L=1e-6
mnway5_cell7 ML5 gate_way5_cell7 GND GND n1 W=1e-6 L=1e-6
mpway5_cell7 ML5 gate_way5_cell7 GND ML5 p1 W=2.4e-6 L=1e-6
mnway5_cell8 ML5 gate_way5_cell8 GND GND n1 W=1e-6 L=1e-6
mpway5_cell8 ML5 gate_way5_cell8 GND ML5 p1 W=2.4e-6 L=1e-6
mnway5_cell9 ML5 gate_way5_cell9 GND GND n1 W=1e-6 L=1e-6
mpway5_cell9 ML5 gate_way5_cell9 GND ML5 p1 W=2.4e-6 L=1e-6
mnway5_cell10 ML5 gate_way5_cell10 GND GND n1 W=1e-6 L=1e-6
mpway5_cell10 ML5 gate_way5_cell10 GND ML5 p1 W=2.4e-6 L=1e-6
mnway5_cell11 ML5 gate_way5_cell11 GND GND n1 W=1e-6 L=1e-6
mpway5_cell11 ML5 gate_way5_cell11 GND ML5 p1 W=2.4e-6 L=1e-6
mnway5_cell12 ML5 gate_way5_cell12 GND GND n1 W=1e-6 L=1e-6
mpway5_cell12 ML5 gate_way5_cell12 GND ML5 p1 W=2.4e-6 L=1e-6
mnway5_cell13 ML5 gate_way5_cell13 GND GND n1 W=1e-6 L=1e-6
mpway5_cell13 ML5 gate_way5_cell13 GND ML5 p1 W=2.4e-6 L=1e-6
mnway5_cell14 ML5 gate_way5_cell14 GND GND n1 W=1e-6 L=1e-6
mpway5_cell14 ML5 gate_way5_cell14 GND ML5 p1 W=2.4e-6 L=1e-6
mnway5_cell15 ML5 gate_way5_cell15 GND GND n1 W=1e-6 L=1e-6
mpway5_cell15 ML5 gate_way5_cell15 GND ML5 p1 W=2.4e-6 L=1e-6
mnway5_cell16 ML5 gate_way5_cell16 GND GND n1 W=1e-6 L=1e-6
mpway5_cell16 ML5 gate_way5_cell16 GND ML5 p1 W=2.4e-6 L=1e-6
mnway5_cell17 ML5 gate_way5_cell17 GND GND n1 W=1e-6 L=1e-6
mpway5_cell17 ML5 gate_way5_cell17 GND ML5 p1 W=2.4e-6 L=1e-6
mnway5_cell18 ML5 gate_way5_cell18 GND GND n1 W=1e-6 L=1e-6
mpway5_cell18 ML5 gate_way5_cell18 GND ML5 p1 W=2.4e-6 L=1e-6
mnway5_cell19 ML5 gate_way5_cell19 GND GND n1 W=1e-6 L=1e-6
mpway5_cell19 ML5 gate_way5_cell19 GND ML5 p1 W=2.4e-6 L=1e-6
mnway5_cell20 ML5 gate_way5_cell20 GND GND n1 W=1e-6 L=1e-6
mpway5_cell20 ML5 gate_way5_cell20 GND ML5 p1 W=2.4e-6 L=1e-6
mnway5_cell21 ML5 gate_way5_cell21 GND GND n1 W=1e-6 L=1e-6
mpway5_cell21 ML5 gate_way5_cell21 GND ML5 p1 W=2.4e-6 L=1e-6
mnway5_cell22 ML5 gate_way5_cell22 GND GND n1 W=1e-6 L=1e-6
mpway5_cell22 ML5 gate_way5_cell22 GND ML5 p1 W=2.4e-6 L=1e-6
mnway5_cell23 ML5 gate_way5_cell23 GND GND n1 W=1e-6 L=1e-6
mpway5_cell23 ML5 gate_way5_cell23 GND ML5 p1 W=2.4e-6 L=1e-6
mnway5_cell24 ML5 gate_way5_cell24 GND GND n1 W=1e-6 L=1e-6
mpway5_cell24 ML5 gate_way5_cell24 GND ML5 p1 W=2.4e-6 L=1e-6
mnway5_cell25 ML5 gate_way5_cell25 GND GND n1 W=1e-6 L=1e-6
mpway5_cell25 ML5 gate_way5_cell25 GND ML5 p1 W=2.4e-6 L=1e-6
mnway5_cell26 ML5 gate_way5_cell26 GND GND n1 W=1e-6 L=1e-6
mpway5_cell26 ML5 gate_way5_cell26 GND ML5 p1 W=2.4e-6 L=1e-6
mnway5_cell27 ML5 gate_way5_cell27 GND GND n1 W=1e-6 L=1e-6
mpway5_cell27 ML5 gate_way5_cell27 GND ML5 p1 W=2.4e-6 L=1e-6
mnway5_cell28 ML5 gate_way5_cell28 GND GND n1 W=1e-6 L=1e-6
mpway5_cell28 ML5 gate_way5_cell28 GND ML5 p1 W=2.4e-6 L=1e-6
mnway5_cell29 ML5 gate_way5_cell29 GND GND n1 W=1e-6 L=1e-6
mpway5_cell29 ML5 gate_way5_cell29 GND ML5 p1 W=2.4e-6 L=1e-6
mnway5_cell30 ML5 gate_way5_cell30 GND GND n1 W=1e-6 L=1e-6
mpway5_cell30 ML5 gate_way5_cell30 GND ML5 p1 W=2.4e-6 L=1e-6
mnway5_cell31 ML5 gate_way5_cell31 GND GND n1 W=1e-6 L=1e-6
mpway5_cell31 ML5 gate_way5_cell31 GND ML5 p1 W=2.4e-6 L=1e-6
mnway5_cell32 ML5 gate_way5_cell32 GND GND n1 W=1e-6 L=1e-6
mpway5_cell32 ML5 gate_way5_cell32 GND ML5 p1 W=2.4e-6 L=1e-6
mnway5_cell33 ML5 gate_way5_cell33 GND GND n1 W=1e-6 L=1e-6
mpway5_cell33 ML5 gate_way5_cell33 GND ML5 p1 W=2.4e-6 L=1e-6
mnway5_cell34 ML5 gate_way5_cell34 GND GND n1 W=1e-6 L=1e-6
mpway5_cell34 ML5 gate_way5_cell34 GND ML5 p1 W=2.4e-6 L=1e-6
mnway5_cell35 ML5 gate_way5_cell35 GND GND n1 W=1e-6 L=1e-6
mpway5_cell35 ML5 gate_way5_cell35 GND ML5 p1 W=2.4e-6 L=1e-6
mnway5_cell36 ML5 gate_way5_cell36 GND GND n1 W=1e-6 L=1e-6
mpway5_cell36 ML5 gate_way5_cell36 GND ML5 p1 W=2.4e-6 L=1e-6
mnway5_cell37 ML5 gate_way5_cell37 GND GND n1 W=1e-6 L=1e-6
mpway5_cell37 ML5 gate_way5_cell37 GND ML5 p1 W=2.4e-6 L=1e-6
mnway5_cell38 ML5 gate_way5_cell38 GND GND n1 W=1e-6 L=1e-6
mpway5_cell38 ML5 gate_way5_cell38 GND ML5 p1 W=2.4e-6 L=1e-6
mnway5_cell39 ML5 gate_way5_cell39 GND GND n1 W=1e-6 L=1e-6
mpway5_cell39 ML5 gate_way5_cell39 GND ML5 p1 W=2.4e-6 L=1e-6
mnway5_cell40 ML5 gate_way5_cell40 GND GND n1 W=1e-6 L=1e-6
mpway5_cell40 ML5 gate_way5_cell40 GND ML5 p1 W=2.4e-6 L=1e-6
mnway5_cell41 ML5 gate_way5_cell41 GND GND n1 W=1e-6 L=1e-6
mpway5_cell41 ML5 gate_way5_cell41 GND ML5 p1 W=2.4e-6 L=1e-6
mnway5_cell42 ML5 gate_way5_cell42 GND GND n1 W=1e-6 L=1e-6
mpway5_cell42 ML5 gate_way5_cell42 GND ML5 p1 W=2.4e-6 L=1e-6
mnway5_cell43 ML5 gate_way5_cell43 GND GND n1 W=1e-6 L=1e-6
mpway5_cell43 ML5 gate_way5_cell43 GND ML5 p1 W=2.4e-6 L=1e-6
mnway5_cell44 ML5 gate_way5_cell44 GND GND n1 W=1e-6 L=1e-6
mpway5_cell44 ML5 gate_way5_cell44 GND ML5 p1 W=2.4e-6 L=1e-6
mnway5_cell45 ML5 gate_way5_cell45 GND GND n1 W=1e-6 L=1e-6
mpway5_cell45 ML5 gate_way5_cell45 GND ML5 p1 W=2.4e-6 L=1e-6
mnway5_cell46 ML5 gate_way5_cell46 GND GND n1 W=1e-6 L=1e-6
mpway5_cell46 ML5 gate_way5_cell46 GND ML5 p1 W=2.4e-6 L=1e-6
mnway5_cell47 ML5 gate_way5_cell47 GND GND n1 W=1e-6 L=1e-6
mpway5_cell47 ML5 gate_way5_cell47 GND ML5 p1 W=2.4e-6 L=1e-6
mnway5_cell48 ML5 gate_way5_cell48 GND GND n1 W=1e-6 L=1e-6
mpway5_cell48 ML5 gate_way5_cell48 GND ML5 p1 W=2.4e-6 L=1e-6
mnway5_cell49 ML5 gate_way5_cell49 GND GND n1 W=1e-6 L=1e-6
mpway5_cell49 ML5 gate_way5_cell49 GND ML5 p1 W=2.4e-6 L=1e-6
mnway5_cell50 ML5 gate_way5_cell50 GND GND n1 W=1e-6 L=1e-6
mpway5_cell50 ML5 gate_way5_cell50 GND ML5 p1 W=2.4e-6 L=1e-6
mnway5_cell51 ML5 gate_way5_cell51 GND GND n1 W=1e-6 L=1e-6
mpway5_cell51 ML5 gate_way5_cell51 GND ML5 p1 W=2.4e-6 L=1e-6
mnway5_cell52 ML5 gate_way5_cell52 GND GND n1 W=1e-6 L=1e-6
mpway5_cell52 ML5 gate_way5_cell52 GND ML5 p1 W=2.4e-6 L=1e-6
mnway5_cell53 ML5 gate_way5_cell53 GND GND n1 W=1e-6 L=1e-6
mpway5_cell53 ML5 gate_way5_cell53 GND ML5 p1 W=2.4e-6 L=1e-6
mnway5_cell54 ML5 gate_way5_cell54 GND GND n1 W=1e-6 L=1e-6
mpway5_cell54 ML5 gate_way5_cell54 GND ML5 p1 W=2.4e-6 L=1e-6
mnway5_cell55 ML5 gate_way5_cell55 GND GND n1 W=1e-6 L=1e-6
mpway5_cell55 ML5 gate_way5_cell55 GND ML5 p1 W=2.4e-6 L=1e-6
mnway5_cell56 ML5 gate_way5_cell56 GND GND n1 W=1e-6 L=1e-6
mpway5_cell56 ML5 gate_way5_cell56 GND ML5 p1 W=2.4e-6 L=1e-6
mnway5_cell57 ML5 gate_way5_cell57 GND GND n1 W=1e-6 L=1e-6
mpway5_cell57 ML5 gate_way5_cell57 GND ML5 p1 W=2.4e-6 L=1e-6
mnway5_cell58 ML5 gate_way5_cell58 GND GND n1 W=1e-6 L=1e-6
mpway5_cell58 ML5 gate_way5_cell58 GND ML5 p1 W=2.4e-6 L=1e-6
mnway5_cell59 ML5 gate_way5_cell59 GND GND n1 W=1e-6 L=1e-6
mpway5_cell59 ML5 gate_way5_cell59 GND ML5 p1 W=2.4e-6 L=1e-6
mnway5_cell60 ML5 gate_way5_cell60 GND GND n1 W=1e-6 L=1e-6
mpway5_cell60 ML5 gate_way5_cell60 GND ML5 p1 W=2.4e-6 L=1e-6
mnway5_cell61 ML5 gate_way5_cell61 GND GND n1 W=1e-6 L=1e-6
mpway5_cell61 ML5 gate_way5_cell61 GND ML5 p1 W=2.4e-6 L=1e-6
mnway5_cell62 ML5 gate_way5_cell62 GND GND n1 W=1e-6 L=1e-6
mpway5_cell62 ML5 gate_way5_cell62 GND ML5 p1 W=2.4e-6 L=1e-6
mnway5_cell63 ML5 gate_way5_cell63 GND GND n1 W=1e-6 L=1e-6
mpway5_cell63 ML5 gate_way5_cell63 GND ML5 p1 W=2.4e-6 L=1e-6
mnway5_cell64 ML5 gate_way5_cell64 GND GND n1 W=1e-6 L=1e-6
mpway5_cell64 ML5 gate_way5_cell64 GND ML5 p1 W=2.4e-6 L=1e-6
mnway5_cell65 ML5 gate_way5_cell65 GND GND n1 W=1e-6 L=1e-6
mpway5_cell65 ML5 gate_way5_cell65 GND ML5 p1 W=2.4e-6 L=1e-6
mnway5_cell66 ML5 gate_way5_cell66 GND GND n1 W=1e-6 L=1e-6
mpway5_cell66 ML5 gate_way5_cell66 GND ML5 p1 W=2.4e-6 L=1e-6
mnway5_cell67 ML5 gate_way5_cell67 GND GND n1 W=1e-6 L=1e-6
mpway5_cell67 ML5 gate_way5_cell67 GND ML5 p1 W=2.4e-6 L=1e-6
mnway5_cell68 ML5 gate_way5_cell68 GND GND n1 W=1e-6 L=1e-6
mpway5_cell68 ML5 gate_way5_cell68 GND ML5 p1 W=2.4e-6 L=1e-6
mnway5_cell69 ML5 gate_way5_cell69 GND GND n1 W=1e-6 L=1e-6
mpway5_cell69 ML5 gate_way5_cell69 GND ML5 p1 W=2.4e-6 L=1e-6
mnway5_cell70 ML5 gate_way5_cell70 GND GND n1 W=1e-6 L=1e-6
mpway5_cell70 ML5 gate_way5_cell70 GND ML5 p1 W=2.4e-6 L=1e-6
mnway5_cell71 ML5 gate_way5_cell71 GND GND n1 W=1e-6 L=1e-6
mpway5_cell71 ML5 gate_way5_cell71 GND ML5 p1 W=2.4e-6 L=1e-6
mnway5_cell72 ML5 gate_way5_cell72 GND GND n1 W=1e-6 L=1e-6
mpway5_cell72 ML5 gate_way5_cell72 GND ML5 p1 W=2.4e-6 L=1e-6
mnway5_cell73 ML5 gate_way5_cell73 GND GND n1 W=1e-6 L=1e-6
mpway5_cell73 ML5 gate_way5_cell73 GND ML5 p1 W=2.4e-6 L=1e-6
mnway5_cell74 ML5 gate_way5_cell74 GND GND n1 W=1e-6 L=1e-6
mpway5_cell74 ML5 gate_way5_cell74 GND ML5 p1 W=2.4e-6 L=1e-6
mnway5_cell75 ML5 gate_way5_cell75 GND GND n1 W=1e-6 L=1e-6
mpway5_cell75 ML5 gate_way5_cell75 GND ML5 p1 W=2.4e-6 L=1e-6
mnway5_cell76 ML5 gate_way5_cell76 GND GND n1 W=1e-6 L=1e-6
mpway5_cell76 ML5 gate_way5_cell76 GND ML5 p1 W=2.4e-6 L=1e-6
mnway5_cell77 ML5 gate_way5_cell77 GND GND n1 W=1e-6 L=1e-6
mpway5_cell77 ML5 gate_way5_cell77 GND ML5 p1 W=2.4e-6 L=1e-6
mnway5_cell78 ML5 gate_way5_cell78 GND GND n1 W=1e-6 L=1e-6
mpway5_cell78 ML5 gate_way5_cell78 GND ML5 p1 W=2.4e-6 L=1e-6
mnway5_cell79 ML5 gate_way5_cell79 GND GND n1 W=1e-6 L=1e-6
mpway5_cell79 ML5 gate_way5_cell79 GND ML5 p1 W=2.4e-6 L=1e-6
mnway5_cell80 ML5 gate_way5_cell80 GND GND n1 W=1e-6 L=1e-6
mpway5_cell80 ML5 gate_way5_cell80 GND ML5 p1 W=2.4e-6 L=1e-6
mnway5_cell81 ML5 gate_way5_cell81 GND GND n1 W=1e-6 L=1e-6
mpway5_cell81 ML5 gate_way5_cell81 GND ML5 p1 W=2.4e-6 L=1e-6
mnway5_cell82 ML5 gate_way5_cell82 GND GND n1 W=1e-6 L=1e-6
mpway5_cell82 ML5 gate_way5_cell82 GND ML5 p1 W=2.4e-6 L=1e-6
mnway5_cell83 ML5 gate_way5_cell83 GND GND n1 W=1e-6 L=1e-6
mpway5_cell83 ML5 gate_way5_cell83 GND ML5 p1 W=2.4e-6 L=1e-6
mnway5_cell84 ML5 gate_way5_cell84 GND GND n1 W=1e-6 L=1e-6
mpway5_cell84 ML5 gate_way5_cell84 GND ML5 p1 W=2.4e-6 L=1e-6
mnway5_cell85 ML5 gate_way5_cell85 GND GND n1 W=1e-6 L=1e-6
mpway5_cell85 ML5 gate_way5_cell85 GND ML5 p1 W=2.4e-6 L=1e-6
mnway5_cell86 ML5 gate_way5_cell86 GND GND n1 W=1e-6 L=1e-6
mpway5_cell86 ML5 gate_way5_cell86 GND ML5 p1 W=2.4e-6 L=1e-6
mnway5_cell87 ML5 gate_way5_cell87 GND GND n1 W=1e-6 L=1e-6
mpway5_cell87 ML5 gate_way5_cell87 GND ML5 p1 W=2.4e-6 L=1e-6
mnway5_cell88 ML5 gate_way5_cell88 GND GND n1 W=1e-6 L=1e-6
mpway5_cell88 ML5 gate_way5_cell88 GND ML5 p1 W=2.4e-6 L=1e-6
mnway5_cell89 ML5 gate_way5_cell89 GND GND n1 W=1e-6 L=1e-6
mpway5_cell89 ML5 gate_way5_cell89 GND ML5 p1 W=2.4e-6 L=1e-6
mnway5_cell90 ML5 gate_way5_cell90 GND GND n1 W=1e-6 L=1e-6
mpway5_cell90 ML5 gate_way5_cell90 GND ML5 p1 W=2.4e-6 L=1e-6
mnway5_cell91 ML5 gate_way5_cell91 GND GND n1 W=1e-6 L=1e-6
mpway5_cell91 ML5 gate_way5_cell91 GND ML5 p1 W=2.4e-6 L=1e-6
mnway5_cell92 ML5 gate_way5_cell92 GND GND n1 W=1e-6 L=1e-6
mpway5_cell92 ML5 gate_way5_cell92 GND ML5 p1 W=2.4e-6 L=1e-6
mnway5_cell93 ML5 gate_way5_cell93 GND GND n1 W=1e-6 L=1e-6
mpway5_cell93 ML5 gate_way5_cell93 GND ML5 p1 W=2.4e-6 L=1e-6
mnway5_cell94 ML5 gate_way5_cell94 GND GND n1 W=1e-6 L=1e-6
mpway5_cell94 ML5 gate_way5_cell94 GND ML5 p1 W=2.4e-6 L=1e-6
mnway5_cell95 ML5 gate_way5_cell95 GND GND n1 W=1e-6 L=1e-6
mpway5_cell95 ML5 gate_way5_cell95 GND ML5 p1 W=2.4e-6 L=1e-6
mnway5_cell96 ML5 gate_way5_cell96 GND GND n1 W=1e-6 L=1e-6
mpway5_cell96 ML5 gate_way5_cell96 GND ML5 p1 W=2.4e-6 L=1e-6
mnway5_cell97 ML5 gate_way5_cell97 GND GND n1 W=1e-6 L=1e-6
mpway5_cell97 ML5 gate_way5_cell97 GND ML5 p1 W=2.4e-6 L=1e-6
mnway5_cell98 ML5 gate_way5_cell98 GND GND n1 W=1e-6 L=1e-6
mpway5_cell98 ML5 gate_way5_cell98 GND ML5 p1 W=2.4e-6 L=1e-6
mnway5_cell99 ML5 gate_way5_cell99 GND GND n1 W=1e-6 L=1e-6
mpway5_cell99 ML5 gate_way5_cell99 GND ML5 p1 W=2.4e-6 L=1e-6
mnway6_cell0 ML6 gate_way6_cell0 GND GND n1 W=1e-6 L=1e-6
mpway6_cell0 ML6 gate_way6_cell0 GND ML6 p1 W=2.4e-6 L=1e-6
mnway6_cell1 ML6 gate_way6_cell1 GND GND n1 W=1e-6 L=1e-6
mpway6_cell1 ML6 gate_way6_cell1 GND ML6 p1 W=2.4e-6 L=1e-6
mnway6_cell2 ML6 gate_way6_cell2 GND GND n1 W=1e-6 L=1e-6
mpway6_cell2 ML6 gate_way6_cell2 GND ML6 p1 W=2.4e-6 L=1e-6
mnway6_cell3 ML6 gate_way6_cell3 GND GND n1 W=1e-6 L=1e-6
mpway6_cell3 ML6 gate_way6_cell3 GND ML6 p1 W=2.4e-6 L=1e-6
mnway6_cell4 ML6 gate_way6_cell4 GND GND n1 W=1e-6 L=1e-6
mpway6_cell4 ML6 gate_way6_cell4 GND ML6 p1 W=2.4e-6 L=1e-6
mnway6_cell5 ML6 gate_way6_cell5 GND GND n1 W=1e-6 L=1e-6
mpway6_cell5 ML6 gate_way6_cell5 GND ML6 p1 W=2.4e-6 L=1e-6
mnway6_cell6 ML6 gate_way6_cell6 GND GND n1 W=1e-6 L=1e-6
mpway6_cell6 ML6 gate_way6_cell6 GND ML6 p1 W=2.4e-6 L=1e-6
mnway6_cell7 ML6 gate_way6_cell7 GND GND n1 W=1e-6 L=1e-6
mpway6_cell7 ML6 gate_way6_cell7 GND ML6 p1 W=2.4e-6 L=1e-6
mnway6_cell8 ML6 gate_way6_cell8 GND GND n1 W=1e-6 L=1e-6
mpway6_cell8 ML6 gate_way6_cell8 GND ML6 p1 W=2.4e-6 L=1e-6
mnway6_cell9 ML6 gate_way6_cell9 GND GND n1 W=1e-6 L=1e-6
mpway6_cell9 ML6 gate_way6_cell9 GND ML6 p1 W=2.4e-6 L=1e-6
mnway6_cell10 ML6 gate_way6_cell10 GND GND n1 W=1e-6 L=1e-6
mpway6_cell10 ML6 gate_way6_cell10 GND ML6 p1 W=2.4e-6 L=1e-6
mnway6_cell11 ML6 gate_way6_cell11 GND GND n1 W=1e-6 L=1e-6
mpway6_cell11 ML6 gate_way6_cell11 GND ML6 p1 W=2.4e-6 L=1e-6
mnway6_cell12 ML6 gate_way6_cell12 GND GND n1 W=1e-6 L=1e-6
mpway6_cell12 ML6 gate_way6_cell12 GND ML6 p1 W=2.4e-6 L=1e-6
mnway6_cell13 ML6 gate_way6_cell13 GND GND n1 W=1e-6 L=1e-6
mpway6_cell13 ML6 gate_way6_cell13 GND ML6 p1 W=2.4e-6 L=1e-6
mnway6_cell14 ML6 gate_way6_cell14 GND GND n1 W=1e-6 L=1e-6
mpway6_cell14 ML6 gate_way6_cell14 GND ML6 p1 W=2.4e-6 L=1e-6
mnway6_cell15 ML6 gate_way6_cell15 GND GND n1 W=1e-6 L=1e-6
mpway6_cell15 ML6 gate_way6_cell15 GND ML6 p1 W=2.4e-6 L=1e-6
mnway6_cell16 ML6 gate_way6_cell16 GND GND n1 W=1e-6 L=1e-6
mpway6_cell16 ML6 gate_way6_cell16 GND ML6 p1 W=2.4e-6 L=1e-6
mnway6_cell17 ML6 gate_way6_cell17 GND GND n1 W=1e-6 L=1e-6
mpway6_cell17 ML6 gate_way6_cell17 GND ML6 p1 W=2.4e-6 L=1e-6
mnway6_cell18 ML6 gate_way6_cell18 GND GND n1 W=1e-6 L=1e-6
mpway6_cell18 ML6 gate_way6_cell18 GND ML6 p1 W=2.4e-6 L=1e-6
mnway6_cell19 ML6 gate_way6_cell19 GND GND n1 W=1e-6 L=1e-6
mpway6_cell19 ML6 gate_way6_cell19 GND ML6 p1 W=2.4e-6 L=1e-6
mnway6_cell20 ML6 gate_way6_cell20 GND GND n1 W=1e-6 L=1e-6
mpway6_cell20 ML6 gate_way6_cell20 GND ML6 p1 W=2.4e-6 L=1e-6
mnway6_cell21 ML6 gate_way6_cell21 GND GND n1 W=1e-6 L=1e-6
mpway6_cell21 ML6 gate_way6_cell21 GND ML6 p1 W=2.4e-6 L=1e-6
mnway6_cell22 ML6 gate_way6_cell22 GND GND n1 W=1e-6 L=1e-6
mpway6_cell22 ML6 gate_way6_cell22 GND ML6 p1 W=2.4e-6 L=1e-6
mnway6_cell23 ML6 gate_way6_cell23 GND GND n1 W=1e-6 L=1e-6
mpway6_cell23 ML6 gate_way6_cell23 GND ML6 p1 W=2.4e-6 L=1e-6
mnway6_cell24 ML6 gate_way6_cell24 GND GND n1 W=1e-6 L=1e-6
mpway6_cell24 ML6 gate_way6_cell24 GND ML6 p1 W=2.4e-6 L=1e-6
mnway6_cell25 ML6 gate_way6_cell25 GND GND n1 W=1e-6 L=1e-6
mpway6_cell25 ML6 gate_way6_cell25 GND ML6 p1 W=2.4e-6 L=1e-6
mnway6_cell26 ML6 gate_way6_cell26 GND GND n1 W=1e-6 L=1e-6
mpway6_cell26 ML6 gate_way6_cell26 GND ML6 p1 W=2.4e-6 L=1e-6
mnway6_cell27 ML6 gate_way6_cell27 GND GND n1 W=1e-6 L=1e-6
mpway6_cell27 ML6 gate_way6_cell27 GND ML6 p1 W=2.4e-6 L=1e-6
mnway6_cell28 ML6 gate_way6_cell28 GND GND n1 W=1e-6 L=1e-6
mpway6_cell28 ML6 gate_way6_cell28 GND ML6 p1 W=2.4e-6 L=1e-6
mnway6_cell29 ML6 gate_way6_cell29 GND GND n1 W=1e-6 L=1e-6
mpway6_cell29 ML6 gate_way6_cell29 GND ML6 p1 W=2.4e-6 L=1e-6
mnway6_cell30 ML6 gate_way6_cell30 GND GND n1 W=1e-6 L=1e-6
mpway6_cell30 ML6 gate_way6_cell30 GND ML6 p1 W=2.4e-6 L=1e-6
mnway6_cell31 ML6 gate_way6_cell31 GND GND n1 W=1e-6 L=1e-6
mpway6_cell31 ML6 gate_way6_cell31 GND ML6 p1 W=2.4e-6 L=1e-6
mnway6_cell32 ML6 gate_way6_cell32 GND GND n1 W=1e-6 L=1e-6
mpway6_cell32 ML6 gate_way6_cell32 GND ML6 p1 W=2.4e-6 L=1e-6
mnway6_cell33 ML6 gate_way6_cell33 GND GND n1 W=1e-6 L=1e-6
mpway6_cell33 ML6 gate_way6_cell33 GND ML6 p1 W=2.4e-6 L=1e-6
mnway6_cell34 ML6 gate_way6_cell34 GND GND n1 W=1e-6 L=1e-6
mpway6_cell34 ML6 gate_way6_cell34 GND ML6 p1 W=2.4e-6 L=1e-6
mnway6_cell35 ML6 gate_way6_cell35 GND GND n1 W=1e-6 L=1e-6
mpway6_cell35 ML6 gate_way6_cell35 GND ML6 p1 W=2.4e-6 L=1e-6
mnway6_cell36 ML6 gate_way6_cell36 GND GND n1 W=1e-6 L=1e-6
mpway6_cell36 ML6 gate_way6_cell36 GND ML6 p1 W=2.4e-6 L=1e-6
mnway6_cell37 ML6 gate_way6_cell37 GND GND n1 W=1e-6 L=1e-6
mpway6_cell37 ML6 gate_way6_cell37 GND ML6 p1 W=2.4e-6 L=1e-6
mnway6_cell38 ML6 gate_way6_cell38 GND GND n1 W=1e-6 L=1e-6
mpway6_cell38 ML6 gate_way6_cell38 GND ML6 p1 W=2.4e-6 L=1e-6
mnway6_cell39 ML6 gate_way6_cell39 GND GND n1 W=1e-6 L=1e-6
mpway6_cell39 ML6 gate_way6_cell39 GND ML6 p1 W=2.4e-6 L=1e-6
mnway6_cell40 ML6 gate_way6_cell40 GND GND n1 W=1e-6 L=1e-6
mpway6_cell40 ML6 gate_way6_cell40 GND ML6 p1 W=2.4e-6 L=1e-6
mnway6_cell41 ML6 gate_way6_cell41 GND GND n1 W=1e-6 L=1e-6
mpway6_cell41 ML6 gate_way6_cell41 GND ML6 p1 W=2.4e-6 L=1e-6
mnway6_cell42 ML6 gate_way6_cell42 GND GND n1 W=1e-6 L=1e-6
mpway6_cell42 ML6 gate_way6_cell42 GND ML6 p1 W=2.4e-6 L=1e-6
mnway6_cell43 ML6 gate_way6_cell43 GND GND n1 W=1e-6 L=1e-6
mpway6_cell43 ML6 gate_way6_cell43 GND ML6 p1 W=2.4e-6 L=1e-6
mnway6_cell44 ML6 gate_way6_cell44 GND GND n1 W=1e-6 L=1e-6
mpway6_cell44 ML6 gate_way6_cell44 GND ML6 p1 W=2.4e-6 L=1e-6
mnway6_cell45 ML6 gate_way6_cell45 GND GND n1 W=1e-6 L=1e-6
mpway6_cell45 ML6 gate_way6_cell45 GND ML6 p1 W=2.4e-6 L=1e-6
mnway6_cell46 ML6 gate_way6_cell46 GND GND n1 W=1e-6 L=1e-6
mpway6_cell46 ML6 gate_way6_cell46 GND ML6 p1 W=2.4e-6 L=1e-6
mnway6_cell47 ML6 gate_way6_cell47 GND GND n1 W=1e-6 L=1e-6
mpway6_cell47 ML6 gate_way6_cell47 GND ML6 p1 W=2.4e-6 L=1e-6
mnway6_cell48 ML6 gate_way6_cell48 GND GND n1 W=1e-6 L=1e-6
mpway6_cell48 ML6 gate_way6_cell48 GND ML6 p1 W=2.4e-6 L=1e-6
mnway6_cell49 ML6 gate_way6_cell49 GND GND n1 W=1e-6 L=1e-6
mpway6_cell49 ML6 gate_way6_cell49 GND ML6 p1 W=2.4e-6 L=1e-6
mnway6_cell50 ML6 gate_way6_cell50 GND GND n1 W=1e-6 L=1e-6
mpway6_cell50 ML6 gate_way6_cell50 GND ML6 p1 W=2.4e-6 L=1e-6
mnway6_cell51 ML6 gate_way6_cell51 GND GND n1 W=1e-6 L=1e-6
mpway6_cell51 ML6 gate_way6_cell51 GND ML6 p1 W=2.4e-6 L=1e-6
mnway6_cell52 ML6 gate_way6_cell52 GND GND n1 W=1e-6 L=1e-6
mpway6_cell52 ML6 gate_way6_cell52 GND ML6 p1 W=2.4e-6 L=1e-6
mnway6_cell53 ML6 gate_way6_cell53 GND GND n1 W=1e-6 L=1e-6
mpway6_cell53 ML6 gate_way6_cell53 GND ML6 p1 W=2.4e-6 L=1e-6
mnway6_cell54 ML6 gate_way6_cell54 GND GND n1 W=1e-6 L=1e-6
mpway6_cell54 ML6 gate_way6_cell54 GND ML6 p1 W=2.4e-6 L=1e-6
mnway6_cell55 ML6 gate_way6_cell55 GND GND n1 W=1e-6 L=1e-6
mpway6_cell55 ML6 gate_way6_cell55 GND ML6 p1 W=2.4e-6 L=1e-6
mnway6_cell56 ML6 gate_way6_cell56 GND GND n1 W=1e-6 L=1e-6
mpway6_cell56 ML6 gate_way6_cell56 GND ML6 p1 W=2.4e-6 L=1e-6
mnway6_cell57 ML6 gate_way6_cell57 GND GND n1 W=1e-6 L=1e-6
mpway6_cell57 ML6 gate_way6_cell57 GND ML6 p1 W=2.4e-6 L=1e-6
mnway6_cell58 ML6 gate_way6_cell58 GND GND n1 W=1e-6 L=1e-6
mpway6_cell58 ML6 gate_way6_cell58 GND ML6 p1 W=2.4e-6 L=1e-6
mnway6_cell59 ML6 gate_way6_cell59 GND GND n1 W=1e-6 L=1e-6
mpway6_cell59 ML6 gate_way6_cell59 GND ML6 p1 W=2.4e-6 L=1e-6
mnway6_cell60 ML6 gate_way6_cell60 GND GND n1 W=1e-6 L=1e-6
mpway6_cell60 ML6 gate_way6_cell60 GND ML6 p1 W=2.4e-6 L=1e-6
mnway6_cell61 ML6 gate_way6_cell61 GND GND n1 W=1e-6 L=1e-6
mpway6_cell61 ML6 gate_way6_cell61 GND ML6 p1 W=2.4e-6 L=1e-6
mnway6_cell62 ML6 gate_way6_cell62 GND GND n1 W=1e-6 L=1e-6
mpway6_cell62 ML6 gate_way6_cell62 GND ML6 p1 W=2.4e-6 L=1e-6
mnway6_cell63 ML6 gate_way6_cell63 GND GND n1 W=1e-6 L=1e-6
mpway6_cell63 ML6 gate_way6_cell63 GND ML6 p1 W=2.4e-6 L=1e-6
mnway6_cell64 ML6 gate_way6_cell64 GND GND n1 W=1e-6 L=1e-6
mpway6_cell64 ML6 gate_way6_cell64 GND ML6 p1 W=2.4e-6 L=1e-6
mnway6_cell65 ML6 gate_way6_cell65 GND GND n1 W=1e-6 L=1e-6
mpway6_cell65 ML6 gate_way6_cell65 GND ML6 p1 W=2.4e-6 L=1e-6
mnway6_cell66 ML6 gate_way6_cell66 GND GND n1 W=1e-6 L=1e-6
mpway6_cell66 ML6 gate_way6_cell66 GND ML6 p1 W=2.4e-6 L=1e-6
mnway6_cell67 ML6 gate_way6_cell67 GND GND n1 W=1e-6 L=1e-6
mpway6_cell67 ML6 gate_way6_cell67 GND ML6 p1 W=2.4e-6 L=1e-6
mnway6_cell68 ML6 gate_way6_cell68 GND GND n1 W=1e-6 L=1e-6
mpway6_cell68 ML6 gate_way6_cell68 GND ML6 p1 W=2.4e-6 L=1e-6
mnway6_cell69 ML6 gate_way6_cell69 GND GND n1 W=1e-6 L=1e-6
mpway6_cell69 ML6 gate_way6_cell69 GND ML6 p1 W=2.4e-6 L=1e-6
mnway6_cell70 ML6 gate_way6_cell70 GND GND n1 W=1e-6 L=1e-6
mpway6_cell70 ML6 gate_way6_cell70 GND ML6 p1 W=2.4e-6 L=1e-6
mnway6_cell71 ML6 gate_way6_cell71 GND GND n1 W=1e-6 L=1e-6
mpway6_cell71 ML6 gate_way6_cell71 GND ML6 p1 W=2.4e-6 L=1e-6
mnway6_cell72 ML6 gate_way6_cell72 GND GND n1 W=1e-6 L=1e-6
mpway6_cell72 ML6 gate_way6_cell72 GND ML6 p1 W=2.4e-6 L=1e-6
mnway6_cell73 ML6 gate_way6_cell73 GND GND n1 W=1e-6 L=1e-6
mpway6_cell73 ML6 gate_way6_cell73 GND ML6 p1 W=2.4e-6 L=1e-6
mnway6_cell74 ML6 gate_way6_cell74 GND GND n1 W=1e-6 L=1e-6
mpway6_cell74 ML6 gate_way6_cell74 GND ML6 p1 W=2.4e-6 L=1e-6
mnway6_cell75 ML6 gate_way6_cell75 GND GND n1 W=1e-6 L=1e-6
mpway6_cell75 ML6 gate_way6_cell75 GND ML6 p1 W=2.4e-6 L=1e-6
mnway6_cell76 ML6 gate_way6_cell76 GND GND n1 W=1e-6 L=1e-6
mpway6_cell76 ML6 gate_way6_cell76 GND ML6 p1 W=2.4e-6 L=1e-6
mnway6_cell77 ML6 gate_way6_cell77 GND GND n1 W=1e-6 L=1e-6
mpway6_cell77 ML6 gate_way6_cell77 GND ML6 p1 W=2.4e-6 L=1e-6
mnway6_cell78 ML6 gate_way6_cell78 GND GND n1 W=1e-6 L=1e-6
mpway6_cell78 ML6 gate_way6_cell78 GND ML6 p1 W=2.4e-6 L=1e-6
mnway6_cell79 ML6 gate_way6_cell79 GND GND n1 W=1e-6 L=1e-6
mpway6_cell79 ML6 gate_way6_cell79 GND ML6 p1 W=2.4e-6 L=1e-6
mnway6_cell80 ML6 gate_way6_cell80 GND GND n1 W=1e-6 L=1e-6
mpway6_cell80 ML6 gate_way6_cell80 GND ML6 p1 W=2.4e-6 L=1e-6
mnway6_cell81 ML6 gate_way6_cell81 GND GND n1 W=1e-6 L=1e-6
mpway6_cell81 ML6 gate_way6_cell81 GND ML6 p1 W=2.4e-6 L=1e-6
mnway6_cell82 ML6 gate_way6_cell82 GND GND n1 W=1e-6 L=1e-6
mpway6_cell82 ML6 gate_way6_cell82 GND ML6 p1 W=2.4e-6 L=1e-6
mnway6_cell83 ML6 gate_way6_cell83 GND GND n1 W=1e-6 L=1e-6
mpway6_cell83 ML6 gate_way6_cell83 GND ML6 p1 W=2.4e-6 L=1e-6
mnway6_cell84 ML6 gate_way6_cell84 GND GND n1 W=1e-6 L=1e-6
mpway6_cell84 ML6 gate_way6_cell84 GND ML6 p1 W=2.4e-6 L=1e-6
mnway6_cell85 ML6 gate_way6_cell85 GND GND n1 W=1e-6 L=1e-6
mpway6_cell85 ML6 gate_way6_cell85 GND ML6 p1 W=2.4e-6 L=1e-6
mnway6_cell86 ML6 gate_way6_cell86 GND GND n1 W=1e-6 L=1e-6
mpway6_cell86 ML6 gate_way6_cell86 GND ML6 p1 W=2.4e-6 L=1e-6
mnway6_cell87 ML6 gate_way6_cell87 GND GND n1 W=1e-6 L=1e-6
mpway6_cell87 ML6 gate_way6_cell87 GND ML6 p1 W=2.4e-6 L=1e-6
mnway6_cell88 ML6 gate_way6_cell88 GND GND n1 W=1e-6 L=1e-6
mpway6_cell88 ML6 gate_way6_cell88 GND ML6 p1 W=2.4e-6 L=1e-6
mnway6_cell89 ML6 gate_way6_cell89 GND GND n1 W=1e-6 L=1e-6
mpway6_cell89 ML6 gate_way6_cell89 GND ML6 p1 W=2.4e-6 L=1e-6
mnway6_cell90 ML6 gate_way6_cell90 GND GND n1 W=1e-6 L=1e-6
mpway6_cell90 ML6 gate_way6_cell90 GND ML6 p1 W=2.4e-6 L=1e-6
mnway6_cell91 ML6 gate_way6_cell91 GND GND n1 W=1e-6 L=1e-6
mpway6_cell91 ML6 gate_way6_cell91 GND ML6 p1 W=2.4e-6 L=1e-6
mnway6_cell92 ML6 gate_way6_cell92 GND GND n1 W=1e-6 L=1e-6
mpway6_cell92 ML6 gate_way6_cell92 GND ML6 p1 W=2.4e-6 L=1e-6
mnway6_cell93 ML6 gate_way6_cell93 GND GND n1 W=1e-6 L=1e-6
mpway6_cell93 ML6 gate_way6_cell93 GND ML6 p1 W=2.4e-6 L=1e-6
mnway6_cell94 ML6 gate_way6_cell94 GND GND n1 W=1e-6 L=1e-6
mpway6_cell94 ML6 gate_way6_cell94 GND ML6 p1 W=2.4e-6 L=1e-6
mnway6_cell95 ML6 gate_way6_cell95 GND GND n1 W=1e-6 L=1e-6
mpway6_cell95 ML6 gate_way6_cell95 GND ML6 p1 W=2.4e-6 L=1e-6
mnway6_cell96 ML6 gate_way6_cell96 GND GND n1 W=1e-6 L=1e-6
mpway6_cell96 ML6 gate_way6_cell96 GND ML6 p1 W=2.4e-6 L=1e-6
mnway6_cell97 ML6 gate_way6_cell97 GND GND n1 W=1e-6 L=1e-6
mpway6_cell97 ML6 gate_way6_cell97 GND ML6 p1 W=2.4e-6 L=1e-6
mnway6_cell98 ML6 gate_way6_cell98 GND GND n1 W=1e-6 L=1e-6
mpway6_cell98 ML6 gate_way6_cell98 GND ML6 p1 W=2.4e-6 L=1e-6
mnway6_cell99 ML6 gate_way6_cell99 GND GND n1 W=1e-6 L=1e-6
mpway6_cell99 ML6 gate_way6_cell99 GND ML6 p1 W=2.4e-6 L=1e-6
mnway7_cell0 ML7 gate_way7_cell0 GND GND n1 W=1e-6 L=1e-6
mpway7_cell0 ML7 gate_way7_cell0 GND ML7 p1 W=2.4e-6 L=1e-6
mnway7_cell1 ML7 gate_way7_cell1 GND GND n1 W=1e-6 L=1e-6
mpway7_cell1 ML7 gate_way7_cell1 GND ML7 p1 W=2.4e-6 L=1e-6
mnway7_cell2 ML7 gate_way7_cell2 GND GND n1 W=1e-6 L=1e-6
mpway7_cell2 ML7 gate_way7_cell2 GND ML7 p1 W=2.4e-6 L=1e-6
mnway7_cell3 ML7 gate_way7_cell3 GND GND n1 W=1e-6 L=1e-6
mpway7_cell3 ML7 gate_way7_cell3 GND ML7 p1 W=2.4e-6 L=1e-6
mnway7_cell4 ML7 gate_way7_cell4 GND GND n1 W=1e-6 L=1e-6
mpway7_cell4 ML7 gate_way7_cell4 GND ML7 p1 W=2.4e-6 L=1e-6
mnway7_cell5 ML7 gate_way7_cell5 GND GND n1 W=1e-6 L=1e-6
mpway7_cell5 ML7 gate_way7_cell5 GND ML7 p1 W=2.4e-6 L=1e-6
mnway7_cell6 ML7 gate_way7_cell6 GND GND n1 W=1e-6 L=1e-6
mpway7_cell6 ML7 gate_way7_cell6 GND ML7 p1 W=2.4e-6 L=1e-6
mnway7_cell7 ML7 gate_way7_cell7 GND GND n1 W=1e-6 L=1e-6
mpway7_cell7 ML7 gate_way7_cell7 GND ML7 p1 W=2.4e-6 L=1e-6
mnway7_cell8 ML7 gate_way7_cell8 GND GND n1 W=1e-6 L=1e-6
mpway7_cell8 ML7 gate_way7_cell8 GND ML7 p1 W=2.4e-6 L=1e-6
mnway7_cell9 ML7 gate_way7_cell9 GND GND n1 W=1e-6 L=1e-6
mpway7_cell9 ML7 gate_way7_cell9 GND ML7 p1 W=2.4e-6 L=1e-6
mnway7_cell10 ML7 gate_way7_cell10 GND GND n1 W=1e-6 L=1e-6
mpway7_cell10 ML7 gate_way7_cell10 GND ML7 p1 W=2.4e-6 L=1e-6
mnway7_cell11 ML7 gate_way7_cell11 GND GND n1 W=1e-6 L=1e-6
mpway7_cell11 ML7 gate_way7_cell11 GND ML7 p1 W=2.4e-6 L=1e-6
mnway7_cell12 ML7 gate_way7_cell12 GND GND n1 W=1e-6 L=1e-6
mpway7_cell12 ML7 gate_way7_cell12 GND ML7 p1 W=2.4e-6 L=1e-6
mnway7_cell13 ML7 gate_way7_cell13 GND GND n1 W=1e-6 L=1e-6
mpway7_cell13 ML7 gate_way7_cell13 GND ML7 p1 W=2.4e-6 L=1e-6
mnway7_cell14 ML7 gate_way7_cell14 GND GND n1 W=1e-6 L=1e-6
mpway7_cell14 ML7 gate_way7_cell14 GND ML7 p1 W=2.4e-6 L=1e-6
mnway7_cell15 ML7 gate_way7_cell15 GND GND n1 W=1e-6 L=1e-6
mpway7_cell15 ML7 gate_way7_cell15 GND ML7 p1 W=2.4e-6 L=1e-6
mnway7_cell16 ML7 gate_way7_cell16 GND GND n1 W=1e-6 L=1e-6
mpway7_cell16 ML7 gate_way7_cell16 GND ML7 p1 W=2.4e-6 L=1e-6
mnway7_cell17 ML7 gate_way7_cell17 GND GND n1 W=1e-6 L=1e-6
mpway7_cell17 ML7 gate_way7_cell17 GND ML7 p1 W=2.4e-6 L=1e-6
mnway7_cell18 ML7 gate_way7_cell18 GND GND n1 W=1e-6 L=1e-6
mpway7_cell18 ML7 gate_way7_cell18 GND ML7 p1 W=2.4e-6 L=1e-6
mnway7_cell19 ML7 gate_way7_cell19 GND GND n1 W=1e-6 L=1e-6
mpway7_cell19 ML7 gate_way7_cell19 GND ML7 p1 W=2.4e-6 L=1e-6
mnway7_cell20 ML7 gate_way7_cell20 GND GND n1 W=1e-6 L=1e-6
mpway7_cell20 ML7 gate_way7_cell20 GND ML7 p1 W=2.4e-6 L=1e-6
mnway7_cell21 ML7 gate_way7_cell21 GND GND n1 W=1e-6 L=1e-6
mpway7_cell21 ML7 gate_way7_cell21 GND ML7 p1 W=2.4e-6 L=1e-6
mnway7_cell22 ML7 gate_way7_cell22 GND GND n1 W=1e-6 L=1e-6
mpway7_cell22 ML7 gate_way7_cell22 GND ML7 p1 W=2.4e-6 L=1e-6
mnway7_cell23 ML7 gate_way7_cell23 GND GND n1 W=1e-6 L=1e-6
mpway7_cell23 ML7 gate_way7_cell23 GND ML7 p1 W=2.4e-6 L=1e-6
mnway7_cell24 ML7 gate_way7_cell24 GND GND n1 W=1e-6 L=1e-6
mpway7_cell24 ML7 gate_way7_cell24 GND ML7 p1 W=2.4e-6 L=1e-6
mnway7_cell25 ML7 gate_way7_cell25 GND GND n1 W=1e-6 L=1e-6
mpway7_cell25 ML7 gate_way7_cell25 GND ML7 p1 W=2.4e-6 L=1e-6
mnway7_cell26 ML7 gate_way7_cell26 GND GND n1 W=1e-6 L=1e-6
mpway7_cell26 ML7 gate_way7_cell26 GND ML7 p1 W=2.4e-6 L=1e-6
mnway7_cell27 ML7 gate_way7_cell27 GND GND n1 W=1e-6 L=1e-6
mpway7_cell27 ML7 gate_way7_cell27 GND ML7 p1 W=2.4e-6 L=1e-6
mnway7_cell28 ML7 gate_way7_cell28 GND GND n1 W=1e-6 L=1e-6
mpway7_cell28 ML7 gate_way7_cell28 GND ML7 p1 W=2.4e-6 L=1e-6
mnway7_cell29 ML7 gate_way7_cell29 GND GND n1 W=1e-6 L=1e-6
mpway7_cell29 ML7 gate_way7_cell29 GND ML7 p1 W=2.4e-6 L=1e-6
mnway7_cell30 ML7 gate_way7_cell30 GND GND n1 W=1e-6 L=1e-6
mpway7_cell30 ML7 gate_way7_cell30 GND ML7 p1 W=2.4e-6 L=1e-6
mnway7_cell31 ML7 gate_way7_cell31 GND GND n1 W=1e-6 L=1e-6
mpway7_cell31 ML7 gate_way7_cell31 GND ML7 p1 W=2.4e-6 L=1e-6
mnway7_cell32 ML7 gate_way7_cell32 GND GND n1 W=1e-6 L=1e-6
mpway7_cell32 ML7 gate_way7_cell32 GND ML7 p1 W=2.4e-6 L=1e-6
mnway7_cell33 ML7 gate_way7_cell33 GND GND n1 W=1e-6 L=1e-6
mpway7_cell33 ML7 gate_way7_cell33 GND ML7 p1 W=2.4e-6 L=1e-6
mnway7_cell34 ML7 gate_way7_cell34 GND GND n1 W=1e-6 L=1e-6
mpway7_cell34 ML7 gate_way7_cell34 GND ML7 p1 W=2.4e-6 L=1e-6
mnway7_cell35 ML7 gate_way7_cell35 GND GND n1 W=1e-6 L=1e-6
mpway7_cell35 ML7 gate_way7_cell35 GND ML7 p1 W=2.4e-6 L=1e-6
mnway7_cell36 ML7 gate_way7_cell36 GND GND n1 W=1e-6 L=1e-6
mpway7_cell36 ML7 gate_way7_cell36 GND ML7 p1 W=2.4e-6 L=1e-6
mnway7_cell37 ML7 gate_way7_cell37 GND GND n1 W=1e-6 L=1e-6
mpway7_cell37 ML7 gate_way7_cell37 GND ML7 p1 W=2.4e-6 L=1e-6
mnway7_cell38 ML7 gate_way7_cell38 GND GND n1 W=1e-6 L=1e-6
mpway7_cell38 ML7 gate_way7_cell38 GND ML7 p1 W=2.4e-6 L=1e-6
mnway7_cell39 ML7 gate_way7_cell39 GND GND n1 W=1e-6 L=1e-6
mpway7_cell39 ML7 gate_way7_cell39 GND ML7 p1 W=2.4e-6 L=1e-6
mnway7_cell40 ML7 gate_way7_cell40 GND GND n1 W=1e-6 L=1e-6
mpway7_cell40 ML7 gate_way7_cell40 GND ML7 p1 W=2.4e-6 L=1e-6
mnway7_cell41 ML7 gate_way7_cell41 GND GND n1 W=1e-6 L=1e-6
mpway7_cell41 ML7 gate_way7_cell41 GND ML7 p1 W=2.4e-6 L=1e-6
mnway7_cell42 ML7 gate_way7_cell42 GND GND n1 W=1e-6 L=1e-6
mpway7_cell42 ML7 gate_way7_cell42 GND ML7 p1 W=2.4e-6 L=1e-6
mnway7_cell43 ML7 gate_way7_cell43 GND GND n1 W=1e-6 L=1e-6
mpway7_cell43 ML7 gate_way7_cell43 GND ML7 p1 W=2.4e-6 L=1e-6
mnway7_cell44 ML7 gate_way7_cell44 GND GND n1 W=1e-6 L=1e-6
mpway7_cell44 ML7 gate_way7_cell44 GND ML7 p1 W=2.4e-6 L=1e-6
mnway7_cell45 ML7 gate_way7_cell45 GND GND n1 W=1e-6 L=1e-6
mpway7_cell45 ML7 gate_way7_cell45 GND ML7 p1 W=2.4e-6 L=1e-6
mnway7_cell46 ML7 gate_way7_cell46 GND GND n1 W=1e-6 L=1e-6
mpway7_cell46 ML7 gate_way7_cell46 GND ML7 p1 W=2.4e-6 L=1e-6
mnway7_cell47 ML7 gate_way7_cell47 GND GND n1 W=1e-6 L=1e-6
mpway7_cell47 ML7 gate_way7_cell47 GND ML7 p1 W=2.4e-6 L=1e-6
mnway7_cell48 ML7 gate_way7_cell48 GND GND n1 W=1e-6 L=1e-6
mpway7_cell48 ML7 gate_way7_cell48 GND ML7 p1 W=2.4e-6 L=1e-6
mnway7_cell49 ML7 gate_way7_cell49 GND GND n1 W=1e-6 L=1e-6
mpway7_cell49 ML7 gate_way7_cell49 GND ML7 p1 W=2.4e-6 L=1e-6
mnway7_cell50 ML7 gate_way7_cell50 GND GND n1 W=1e-6 L=1e-6
mpway7_cell50 ML7 gate_way7_cell50 GND ML7 p1 W=2.4e-6 L=1e-6
mnway7_cell51 ML7 gate_way7_cell51 GND GND n1 W=1e-6 L=1e-6
mpway7_cell51 ML7 gate_way7_cell51 GND ML7 p1 W=2.4e-6 L=1e-6
mnway7_cell52 ML7 gate_way7_cell52 GND GND n1 W=1e-6 L=1e-6
mpway7_cell52 ML7 gate_way7_cell52 GND ML7 p1 W=2.4e-6 L=1e-6
mnway7_cell53 ML7 gate_way7_cell53 GND GND n1 W=1e-6 L=1e-6
mpway7_cell53 ML7 gate_way7_cell53 GND ML7 p1 W=2.4e-6 L=1e-6
mnway7_cell54 ML7 gate_way7_cell54 GND GND n1 W=1e-6 L=1e-6
mpway7_cell54 ML7 gate_way7_cell54 GND ML7 p1 W=2.4e-6 L=1e-6
mnway7_cell55 ML7 gate_way7_cell55 GND GND n1 W=1e-6 L=1e-6
mpway7_cell55 ML7 gate_way7_cell55 GND ML7 p1 W=2.4e-6 L=1e-6
mnway7_cell56 ML7 gate_way7_cell56 GND GND n1 W=1e-6 L=1e-6
mpway7_cell56 ML7 gate_way7_cell56 GND ML7 p1 W=2.4e-6 L=1e-6
mnway7_cell57 ML7 gate_way7_cell57 GND GND n1 W=1e-6 L=1e-6
mpway7_cell57 ML7 gate_way7_cell57 GND ML7 p1 W=2.4e-6 L=1e-6
mnway7_cell58 ML7 gate_way7_cell58 GND GND n1 W=1e-6 L=1e-6
mpway7_cell58 ML7 gate_way7_cell58 GND ML7 p1 W=2.4e-6 L=1e-6
mnway7_cell59 ML7 gate_way7_cell59 GND GND n1 W=1e-6 L=1e-6
mpway7_cell59 ML7 gate_way7_cell59 GND ML7 p1 W=2.4e-6 L=1e-6
mnway7_cell60 ML7 gate_way7_cell60 GND GND n1 W=1e-6 L=1e-6
mpway7_cell60 ML7 gate_way7_cell60 GND ML7 p1 W=2.4e-6 L=1e-6
mnway7_cell61 ML7 gate_way7_cell61 GND GND n1 W=1e-6 L=1e-6
mpway7_cell61 ML7 gate_way7_cell61 GND ML7 p1 W=2.4e-6 L=1e-6
mnway7_cell62 ML7 gate_way7_cell62 GND GND n1 W=1e-6 L=1e-6
mpway7_cell62 ML7 gate_way7_cell62 GND ML7 p1 W=2.4e-6 L=1e-6
mnway7_cell63 ML7 gate_way7_cell63 GND GND n1 W=1e-6 L=1e-6
mpway7_cell63 ML7 gate_way7_cell63 GND ML7 p1 W=2.4e-6 L=1e-6
mnway7_cell64 ML7 gate_way7_cell64 GND GND n1 W=1e-6 L=1e-6
mpway7_cell64 ML7 gate_way7_cell64 GND ML7 p1 W=2.4e-6 L=1e-6
mnway7_cell65 ML7 gate_way7_cell65 GND GND n1 W=1e-6 L=1e-6
mpway7_cell65 ML7 gate_way7_cell65 GND ML7 p1 W=2.4e-6 L=1e-6
mnway7_cell66 ML7 gate_way7_cell66 GND GND n1 W=1e-6 L=1e-6
mpway7_cell66 ML7 gate_way7_cell66 GND ML7 p1 W=2.4e-6 L=1e-6
mnway7_cell67 ML7 gate_way7_cell67 GND GND n1 W=1e-6 L=1e-6
mpway7_cell67 ML7 gate_way7_cell67 GND ML7 p1 W=2.4e-6 L=1e-6
mnway7_cell68 ML7 gate_way7_cell68 GND GND n1 W=1e-6 L=1e-6
mpway7_cell68 ML7 gate_way7_cell68 GND ML7 p1 W=2.4e-6 L=1e-6
mnway7_cell69 ML7 gate_way7_cell69 GND GND n1 W=1e-6 L=1e-6
mpway7_cell69 ML7 gate_way7_cell69 GND ML7 p1 W=2.4e-6 L=1e-6
mnway7_cell70 ML7 gate_way7_cell70 GND GND n1 W=1e-6 L=1e-6
mpway7_cell70 ML7 gate_way7_cell70 GND ML7 p1 W=2.4e-6 L=1e-6
mnway7_cell71 ML7 gate_way7_cell71 GND GND n1 W=1e-6 L=1e-6
mpway7_cell71 ML7 gate_way7_cell71 GND ML7 p1 W=2.4e-6 L=1e-6
mnway7_cell72 ML7 gate_way7_cell72 GND GND n1 W=1e-6 L=1e-6
mpway7_cell72 ML7 gate_way7_cell72 GND ML7 p1 W=2.4e-6 L=1e-6
mnway7_cell73 ML7 gate_way7_cell73 GND GND n1 W=1e-6 L=1e-6
mpway7_cell73 ML7 gate_way7_cell73 GND ML7 p1 W=2.4e-6 L=1e-6
mnway7_cell74 ML7 gate_way7_cell74 GND GND n1 W=1e-6 L=1e-6
mpway7_cell74 ML7 gate_way7_cell74 GND ML7 p1 W=2.4e-6 L=1e-6
mnway7_cell75 ML7 gate_way7_cell75 GND GND n1 W=1e-6 L=1e-6
mpway7_cell75 ML7 gate_way7_cell75 GND ML7 p1 W=2.4e-6 L=1e-6
mnway7_cell76 ML7 gate_way7_cell76 GND GND n1 W=1e-6 L=1e-6
mpway7_cell76 ML7 gate_way7_cell76 GND ML7 p1 W=2.4e-6 L=1e-6
mnway7_cell77 ML7 gate_way7_cell77 GND GND n1 W=1e-6 L=1e-6
mpway7_cell77 ML7 gate_way7_cell77 GND ML7 p1 W=2.4e-6 L=1e-6
mnway7_cell78 ML7 gate_way7_cell78 GND GND n1 W=1e-6 L=1e-6
mpway7_cell78 ML7 gate_way7_cell78 GND ML7 p1 W=2.4e-6 L=1e-6
mnway7_cell79 ML7 gate_way7_cell79 GND GND n1 W=1e-6 L=1e-6
mpway7_cell79 ML7 gate_way7_cell79 GND ML7 p1 W=2.4e-6 L=1e-6
mnway7_cell80 ML7 gate_way7_cell80 GND GND n1 W=1e-6 L=1e-6
mpway7_cell80 ML7 gate_way7_cell80 GND ML7 p1 W=2.4e-6 L=1e-6
mnway7_cell81 ML7 gate_way7_cell81 GND GND n1 W=1e-6 L=1e-6
mpway7_cell81 ML7 gate_way7_cell81 GND ML7 p1 W=2.4e-6 L=1e-6
mnway7_cell82 ML7 gate_way7_cell82 GND GND n1 W=1e-6 L=1e-6
mpway7_cell82 ML7 gate_way7_cell82 GND ML7 p1 W=2.4e-6 L=1e-6
mnway7_cell83 ML7 gate_way7_cell83 GND GND n1 W=1e-6 L=1e-6
mpway7_cell83 ML7 gate_way7_cell83 GND ML7 p1 W=2.4e-6 L=1e-6
mnway7_cell84 ML7 gate_way7_cell84 GND GND n1 W=1e-6 L=1e-6
mpway7_cell84 ML7 gate_way7_cell84 GND ML7 p1 W=2.4e-6 L=1e-6
mnway7_cell85 ML7 gate_way7_cell85 GND GND n1 W=1e-6 L=1e-6
mpway7_cell85 ML7 gate_way7_cell85 GND ML7 p1 W=2.4e-6 L=1e-6
mnway7_cell86 ML7 gate_way7_cell86 GND GND n1 W=1e-6 L=1e-6
mpway7_cell86 ML7 gate_way7_cell86 GND ML7 p1 W=2.4e-6 L=1e-6
mnway7_cell87 ML7 gate_way7_cell87 GND GND n1 W=1e-6 L=1e-6
mpway7_cell87 ML7 gate_way7_cell87 GND ML7 p1 W=2.4e-6 L=1e-6
mnway7_cell88 ML7 gate_way7_cell88 GND GND n1 W=1e-6 L=1e-6
mpway7_cell88 ML7 gate_way7_cell88 GND ML7 p1 W=2.4e-6 L=1e-6
mnway7_cell89 ML7 gate_way7_cell89 GND GND n1 W=1e-6 L=1e-6
mpway7_cell89 ML7 gate_way7_cell89 GND ML7 p1 W=2.4e-6 L=1e-6
mnway7_cell90 ML7 gate_way7_cell90 GND GND n1 W=1e-6 L=1e-6
mpway7_cell90 ML7 gate_way7_cell90 GND ML7 p1 W=2.4e-6 L=1e-6
mnway7_cell91 ML7 gate_way7_cell91 GND GND n1 W=1e-6 L=1e-6
mpway7_cell91 ML7 gate_way7_cell91 GND ML7 p1 W=2.4e-6 L=1e-6
mnway7_cell92 ML7 gate_way7_cell92 GND GND n1 W=1e-6 L=1e-6
mpway7_cell92 ML7 gate_way7_cell92 GND ML7 p1 W=2.4e-6 L=1e-6
mnway7_cell93 ML7 gate_way7_cell93 GND GND n1 W=1e-6 L=1e-6
mpway7_cell93 ML7 gate_way7_cell93 GND ML7 p1 W=2.4e-6 L=1e-6
mnway7_cell94 ML7 gate_way7_cell94 GND GND n1 W=1e-6 L=1e-6
mpway7_cell94 ML7 gate_way7_cell94 GND ML7 p1 W=2.4e-6 L=1e-6
mnway7_cell95 ML7 gate_way7_cell95 GND GND n1 W=1e-6 L=1e-6
mpway7_cell95 ML7 gate_way7_cell95 GND ML7 p1 W=2.4e-6 L=1e-6
mnway7_cell96 ML7 gate_way7_cell96 GND GND n1 W=1e-6 L=1e-6
mpway7_cell96 ML7 gate_way7_cell96 GND ML7 p1 W=2.4e-6 L=1e-6
mnway7_cell97 ML7 gate_way7_cell97 GND GND n1 W=1e-6 L=1e-6
mpway7_cell97 ML7 gate_way7_cell97 GND ML7 p1 W=2.4e-6 L=1e-6
mnway7_cell98 ML7 gate_way7_cell98 GND GND n1 W=1e-6 L=1e-6
mpway7_cell98 ML7 gate_way7_cell98 GND ML7 p1 W=2.4e-6 L=1e-6
mnway7_cell99 ML7 gate_way7_cell99 GND GND n1 W=1e-6 L=1e-6
mpway7_cell99 ML7 gate_way7_cell99 GND ML7 p1 W=2.4e-6 L=1e-6
mnway8_cell0 ML8 gate_way8_cell0 GND GND n1 W=1e-6 L=1e-6
mpway8_cell0 ML8 gate_way8_cell0 GND ML8 p1 W=2.4e-6 L=1e-6
mnway8_cell1 ML8 gate_way8_cell1 GND GND n1 W=1e-6 L=1e-6
mpway8_cell1 ML8 gate_way8_cell1 GND ML8 p1 W=2.4e-6 L=1e-6
mnway8_cell2 ML8 gate_way8_cell2 GND GND n1 W=1e-6 L=1e-6
mpway8_cell2 ML8 gate_way8_cell2 GND ML8 p1 W=2.4e-6 L=1e-6
mnway8_cell3 ML8 gate_way8_cell3 GND GND n1 W=1e-6 L=1e-6
mpway8_cell3 ML8 gate_way8_cell3 GND ML8 p1 W=2.4e-6 L=1e-6
mnway8_cell4 ML8 gate_way8_cell4 GND GND n1 W=1e-6 L=1e-6
mpway8_cell4 ML8 gate_way8_cell4 GND ML8 p1 W=2.4e-6 L=1e-6
mnway8_cell5 ML8 gate_way8_cell5 GND GND n1 W=1e-6 L=1e-6
mpway8_cell5 ML8 gate_way8_cell5 GND ML8 p1 W=2.4e-6 L=1e-6
mnway8_cell6 ML8 gate_way8_cell6 GND GND n1 W=1e-6 L=1e-6
mpway8_cell6 ML8 gate_way8_cell6 GND ML8 p1 W=2.4e-6 L=1e-6
mnway8_cell7 ML8 gate_way8_cell7 GND GND n1 W=1e-6 L=1e-6
mpway8_cell7 ML8 gate_way8_cell7 GND ML8 p1 W=2.4e-6 L=1e-6
mnway8_cell8 ML8 gate_way8_cell8 GND GND n1 W=1e-6 L=1e-6
mpway8_cell8 ML8 gate_way8_cell8 GND ML8 p1 W=2.4e-6 L=1e-6
mnway8_cell9 ML8 gate_way8_cell9 GND GND n1 W=1e-6 L=1e-6
mpway8_cell9 ML8 gate_way8_cell9 GND ML8 p1 W=2.4e-6 L=1e-6
mnway8_cell10 ML8 gate_way8_cell10 GND GND n1 W=1e-6 L=1e-6
mpway8_cell10 ML8 gate_way8_cell10 GND ML8 p1 W=2.4e-6 L=1e-6
mnway8_cell11 ML8 gate_way8_cell11 GND GND n1 W=1e-6 L=1e-6
mpway8_cell11 ML8 gate_way8_cell11 GND ML8 p1 W=2.4e-6 L=1e-6
mnway8_cell12 ML8 gate_way8_cell12 GND GND n1 W=1e-6 L=1e-6
mpway8_cell12 ML8 gate_way8_cell12 GND ML8 p1 W=2.4e-6 L=1e-6
mnway8_cell13 ML8 gate_way8_cell13 GND GND n1 W=1e-6 L=1e-6
mpway8_cell13 ML8 gate_way8_cell13 GND ML8 p1 W=2.4e-6 L=1e-6
mnway8_cell14 ML8 gate_way8_cell14 GND GND n1 W=1e-6 L=1e-6
mpway8_cell14 ML8 gate_way8_cell14 GND ML8 p1 W=2.4e-6 L=1e-6
mnway8_cell15 ML8 gate_way8_cell15 GND GND n1 W=1e-6 L=1e-6
mpway8_cell15 ML8 gate_way8_cell15 GND ML8 p1 W=2.4e-6 L=1e-6
mnway8_cell16 ML8 gate_way8_cell16 GND GND n1 W=1e-6 L=1e-6
mpway8_cell16 ML8 gate_way8_cell16 GND ML8 p1 W=2.4e-6 L=1e-6
mnway8_cell17 ML8 gate_way8_cell17 GND GND n1 W=1e-6 L=1e-6
mpway8_cell17 ML8 gate_way8_cell17 GND ML8 p1 W=2.4e-6 L=1e-6
mnway8_cell18 ML8 gate_way8_cell18 GND GND n1 W=1e-6 L=1e-6
mpway8_cell18 ML8 gate_way8_cell18 GND ML8 p1 W=2.4e-6 L=1e-6
mnway8_cell19 ML8 gate_way8_cell19 GND GND n1 W=1e-6 L=1e-6
mpway8_cell19 ML8 gate_way8_cell19 GND ML8 p1 W=2.4e-6 L=1e-6
mnway8_cell20 ML8 gate_way8_cell20 GND GND n1 W=1e-6 L=1e-6
mpway8_cell20 ML8 gate_way8_cell20 GND ML8 p1 W=2.4e-6 L=1e-6
mnway8_cell21 ML8 gate_way8_cell21 GND GND n1 W=1e-6 L=1e-6
mpway8_cell21 ML8 gate_way8_cell21 GND ML8 p1 W=2.4e-6 L=1e-6
mnway8_cell22 ML8 gate_way8_cell22 GND GND n1 W=1e-6 L=1e-6
mpway8_cell22 ML8 gate_way8_cell22 GND ML8 p1 W=2.4e-6 L=1e-6
mnway8_cell23 ML8 gate_way8_cell23 GND GND n1 W=1e-6 L=1e-6
mpway8_cell23 ML8 gate_way8_cell23 GND ML8 p1 W=2.4e-6 L=1e-6
mnway8_cell24 ML8 gate_way8_cell24 GND GND n1 W=1e-6 L=1e-6
mpway8_cell24 ML8 gate_way8_cell24 GND ML8 p1 W=2.4e-6 L=1e-6
mnway8_cell25 ML8 gate_way8_cell25 GND GND n1 W=1e-6 L=1e-6
mpway8_cell25 ML8 gate_way8_cell25 GND ML8 p1 W=2.4e-6 L=1e-6
mnway8_cell26 ML8 gate_way8_cell26 GND GND n1 W=1e-6 L=1e-6
mpway8_cell26 ML8 gate_way8_cell26 GND ML8 p1 W=2.4e-6 L=1e-6
mnway8_cell27 ML8 gate_way8_cell27 GND GND n1 W=1e-6 L=1e-6
mpway8_cell27 ML8 gate_way8_cell27 GND ML8 p1 W=2.4e-6 L=1e-6
mnway8_cell28 ML8 gate_way8_cell28 GND GND n1 W=1e-6 L=1e-6
mpway8_cell28 ML8 gate_way8_cell28 GND ML8 p1 W=2.4e-6 L=1e-6
mnway8_cell29 ML8 gate_way8_cell29 GND GND n1 W=1e-6 L=1e-6
mpway8_cell29 ML8 gate_way8_cell29 GND ML8 p1 W=2.4e-6 L=1e-6
mnway8_cell30 ML8 gate_way8_cell30 GND GND n1 W=1e-6 L=1e-6
mpway8_cell30 ML8 gate_way8_cell30 GND ML8 p1 W=2.4e-6 L=1e-6
mnway8_cell31 ML8 gate_way8_cell31 GND GND n1 W=1e-6 L=1e-6
mpway8_cell31 ML8 gate_way8_cell31 GND ML8 p1 W=2.4e-6 L=1e-6
mnway8_cell32 ML8 gate_way8_cell32 GND GND n1 W=1e-6 L=1e-6
mpway8_cell32 ML8 gate_way8_cell32 GND ML8 p1 W=2.4e-6 L=1e-6
mnway8_cell33 ML8 gate_way8_cell33 GND GND n1 W=1e-6 L=1e-6
mpway8_cell33 ML8 gate_way8_cell33 GND ML8 p1 W=2.4e-6 L=1e-6
mnway8_cell34 ML8 gate_way8_cell34 GND GND n1 W=1e-6 L=1e-6
mpway8_cell34 ML8 gate_way8_cell34 GND ML8 p1 W=2.4e-6 L=1e-6
mnway8_cell35 ML8 gate_way8_cell35 GND GND n1 W=1e-6 L=1e-6
mpway8_cell35 ML8 gate_way8_cell35 GND ML8 p1 W=2.4e-6 L=1e-6
mnway8_cell36 ML8 gate_way8_cell36 GND GND n1 W=1e-6 L=1e-6
mpway8_cell36 ML8 gate_way8_cell36 GND ML8 p1 W=2.4e-6 L=1e-6
mnway8_cell37 ML8 gate_way8_cell37 GND GND n1 W=1e-6 L=1e-6
mpway8_cell37 ML8 gate_way8_cell37 GND ML8 p1 W=2.4e-6 L=1e-6
mnway8_cell38 ML8 gate_way8_cell38 GND GND n1 W=1e-6 L=1e-6
mpway8_cell38 ML8 gate_way8_cell38 GND ML8 p1 W=2.4e-6 L=1e-6
mnway8_cell39 ML8 gate_way8_cell39 GND GND n1 W=1e-6 L=1e-6
mpway8_cell39 ML8 gate_way8_cell39 GND ML8 p1 W=2.4e-6 L=1e-6
mnway8_cell40 ML8 gate_way8_cell40 GND GND n1 W=1e-6 L=1e-6
mpway8_cell40 ML8 gate_way8_cell40 GND ML8 p1 W=2.4e-6 L=1e-6
mnway8_cell41 ML8 gate_way8_cell41 GND GND n1 W=1e-6 L=1e-6
mpway8_cell41 ML8 gate_way8_cell41 GND ML8 p1 W=2.4e-6 L=1e-6
mnway8_cell42 ML8 gate_way8_cell42 GND GND n1 W=1e-6 L=1e-6
mpway8_cell42 ML8 gate_way8_cell42 GND ML8 p1 W=2.4e-6 L=1e-6
mnway8_cell43 ML8 gate_way8_cell43 GND GND n1 W=1e-6 L=1e-6
mpway8_cell43 ML8 gate_way8_cell43 GND ML8 p1 W=2.4e-6 L=1e-6
mnway8_cell44 ML8 gate_way8_cell44 GND GND n1 W=1e-6 L=1e-6
mpway8_cell44 ML8 gate_way8_cell44 GND ML8 p1 W=2.4e-6 L=1e-6
mnway8_cell45 ML8 gate_way8_cell45 GND GND n1 W=1e-6 L=1e-6
mpway8_cell45 ML8 gate_way8_cell45 GND ML8 p1 W=2.4e-6 L=1e-6
mnway8_cell46 ML8 gate_way8_cell46 GND GND n1 W=1e-6 L=1e-6
mpway8_cell46 ML8 gate_way8_cell46 GND ML8 p1 W=2.4e-6 L=1e-6
mnway8_cell47 ML8 gate_way8_cell47 GND GND n1 W=1e-6 L=1e-6
mpway8_cell47 ML8 gate_way8_cell47 GND ML8 p1 W=2.4e-6 L=1e-6
mnway8_cell48 ML8 gate_way8_cell48 GND GND n1 W=1e-6 L=1e-6
mpway8_cell48 ML8 gate_way8_cell48 GND ML8 p1 W=2.4e-6 L=1e-6
mnway8_cell49 ML8 gate_way8_cell49 GND GND n1 W=1e-6 L=1e-6
mpway8_cell49 ML8 gate_way8_cell49 GND ML8 p1 W=2.4e-6 L=1e-6
mnway8_cell50 ML8 gate_way8_cell50 GND GND n1 W=1e-6 L=1e-6
mpway8_cell50 ML8 gate_way8_cell50 GND ML8 p1 W=2.4e-6 L=1e-6
mnway8_cell51 ML8 gate_way8_cell51 GND GND n1 W=1e-6 L=1e-6
mpway8_cell51 ML8 gate_way8_cell51 GND ML8 p1 W=2.4e-6 L=1e-6
mnway8_cell52 ML8 gate_way8_cell52 GND GND n1 W=1e-6 L=1e-6
mpway8_cell52 ML8 gate_way8_cell52 GND ML8 p1 W=2.4e-6 L=1e-6
mnway8_cell53 ML8 gate_way8_cell53 GND GND n1 W=1e-6 L=1e-6
mpway8_cell53 ML8 gate_way8_cell53 GND ML8 p1 W=2.4e-6 L=1e-6
mnway8_cell54 ML8 gate_way8_cell54 GND GND n1 W=1e-6 L=1e-6
mpway8_cell54 ML8 gate_way8_cell54 GND ML8 p1 W=2.4e-6 L=1e-6
mnway8_cell55 ML8 gate_way8_cell55 GND GND n1 W=1e-6 L=1e-6
mpway8_cell55 ML8 gate_way8_cell55 GND ML8 p1 W=2.4e-6 L=1e-6
mnway8_cell56 ML8 gate_way8_cell56 GND GND n1 W=1e-6 L=1e-6
mpway8_cell56 ML8 gate_way8_cell56 GND ML8 p1 W=2.4e-6 L=1e-6
mnway8_cell57 ML8 gate_way8_cell57 GND GND n1 W=1e-6 L=1e-6
mpway8_cell57 ML8 gate_way8_cell57 GND ML8 p1 W=2.4e-6 L=1e-6
mnway8_cell58 ML8 gate_way8_cell58 GND GND n1 W=1e-6 L=1e-6
mpway8_cell58 ML8 gate_way8_cell58 GND ML8 p1 W=2.4e-6 L=1e-6
mnway8_cell59 ML8 gate_way8_cell59 GND GND n1 W=1e-6 L=1e-6
mpway8_cell59 ML8 gate_way8_cell59 GND ML8 p1 W=2.4e-6 L=1e-6
mnway8_cell60 ML8 gate_way8_cell60 GND GND n1 W=1e-6 L=1e-6
mpway8_cell60 ML8 gate_way8_cell60 GND ML8 p1 W=2.4e-6 L=1e-6
mnway8_cell61 ML8 gate_way8_cell61 GND GND n1 W=1e-6 L=1e-6
mpway8_cell61 ML8 gate_way8_cell61 GND ML8 p1 W=2.4e-6 L=1e-6
mnway8_cell62 ML8 gate_way8_cell62 GND GND n1 W=1e-6 L=1e-6
mpway8_cell62 ML8 gate_way8_cell62 GND ML8 p1 W=2.4e-6 L=1e-6
mnway8_cell63 ML8 gate_way8_cell63 GND GND n1 W=1e-6 L=1e-6
mpway8_cell63 ML8 gate_way8_cell63 GND ML8 p1 W=2.4e-6 L=1e-6
mnway8_cell64 ML8 gate_way8_cell64 GND GND n1 W=1e-6 L=1e-6
mpway8_cell64 ML8 gate_way8_cell64 GND ML8 p1 W=2.4e-6 L=1e-6
mnway8_cell65 ML8 gate_way8_cell65 GND GND n1 W=1e-6 L=1e-6
mpway8_cell65 ML8 gate_way8_cell65 GND ML8 p1 W=2.4e-6 L=1e-6
mnway8_cell66 ML8 gate_way8_cell66 GND GND n1 W=1e-6 L=1e-6
mpway8_cell66 ML8 gate_way8_cell66 GND ML8 p1 W=2.4e-6 L=1e-6
mnway8_cell67 ML8 gate_way8_cell67 GND GND n1 W=1e-6 L=1e-6
mpway8_cell67 ML8 gate_way8_cell67 GND ML8 p1 W=2.4e-6 L=1e-6
mnway8_cell68 ML8 gate_way8_cell68 GND GND n1 W=1e-6 L=1e-6
mpway8_cell68 ML8 gate_way8_cell68 GND ML8 p1 W=2.4e-6 L=1e-6
mnway8_cell69 ML8 gate_way8_cell69 GND GND n1 W=1e-6 L=1e-6
mpway8_cell69 ML8 gate_way8_cell69 GND ML8 p1 W=2.4e-6 L=1e-6
mnway8_cell70 ML8 gate_way8_cell70 GND GND n1 W=1e-6 L=1e-6
mpway8_cell70 ML8 gate_way8_cell70 GND ML8 p1 W=2.4e-6 L=1e-6
mnway8_cell71 ML8 gate_way8_cell71 GND GND n1 W=1e-6 L=1e-6
mpway8_cell71 ML8 gate_way8_cell71 GND ML8 p1 W=2.4e-6 L=1e-6
mnway8_cell72 ML8 gate_way8_cell72 GND GND n1 W=1e-6 L=1e-6
mpway8_cell72 ML8 gate_way8_cell72 GND ML8 p1 W=2.4e-6 L=1e-6
mnway8_cell73 ML8 gate_way8_cell73 GND GND n1 W=1e-6 L=1e-6
mpway8_cell73 ML8 gate_way8_cell73 GND ML8 p1 W=2.4e-6 L=1e-6
mnway8_cell74 ML8 gate_way8_cell74 GND GND n1 W=1e-6 L=1e-6
mpway8_cell74 ML8 gate_way8_cell74 GND ML8 p1 W=2.4e-6 L=1e-6
mnway8_cell75 ML8 gate_way8_cell75 GND GND n1 W=1e-6 L=1e-6
mpway8_cell75 ML8 gate_way8_cell75 GND ML8 p1 W=2.4e-6 L=1e-6
mnway8_cell76 ML8 gate_way8_cell76 GND GND n1 W=1e-6 L=1e-6
mpway8_cell76 ML8 gate_way8_cell76 GND ML8 p1 W=2.4e-6 L=1e-6
mnway8_cell77 ML8 gate_way8_cell77 GND GND n1 W=1e-6 L=1e-6
mpway8_cell77 ML8 gate_way8_cell77 GND ML8 p1 W=2.4e-6 L=1e-6
mnway8_cell78 ML8 gate_way8_cell78 GND GND n1 W=1e-6 L=1e-6
mpway8_cell78 ML8 gate_way8_cell78 GND ML8 p1 W=2.4e-6 L=1e-6
mnway8_cell79 ML8 gate_way8_cell79 GND GND n1 W=1e-6 L=1e-6
mpway8_cell79 ML8 gate_way8_cell79 GND ML8 p1 W=2.4e-6 L=1e-6
mnway8_cell80 ML8 gate_way8_cell80 GND GND n1 W=1e-6 L=1e-6
mpway8_cell80 ML8 gate_way8_cell80 GND ML8 p1 W=2.4e-6 L=1e-6
mnway8_cell81 ML8 gate_way8_cell81 GND GND n1 W=1e-6 L=1e-6
mpway8_cell81 ML8 gate_way8_cell81 GND ML8 p1 W=2.4e-6 L=1e-6
mnway8_cell82 ML8 gate_way8_cell82 GND GND n1 W=1e-6 L=1e-6
mpway8_cell82 ML8 gate_way8_cell82 GND ML8 p1 W=2.4e-6 L=1e-6
mnway8_cell83 ML8 gate_way8_cell83 GND GND n1 W=1e-6 L=1e-6
mpway8_cell83 ML8 gate_way8_cell83 GND ML8 p1 W=2.4e-6 L=1e-6
mnway8_cell84 ML8 gate_way8_cell84 GND GND n1 W=1e-6 L=1e-6
mpway8_cell84 ML8 gate_way8_cell84 GND ML8 p1 W=2.4e-6 L=1e-6
mnway8_cell85 ML8 gate_way8_cell85 GND GND n1 W=1e-6 L=1e-6
mpway8_cell85 ML8 gate_way8_cell85 GND ML8 p1 W=2.4e-6 L=1e-6
mnway8_cell86 ML8 gate_way8_cell86 GND GND n1 W=1e-6 L=1e-6
mpway8_cell86 ML8 gate_way8_cell86 GND ML8 p1 W=2.4e-6 L=1e-6
mnway8_cell87 ML8 gate_way8_cell87 GND GND n1 W=1e-6 L=1e-6
mpway8_cell87 ML8 gate_way8_cell87 GND ML8 p1 W=2.4e-6 L=1e-6
mnway8_cell88 ML8 gate_way8_cell88 GND GND n1 W=1e-6 L=1e-6
mpway8_cell88 ML8 gate_way8_cell88 GND ML8 p1 W=2.4e-6 L=1e-6
mnway8_cell89 ML8 gate_way8_cell89 GND GND n1 W=1e-6 L=1e-6
mpway8_cell89 ML8 gate_way8_cell89 GND ML8 p1 W=2.4e-6 L=1e-6
mnway8_cell90 ML8 gate_way8_cell90 GND GND n1 W=1e-6 L=1e-6
mpway8_cell90 ML8 gate_way8_cell90 GND ML8 p1 W=2.4e-6 L=1e-6
mnway8_cell91 ML8 gate_way8_cell91 GND GND n1 W=1e-6 L=1e-6
mpway8_cell91 ML8 gate_way8_cell91 GND ML8 p1 W=2.4e-6 L=1e-6
mnway8_cell92 ML8 gate_way8_cell92 GND GND n1 W=1e-6 L=1e-6
mpway8_cell92 ML8 gate_way8_cell92 GND ML8 p1 W=2.4e-6 L=1e-6
mnway8_cell93 ML8 gate_way8_cell93 GND GND n1 W=1e-6 L=1e-6
mpway8_cell93 ML8 gate_way8_cell93 GND ML8 p1 W=2.4e-6 L=1e-6
mnway8_cell94 ML8 gate_way8_cell94 GND GND n1 W=1e-6 L=1e-6
mpway8_cell94 ML8 gate_way8_cell94 GND ML8 p1 W=2.4e-6 L=1e-6
mnway8_cell95 ML8 gate_way8_cell95 GND GND n1 W=1e-6 L=1e-6
mpway8_cell95 ML8 gate_way8_cell95 GND ML8 p1 W=2.4e-6 L=1e-6
mnway8_cell96 ML8 gate_way8_cell96 GND GND n1 W=1e-6 L=1e-6
mpway8_cell96 ML8 gate_way8_cell96 GND ML8 p1 W=2.4e-6 L=1e-6
mnway8_cell97 ML8 gate_way8_cell97 GND GND n1 W=1e-6 L=1e-6
mpway8_cell97 ML8 gate_way8_cell97 GND ML8 p1 W=2.4e-6 L=1e-6
mnway8_cell98 ML8 gate_way8_cell98 GND GND n1 W=1e-6 L=1e-6
mpway8_cell98 ML8 gate_way8_cell98 GND ML8 p1 W=2.4e-6 L=1e-6
mnway8_cell99 ML8 gate_way8_cell99 GND GND n1 W=1e-6 L=1e-6
mpway8_cell99 ML8 gate_way8_cell99 GND ML8 p1 W=2.4e-6 L=1e-6
mnway9_cell0 ML9 gate_way9_cell0 GND GND n1 W=1e-6 L=1e-6
mpway9_cell0 ML9 gate_way9_cell0 GND ML9 p1 W=2.4e-6 L=1e-6
mnway9_cell1 ML9 gate_way9_cell1 GND GND n1 W=1e-6 L=1e-6
mpway9_cell1 ML9 gate_way9_cell1 GND ML9 p1 W=2.4e-6 L=1e-6
mnway9_cell2 ML9 gate_way9_cell2 GND GND n1 W=1e-6 L=1e-6
mpway9_cell2 ML9 gate_way9_cell2 GND ML9 p1 W=2.4e-6 L=1e-6
mnway9_cell3 ML9 gate_way9_cell3 GND GND n1 W=1e-6 L=1e-6
mpway9_cell3 ML9 gate_way9_cell3 GND ML9 p1 W=2.4e-6 L=1e-6
mnway9_cell4 ML9 gate_way9_cell4 GND GND n1 W=1e-6 L=1e-6
mpway9_cell4 ML9 gate_way9_cell4 GND ML9 p1 W=2.4e-6 L=1e-6
mnway9_cell5 ML9 gate_way9_cell5 GND GND n1 W=1e-6 L=1e-6
mpway9_cell5 ML9 gate_way9_cell5 GND ML9 p1 W=2.4e-6 L=1e-6
mnway9_cell6 ML9 gate_way9_cell6 GND GND n1 W=1e-6 L=1e-6
mpway9_cell6 ML9 gate_way9_cell6 GND ML9 p1 W=2.4e-6 L=1e-6
mnway9_cell7 ML9 gate_way9_cell7 GND GND n1 W=1e-6 L=1e-6
mpway9_cell7 ML9 gate_way9_cell7 GND ML9 p1 W=2.4e-6 L=1e-6
mnway9_cell8 ML9 gate_way9_cell8 GND GND n1 W=1e-6 L=1e-6
mpway9_cell8 ML9 gate_way9_cell8 GND ML9 p1 W=2.4e-6 L=1e-6
mnway9_cell9 ML9 gate_way9_cell9 GND GND n1 W=1e-6 L=1e-6
mpway9_cell9 ML9 gate_way9_cell9 GND ML9 p1 W=2.4e-6 L=1e-6
mnway9_cell10 ML9 gate_way9_cell10 GND GND n1 W=1e-6 L=1e-6
mpway9_cell10 ML9 gate_way9_cell10 GND ML9 p1 W=2.4e-6 L=1e-6
mnway9_cell11 ML9 gate_way9_cell11 GND GND n1 W=1e-6 L=1e-6
mpway9_cell11 ML9 gate_way9_cell11 GND ML9 p1 W=2.4e-6 L=1e-6
mnway9_cell12 ML9 gate_way9_cell12 GND GND n1 W=1e-6 L=1e-6
mpway9_cell12 ML9 gate_way9_cell12 GND ML9 p1 W=2.4e-6 L=1e-6
mnway9_cell13 ML9 gate_way9_cell13 GND GND n1 W=1e-6 L=1e-6
mpway9_cell13 ML9 gate_way9_cell13 GND ML9 p1 W=2.4e-6 L=1e-6
mnway9_cell14 ML9 gate_way9_cell14 GND GND n1 W=1e-6 L=1e-6
mpway9_cell14 ML9 gate_way9_cell14 GND ML9 p1 W=2.4e-6 L=1e-6
mnway9_cell15 ML9 gate_way9_cell15 GND GND n1 W=1e-6 L=1e-6
mpway9_cell15 ML9 gate_way9_cell15 GND ML9 p1 W=2.4e-6 L=1e-6
mnway9_cell16 ML9 gate_way9_cell16 GND GND n1 W=1e-6 L=1e-6
mpway9_cell16 ML9 gate_way9_cell16 GND ML9 p1 W=2.4e-6 L=1e-6
mnway9_cell17 ML9 gate_way9_cell17 GND GND n1 W=1e-6 L=1e-6
mpway9_cell17 ML9 gate_way9_cell17 GND ML9 p1 W=2.4e-6 L=1e-6
mnway9_cell18 ML9 gate_way9_cell18 GND GND n1 W=1e-6 L=1e-6
mpway9_cell18 ML9 gate_way9_cell18 GND ML9 p1 W=2.4e-6 L=1e-6
mnway9_cell19 ML9 gate_way9_cell19 GND GND n1 W=1e-6 L=1e-6
mpway9_cell19 ML9 gate_way9_cell19 GND ML9 p1 W=2.4e-6 L=1e-6
mnway9_cell20 ML9 gate_way9_cell20 GND GND n1 W=1e-6 L=1e-6
mpway9_cell20 ML9 gate_way9_cell20 GND ML9 p1 W=2.4e-6 L=1e-6
mnway9_cell21 ML9 gate_way9_cell21 GND GND n1 W=1e-6 L=1e-6
mpway9_cell21 ML9 gate_way9_cell21 GND ML9 p1 W=2.4e-6 L=1e-6
mnway9_cell22 ML9 gate_way9_cell22 GND GND n1 W=1e-6 L=1e-6
mpway9_cell22 ML9 gate_way9_cell22 GND ML9 p1 W=2.4e-6 L=1e-6
mnway9_cell23 ML9 gate_way9_cell23 GND GND n1 W=1e-6 L=1e-6
mpway9_cell23 ML9 gate_way9_cell23 GND ML9 p1 W=2.4e-6 L=1e-6
mnway9_cell24 ML9 gate_way9_cell24 GND GND n1 W=1e-6 L=1e-6
mpway9_cell24 ML9 gate_way9_cell24 GND ML9 p1 W=2.4e-6 L=1e-6
mnway9_cell25 ML9 gate_way9_cell25 GND GND n1 W=1e-6 L=1e-6
mpway9_cell25 ML9 gate_way9_cell25 GND ML9 p1 W=2.4e-6 L=1e-6
mnway9_cell26 ML9 gate_way9_cell26 GND GND n1 W=1e-6 L=1e-6
mpway9_cell26 ML9 gate_way9_cell26 GND ML9 p1 W=2.4e-6 L=1e-6
mnway9_cell27 ML9 gate_way9_cell27 GND GND n1 W=1e-6 L=1e-6
mpway9_cell27 ML9 gate_way9_cell27 GND ML9 p1 W=2.4e-6 L=1e-6
mnway9_cell28 ML9 gate_way9_cell28 GND GND n1 W=1e-6 L=1e-6
mpway9_cell28 ML9 gate_way9_cell28 GND ML9 p1 W=2.4e-6 L=1e-6
mnway9_cell29 ML9 gate_way9_cell29 GND GND n1 W=1e-6 L=1e-6
mpway9_cell29 ML9 gate_way9_cell29 GND ML9 p1 W=2.4e-6 L=1e-6
mnway9_cell30 ML9 gate_way9_cell30 GND GND n1 W=1e-6 L=1e-6
mpway9_cell30 ML9 gate_way9_cell30 GND ML9 p1 W=2.4e-6 L=1e-6
mnway9_cell31 ML9 gate_way9_cell31 GND GND n1 W=1e-6 L=1e-6
mpway9_cell31 ML9 gate_way9_cell31 GND ML9 p1 W=2.4e-6 L=1e-6
mnway9_cell32 ML9 gate_way9_cell32 GND GND n1 W=1e-6 L=1e-6
mpway9_cell32 ML9 gate_way9_cell32 GND ML9 p1 W=2.4e-6 L=1e-6
mnway9_cell33 ML9 gate_way9_cell33 GND GND n1 W=1e-6 L=1e-6
mpway9_cell33 ML9 gate_way9_cell33 GND ML9 p1 W=2.4e-6 L=1e-6
mnway9_cell34 ML9 gate_way9_cell34 GND GND n1 W=1e-6 L=1e-6
mpway9_cell34 ML9 gate_way9_cell34 GND ML9 p1 W=2.4e-6 L=1e-6
mnway9_cell35 ML9 gate_way9_cell35 GND GND n1 W=1e-6 L=1e-6
mpway9_cell35 ML9 gate_way9_cell35 GND ML9 p1 W=2.4e-6 L=1e-6
mnway9_cell36 ML9 gate_way9_cell36 GND GND n1 W=1e-6 L=1e-6
mpway9_cell36 ML9 gate_way9_cell36 GND ML9 p1 W=2.4e-6 L=1e-6
mnway9_cell37 ML9 gate_way9_cell37 GND GND n1 W=1e-6 L=1e-6
mpway9_cell37 ML9 gate_way9_cell37 GND ML9 p1 W=2.4e-6 L=1e-6
mnway9_cell38 ML9 gate_way9_cell38 GND GND n1 W=1e-6 L=1e-6
mpway9_cell38 ML9 gate_way9_cell38 GND ML9 p1 W=2.4e-6 L=1e-6
mnway9_cell39 ML9 gate_way9_cell39 GND GND n1 W=1e-6 L=1e-6
mpway9_cell39 ML9 gate_way9_cell39 GND ML9 p1 W=2.4e-6 L=1e-6
mnway9_cell40 ML9 gate_way9_cell40 GND GND n1 W=1e-6 L=1e-6
mpway9_cell40 ML9 gate_way9_cell40 GND ML9 p1 W=2.4e-6 L=1e-6
mnway9_cell41 ML9 gate_way9_cell41 GND GND n1 W=1e-6 L=1e-6
mpway9_cell41 ML9 gate_way9_cell41 GND ML9 p1 W=2.4e-6 L=1e-6
mnway9_cell42 ML9 gate_way9_cell42 GND GND n1 W=1e-6 L=1e-6
mpway9_cell42 ML9 gate_way9_cell42 GND ML9 p1 W=2.4e-6 L=1e-6
mnway9_cell43 ML9 gate_way9_cell43 GND GND n1 W=1e-6 L=1e-6
mpway9_cell43 ML9 gate_way9_cell43 GND ML9 p1 W=2.4e-6 L=1e-6
mnway9_cell44 ML9 gate_way9_cell44 GND GND n1 W=1e-6 L=1e-6
mpway9_cell44 ML9 gate_way9_cell44 GND ML9 p1 W=2.4e-6 L=1e-6
mnway9_cell45 ML9 gate_way9_cell45 GND GND n1 W=1e-6 L=1e-6
mpway9_cell45 ML9 gate_way9_cell45 GND ML9 p1 W=2.4e-6 L=1e-6
mnway9_cell46 ML9 gate_way9_cell46 GND GND n1 W=1e-6 L=1e-6
mpway9_cell46 ML9 gate_way9_cell46 GND ML9 p1 W=2.4e-6 L=1e-6
mnway9_cell47 ML9 gate_way9_cell47 GND GND n1 W=1e-6 L=1e-6
mpway9_cell47 ML9 gate_way9_cell47 GND ML9 p1 W=2.4e-6 L=1e-6
mnway9_cell48 ML9 gate_way9_cell48 GND GND n1 W=1e-6 L=1e-6
mpway9_cell48 ML9 gate_way9_cell48 GND ML9 p1 W=2.4e-6 L=1e-6
mnway9_cell49 ML9 gate_way9_cell49 GND GND n1 W=1e-6 L=1e-6
mpway9_cell49 ML9 gate_way9_cell49 GND ML9 p1 W=2.4e-6 L=1e-6
mnway9_cell50 ML9 gate_way9_cell50 GND GND n1 W=1e-6 L=1e-6
mpway9_cell50 ML9 gate_way9_cell50 GND ML9 p1 W=2.4e-6 L=1e-6
mnway9_cell51 ML9 gate_way9_cell51 GND GND n1 W=1e-6 L=1e-6
mpway9_cell51 ML9 gate_way9_cell51 GND ML9 p1 W=2.4e-6 L=1e-6
mnway9_cell52 ML9 gate_way9_cell52 GND GND n1 W=1e-6 L=1e-6
mpway9_cell52 ML9 gate_way9_cell52 GND ML9 p1 W=2.4e-6 L=1e-6
mnway9_cell53 ML9 gate_way9_cell53 GND GND n1 W=1e-6 L=1e-6
mpway9_cell53 ML9 gate_way9_cell53 GND ML9 p1 W=2.4e-6 L=1e-6
mnway9_cell54 ML9 gate_way9_cell54 GND GND n1 W=1e-6 L=1e-6
mpway9_cell54 ML9 gate_way9_cell54 GND ML9 p1 W=2.4e-6 L=1e-6
mnway9_cell55 ML9 gate_way9_cell55 GND GND n1 W=1e-6 L=1e-6
mpway9_cell55 ML9 gate_way9_cell55 GND ML9 p1 W=2.4e-6 L=1e-6
mnway9_cell56 ML9 gate_way9_cell56 GND GND n1 W=1e-6 L=1e-6
mpway9_cell56 ML9 gate_way9_cell56 GND ML9 p1 W=2.4e-6 L=1e-6
mnway9_cell57 ML9 gate_way9_cell57 GND GND n1 W=1e-6 L=1e-6
mpway9_cell57 ML9 gate_way9_cell57 GND ML9 p1 W=2.4e-6 L=1e-6
mnway9_cell58 ML9 gate_way9_cell58 GND GND n1 W=1e-6 L=1e-6
mpway9_cell58 ML9 gate_way9_cell58 GND ML9 p1 W=2.4e-6 L=1e-6
mnway9_cell59 ML9 gate_way9_cell59 GND GND n1 W=1e-6 L=1e-6
mpway9_cell59 ML9 gate_way9_cell59 GND ML9 p1 W=2.4e-6 L=1e-6
mnway9_cell60 ML9 gate_way9_cell60 GND GND n1 W=1e-6 L=1e-6
mpway9_cell60 ML9 gate_way9_cell60 GND ML9 p1 W=2.4e-6 L=1e-6
mnway9_cell61 ML9 gate_way9_cell61 GND GND n1 W=1e-6 L=1e-6
mpway9_cell61 ML9 gate_way9_cell61 GND ML9 p1 W=2.4e-6 L=1e-6
mnway9_cell62 ML9 gate_way9_cell62 GND GND n1 W=1e-6 L=1e-6
mpway9_cell62 ML9 gate_way9_cell62 GND ML9 p1 W=2.4e-6 L=1e-6
mnway9_cell63 ML9 gate_way9_cell63 GND GND n1 W=1e-6 L=1e-6
mpway9_cell63 ML9 gate_way9_cell63 GND ML9 p1 W=2.4e-6 L=1e-6
mnway9_cell64 ML9 gate_way9_cell64 GND GND n1 W=1e-6 L=1e-6
mpway9_cell64 ML9 gate_way9_cell64 GND ML9 p1 W=2.4e-6 L=1e-6
mnway9_cell65 ML9 gate_way9_cell65 GND GND n1 W=1e-6 L=1e-6
mpway9_cell65 ML9 gate_way9_cell65 GND ML9 p1 W=2.4e-6 L=1e-6
mnway9_cell66 ML9 gate_way9_cell66 GND GND n1 W=1e-6 L=1e-6
mpway9_cell66 ML9 gate_way9_cell66 GND ML9 p1 W=2.4e-6 L=1e-6
mnway9_cell67 ML9 gate_way9_cell67 GND GND n1 W=1e-6 L=1e-6
mpway9_cell67 ML9 gate_way9_cell67 GND ML9 p1 W=2.4e-6 L=1e-6
mnway9_cell68 ML9 gate_way9_cell68 GND GND n1 W=1e-6 L=1e-6
mpway9_cell68 ML9 gate_way9_cell68 GND ML9 p1 W=2.4e-6 L=1e-6
mnway9_cell69 ML9 gate_way9_cell69 GND GND n1 W=1e-6 L=1e-6
mpway9_cell69 ML9 gate_way9_cell69 GND ML9 p1 W=2.4e-6 L=1e-6
mnway9_cell70 ML9 gate_way9_cell70 GND GND n1 W=1e-6 L=1e-6
mpway9_cell70 ML9 gate_way9_cell70 GND ML9 p1 W=2.4e-6 L=1e-6
mnway9_cell71 ML9 gate_way9_cell71 GND GND n1 W=1e-6 L=1e-6
mpway9_cell71 ML9 gate_way9_cell71 GND ML9 p1 W=2.4e-6 L=1e-6
mnway9_cell72 ML9 gate_way9_cell72 GND GND n1 W=1e-6 L=1e-6
mpway9_cell72 ML9 gate_way9_cell72 GND ML9 p1 W=2.4e-6 L=1e-6
mnway9_cell73 ML9 gate_way9_cell73 GND GND n1 W=1e-6 L=1e-6
mpway9_cell73 ML9 gate_way9_cell73 GND ML9 p1 W=2.4e-6 L=1e-6
mnway9_cell74 ML9 gate_way9_cell74 GND GND n1 W=1e-6 L=1e-6
mpway9_cell74 ML9 gate_way9_cell74 GND ML9 p1 W=2.4e-6 L=1e-6
mnway9_cell75 ML9 gate_way9_cell75 GND GND n1 W=1e-6 L=1e-6
mpway9_cell75 ML9 gate_way9_cell75 GND ML9 p1 W=2.4e-6 L=1e-6
mnway9_cell76 ML9 gate_way9_cell76 GND GND n1 W=1e-6 L=1e-6
mpway9_cell76 ML9 gate_way9_cell76 GND ML9 p1 W=2.4e-6 L=1e-6
mnway9_cell77 ML9 gate_way9_cell77 GND GND n1 W=1e-6 L=1e-6
mpway9_cell77 ML9 gate_way9_cell77 GND ML9 p1 W=2.4e-6 L=1e-6
mnway9_cell78 ML9 gate_way9_cell78 GND GND n1 W=1e-6 L=1e-6
mpway9_cell78 ML9 gate_way9_cell78 GND ML9 p1 W=2.4e-6 L=1e-6
mnway9_cell79 ML9 gate_way9_cell79 GND GND n1 W=1e-6 L=1e-6
mpway9_cell79 ML9 gate_way9_cell79 GND ML9 p1 W=2.4e-6 L=1e-6
mnway9_cell80 ML9 gate_way9_cell80 GND GND n1 W=1e-6 L=1e-6
mpway9_cell80 ML9 gate_way9_cell80 GND ML9 p1 W=2.4e-6 L=1e-6
mnway9_cell81 ML9 gate_way9_cell81 GND GND n1 W=1e-6 L=1e-6
mpway9_cell81 ML9 gate_way9_cell81 GND ML9 p1 W=2.4e-6 L=1e-6
mnway9_cell82 ML9 gate_way9_cell82 GND GND n1 W=1e-6 L=1e-6
mpway9_cell82 ML9 gate_way9_cell82 GND ML9 p1 W=2.4e-6 L=1e-6
mnway9_cell83 ML9 gate_way9_cell83 GND GND n1 W=1e-6 L=1e-6
mpway9_cell83 ML9 gate_way9_cell83 GND ML9 p1 W=2.4e-6 L=1e-6
mnway9_cell84 ML9 gate_way9_cell84 GND GND n1 W=1e-6 L=1e-6
mpway9_cell84 ML9 gate_way9_cell84 GND ML9 p1 W=2.4e-6 L=1e-6
mnway9_cell85 ML9 gate_way9_cell85 GND GND n1 W=1e-6 L=1e-6
mpway9_cell85 ML9 gate_way9_cell85 GND ML9 p1 W=2.4e-6 L=1e-6
mnway9_cell86 ML9 gate_way9_cell86 GND GND n1 W=1e-6 L=1e-6
mpway9_cell86 ML9 gate_way9_cell86 GND ML9 p1 W=2.4e-6 L=1e-6
mnway9_cell87 ML9 gate_way9_cell87 GND GND n1 W=1e-6 L=1e-6
mpway9_cell87 ML9 gate_way9_cell87 GND ML9 p1 W=2.4e-6 L=1e-6
mnway9_cell88 ML9 gate_way9_cell88 GND GND n1 W=1e-6 L=1e-6
mpway9_cell88 ML9 gate_way9_cell88 GND ML9 p1 W=2.4e-6 L=1e-6
mnway9_cell89 ML9 gate_way9_cell89 GND GND n1 W=1e-6 L=1e-6
mpway9_cell89 ML9 gate_way9_cell89 GND ML9 p1 W=2.4e-6 L=1e-6
mnway9_cell90 ML9 gate_way9_cell90 GND GND n1 W=1e-6 L=1e-6
mpway9_cell90 ML9 gate_way9_cell90 GND ML9 p1 W=2.4e-6 L=1e-6
mnway9_cell91 ML9 gate_way9_cell91 GND GND n1 W=1e-6 L=1e-6
mpway9_cell91 ML9 gate_way9_cell91 GND ML9 p1 W=2.4e-6 L=1e-6
mnway9_cell92 ML9 gate_way9_cell92 GND GND n1 W=1e-6 L=1e-6
mpway9_cell92 ML9 gate_way9_cell92 GND ML9 p1 W=2.4e-6 L=1e-6
mnway9_cell93 ML9 gate_way9_cell93 GND GND n1 W=1e-6 L=1e-6
mpway9_cell93 ML9 gate_way9_cell93 GND ML9 p1 W=2.4e-6 L=1e-6
mnway9_cell94 ML9 gate_way9_cell94 GND GND n1 W=1e-6 L=1e-6
mpway9_cell94 ML9 gate_way9_cell94 GND ML9 p1 W=2.4e-6 L=1e-6
mnway9_cell95 ML9 gate_way9_cell95 GND GND n1 W=1e-6 L=1e-6
mpway9_cell95 ML9 gate_way9_cell95 GND ML9 p1 W=2.4e-6 L=1e-6
mnway9_cell96 ML9 gate_way9_cell96 GND GND n1 W=1e-6 L=1e-6
mpway9_cell96 ML9 gate_way9_cell96 GND ML9 p1 W=2.4e-6 L=1e-6
mnway9_cell97 ML9 gate_way9_cell97 GND GND n1 W=1e-6 L=1e-6
mpway9_cell97 ML9 gate_way9_cell97 GND ML9 p1 W=2.4e-6 L=1e-6
mnway9_cell98 ML9 gate_way9_cell98 GND GND n1 W=1e-6 L=1e-6
mpway9_cell98 ML9 gate_way9_cell98 GND ML9 p1 W=2.4e-6 L=1e-6
mnway9_cell99 ML9 gate_way9_cell99 GND GND n1 W=1e-6 L=1e-6
mpway9_cell99 ML9 gate_way9_cell99 GND ML9 p1 W=2.4e-6 L=1e-6
mnway10_cell0 ML10 gate_way10_cell0 GND GND n1 W=1e-6 L=1e-6
mpway10_cell0 ML10 gate_way10_cell0 GND ML10 p1 W=2.4e-6 L=1e-6
mnway10_cell1 ML10 gate_way10_cell1 GND GND n1 W=1e-6 L=1e-6
mpway10_cell1 ML10 gate_way10_cell1 GND ML10 p1 W=2.4e-6 L=1e-6
mnway10_cell2 ML10 gate_way10_cell2 GND GND n1 W=1e-6 L=1e-6
mpway10_cell2 ML10 gate_way10_cell2 GND ML10 p1 W=2.4e-6 L=1e-6
mnway10_cell3 ML10 gate_way10_cell3 GND GND n1 W=1e-6 L=1e-6
mpway10_cell3 ML10 gate_way10_cell3 GND ML10 p1 W=2.4e-6 L=1e-6
mnway10_cell4 ML10 gate_way10_cell4 GND GND n1 W=1e-6 L=1e-6
mpway10_cell4 ML10 gate_way10_cell4 GND ML10 p1 W=2.4e-6 L=1e-6
mnway10_cell5 ML10 gate_way10_cell5 GND GND n1 W=1e-6 L=1e-6
mpway10_cell5 ML10 gate_way10_cell5 GND ML10 p1 W=2.4e-6 L=1e-6
mnway10_cell6 ML10 gate_way10_cell6 GND GND n1 W=1e-6 L=1e-6
mpway10_cell6 ML10 gate_way10_cell6 GND ML10 p1 W=2.4e-6 L=1e-6
mnway10_cell7 ML10 gate_way10_cell7 GND GND n1 W=1e-6 L=1e-6
mpway10_cell7 ML10 gate_way10_cell7 GND ML10 p1 W=2.4e-6 L=1e-6
mnway10_cell8 ML10 gate_way10_cell8 GND GND n1 W=1e-6 L=1e-6
mpway10_cell8 ML10 gate_way10_cell8 GND ML10 p1 W=2.4e-6 L=1e-6
mnway10_cell9 ML10 gate_way10_cell9 GND GND n1 W=1e-6 L=1e-6
mpway10_cell9 ML10 gate_way10_cell9 GND ML10 p1 W=2.4e-6 L=1e-6
mnway10_cell10 ML10 gate_way10_cell10 GND GND n1 W=1e-6 L=1e-6
mpway10_cell10 ML10 gate_way10_cell10 GND ML10 p1 W=2.4e-6 L=1e-6
mnway10_cell11 ML10 gate_way10_cell11 GND GND n1 W=1e-6 L=1e-6
mpway10_cell11 ML10 gate_way10_cell11 GND ML10 p1 W=2.4e-6 L=1e-6
mnway10_cell12 ML10 gate_way10_cell12 GND GND n1 W=1e-6 L=1e-6
mpway10_cell12 ML10 gate_way10_cell12 GND ML10 p1 W=2.4e-6 L=1e-6
mnway10_cell13 ML10 gate_way10_cell13 GND GND n1 W=1e-6 L=1e-6
mpway10_cell13 ML10 gate_way10_cell13 GND ML10 p1 W=2.4e-6 L=1e-6
mnway10_cell14 ML10 gate_way10_cell14 GND GND n1 W=1e-6 L=1e-6
mpway10_cell14 ML10 gate_way10_cell14 GND ML10 p1 W=2.4e-6 L=1e-6
mnway10_cell15 ML10 gate_way10_cell15 GND GND n1 W=1e-6 L=1e-6
mpway10_cell15 ML10 gate_way10_cell15 GND ML10 p1 W=2.4e-6 L=1e-6
mnway10_cell16 ML10 gate_way10_cell16 GND GND n1 W=1e-6 L=1e-6
mpway10_cell16 ML10 gate_way10_cell16 GND ML10 p1 W=2.4e-6 L=1e-6
mnway10_cell17 ML10 gate_way10_cell17 GND GND n1 W=1e-6 L=1e-6
mpway10_cell17 ML10 gate_way10_cell17 GND ML10 p1 W=2.4e-6 L=1e-6
mnway10_cell18 ML10 gate_way10_cell18 GND GND n1 W=1e-6 L=1e-6
mpway10_cell18 ML10 gate_way10_cell18 GND ML10 p1 W=2.4e-6 L=1e-6
mnway10_cell19 ML10 gate_way10_cell19 GND GND n1 W=1e-6 L=1e-6
mpway10_cell19 ML10 gate_way10_cell19 GND ML10 p1 W=2.4e-6 L=1e-6
mnway10_cell20 ML10 gate_way10_cell20 GND GND n1 W=1e-6 L=1e-6
mpway10_cell20 ML10 gate_way10_cell20 GND ML10 p1 W=2.4e-6 L=1e-6
mnway10_cell21 ML10 gate_way10_cell21 GND GND n1 W=1e-6 L=1e-6
mpway10_cell21 ML10 gate_way10_cell21 GND ML10 p1 W=2.4e-6 L=1e-6
mnway10_cell22 ML10 gate_way10_cell22 GND GND n1 W=1e-6 L=1e-6
mpway10_cell22 ML10 gate_way10_cell22 GND ML10 p1 W=2.4e-6 L=1e-6
mnway10_cell23 ML10 gate_way10_cell23 GND GND n1 W=1e-6 L=1e-6
mpway10_cell23 ML10 gate_way10_cell23 GND ML10 p1 W=2.4e-6 L=1e-6
mnway10_cell24 ML10 gate_way10_cell24 GND GND n1 W=1e-6 L=1e-6
mpway10_cell24 ML10 gate_way10_cell24 GND ML10 p1 W=2.4e-6 L=1e-6
mnway10_cell25 ML10 gate_way10_cell25 GND GND n1 W=1e-6 L=1e-6
mpway10_cell25 ML10 gate_way10_cell25 GND ML10 p1 W=2.4e-6 L=1e-6
mnway10_cell26 ML10 gate_way10_cell26 GND GND n1 W=1e-6 L=1e-6
mpway10_cell26 ML10 gate_way10_cell26 GND ML10 p1 W=2.4e-6 L=1e-6
mnway10_cell27 ML10 gate_way10_cell27 GND GND n1 W=1e-6 L=1e-6
mpway10_cell27 ML10 gate_way10_cell27 GND ML10 p1 W=2.4e-6 L=1e-6
mnway10_cell28 ML10 gate_way10_cell28 GND GND n1 W=1e-6 L=1e-6
mpway10_cell28 ML10 gate_way10_cell28 GND ML10 p1 W=2.4e-6 L=1e-6
mnway10_cell29 ML10 gate_way10_cell29 GND GND n1 W=1e-6 L=1e-6
mpway10_cell29 ML10 gate_way10_cell29 GND ML10 p1 W=2.4e-6 L=1e-6
mnway10_cell30 ML10 gate_way10_cell30 GND GND n1 W=1e-6 L=1e-6
mpway10_cell30 ML10 gate_way10_cell30 GND ML10 p1 W=2.4e-6 L=1e-6
mnway10_cell31 ML10 gate_way10_cell31 GND GND n1 W=1e-6 L=1e-6
mpway10_cell31 ML10 gate_way10_cell31 GND ML10 p1 W=2.4e-6 L=1e-6
mnway10_cell32 ML10 gate_way10_cell32 GND GND n1 W=1e-6 L=1e-6
mpway10_cell32 ML10 gate_way10_cell32 GND ML10 p1 W=2.4e-6 L=1e-6
mnway10_cell33 ML10 gate_way10_cell33 GND GND n1 W=1e-6 L=1e-6
mpway10_cell33 ML10 gate_way10_cell33 GND ML10 p1 W=2.4e-6 L=1e-6
mnway10_cell34 ML10 gate_way10_cell34 GND GND n1 W=1e-6 L=1e-6
mpway10_cell34 ML10 gate_way10_cell34 GND ML10 p1 W=2.4e-6 L=1e-6
mnway10_cell35 ML10 gate_way10_cell35 GND GND n1 W=1e-6 L=1e-6
mpway10_cell35 ML10 gate_way10_cell35 GND ML10 p1 W=2.4e-6 L=1e-6
mnway10_cell36 ML10 gate_way10_cell36 GND GND n1 W=1e-6 L=1e-6
mpway10_cell36 ML10 gate_way10_cell36 GND ML10 p1 W=2.4e-6 L=1e-6
mnway10_cell37 ML10 gate_way10_cell37 GND GND n1 W=1e-6 L=1e-6
mpway10_cell37 ML10 gate_way10_cell37 GND ML10 p1 W=2.4e-6 L=1e-6
mnway10_cell38 ML10 gate_way10_cell38 GND GND n1 W=1e-6 L=1e-6
mpway10_cell38 ML10 gate_way10_cell38 GND ML10 p1 W=2.4e-6 L=1e-6
mnway10_cell39 ML10 gate_way10_cell39 GND GND n1 W=1e-6 L=1e-6
mpway10_cell39 ML10 gate_way10_cell39 GND ML10 p1 W=2.4e-6 L=1e-6
mnway10_cell40 ML10 gate_way10_cell40 GND GND n1 W=1e-6 L=1e-6
mpway10_cell40 ML10 gate_way10_cell40 GND ML10 p1 W=2.4e-6 L=1e-6
mnway10_cell41 ML10 gate_way10_cell41 GND GND n1 W=1e-6 L=1e-6
mpway10_cell41 ML10 gate_way10_cell41 GND ML10 p1 W=2.4e-6 L=1e-6
mnway10_cell42 ML10 gate_way10_cell42 GND GND n1 W=1e-6 L=1e-6
mpway10_cell42 ML10 gate_way10_cell42 GND ML10 p1 W=2.4e-6 L=1e-6
mnway10_cell43 ML10 gate_way10_cell43 GND GND n1 W=1e-6 L=1e-6
mpway10_cell43 ML10 gate_way10_cell43 GND ML10 p1 W=2.4e-6 L=1e-6
mnway10_cell44 ML10 gate_way10_cell44 GND GND n1 W=1e-6 L=1e-6
mpway10_cell44 ML10 gate_way10_cell44 GND ML10 p1 W=2.4e-6 L=1e-6
mnway10_cell45 ML10 gate_way10_cell45 GND GND n1 W=1e-6 L=1e-6
mpway10_cell45 ML10 gate_way10_cell45 GND ML10 p1 W=2.4e-6 L=1e-6
mnway10_cell46 ML10 gate_way10_cell46 GND GND n1 W=1e-6 L=1e-6
mpway10_cell46 ML10 gate_way10_cell46 GND ML10 p1 W=2.4e-6 L=1e-6
mnway10_cell47 ML10 gate_way10_cell47 GND GND n1 W=1e-6 L=1e-6
mpway10_cell47 ML10 gate_way10_cell47 GND ML10 p1 W=2.4e-6 L=1e-6
mnway10_cell48 ML10 gate_way10_cell48 GND GND n1 W=1e-6 L=1e-6
mpway10_cell48 ML10 gate_way10_cell48 GND ML10 p1 W=2.4e-6 L=1e-6
mnway10_cell49 ML10 gate_way10_cell49 GND GND n1 W=1e-6 L=1e-6
mpway10_cell49 ML10 gate_way10_cell49 GND ML10 p1 W=2.4e-6 L=1e-6
mnway10_cell50 ML10 gate_way10_cell50 GND GND n1 W=1e-6 L=1e-6
mpway10_cell50 ML10 gate_way10_cell50 GND ML10 p1 W=2.4e-6 L=1e-6
mnway10_cell51 ML10 gate_way10_cell51 GND GND n1 W=1e-6 L=1e-6
mpway10_cell51 ML10 gate_way10_cell51 GND ML10 p1 W=2.4e-6 L=1e-6
mnway10_cell52 ML10 gate_way10_cell52 GND GND n1 W=1e-6 L=1e-6
mpway10_cell52 ML10 gate_way10_cell52 GND ML10 p1 W=2.4e-6 L=1e-6
mnway10_cell53 ML10 gate_way10_cell53 GND GND n1 W=1e-6 L=1e-6
mpway10_cell53 ML10 gate_way10_cell53 GND ML10 p1 W=2.4e-6 L=1e-6
mnway10_cell54 ML10 gate_way10_cell54 GND GND n1 W=1e-6 L=1e-6
mpway10_cell54 ML10 gate_way10_cell54 GND ML10 p1 W=2.4e-6 L=1e-6
mnway10_cell55 ML10 gate_way10_cell55 GND GND n1 W=1e-6 L=1e-6
mpway10_cell55 ML10 gate_way10_cell55 GND ML10 p1 W=2.4e-6 L=1e-6
mnway10_cell56 ML10 gate_way10_cell56 GND GND n1 W=1e-6 L=1e-6
mpway10_cell56 ML10 gate_way10_cell56 GND ML10 p1 W=2.4e-6 L=1e-6
mnway10_cell57 ML10 gate_way10_cell57 GND GND n1 W=1e-6 L=1e-6
mpway10_cell57 ML10 gate_way10_cell57 GND ML10 p1 W=2.4e-6 L=1e-6
mnway10_cell58 ML10 gate_way10_cell58 GND GND n1 W=1e-6 L=1e-6
mpway10_cell58 ML10 gate_way10_cell58 GND ML10 p1 W=2.4e-6 L=1e-6
mnway10_cell59 ML10 gate_way10_cell59 GND GND n1 W=1e-6 L=1e-6
mpway10_cell59 ML10 gate_way10_cell59 GND ML10 p1 W=2.4e-6 L=1e-6
mnway10_cell60 ML10 gate_way10_cell60 GND GND n1 W=1e-6 L=1e-6
mpway10_cell60 ML10 gate_way10_cell60 GND ML10 p1 W=2.4e-6 L=1e-6
mnway10_cell61 ML10 gate_way10_cell61 GND GND n1 W=1e-6 L=1e-6
mpway10_cell61 ML10 gate_way10_cell61 GND ML10 p1 W=2.4e-6 L=1e-6
mnway10_cell62 ML10 gate_way10_cell62 GND GND n1 W=1e-6 L=1e-6
mpway10_cell62 ML10 gate_way10_cell62 GND ML10 p1 W=2.4e-6 L=1e-6
mnway10_cell63 ML10 gate_way10_cell63 GND GND n1 W=1e-6 L=1e-6
mpway10_cell63 ML10 gate_way10_cell63 GND ML10 p1 W=2.4e-6 L=1e-6
mnway10_cell64 ML10 gate_way10_cell64 GND GND n1 W=1e-6 L=1e-6
mpway10_cell64 ML10 gate_way10_cell64 GND ML10 p1 W=2.4e-6 L=1e-6
mnway10_cell65 ML10 gate_way10_cell65 GND GND n1 W=1e-6 L=1e-6
mpway10_cell65 ML10 gate_way10_cell65 GND ML10 p1 W=2.4e-6 L=1e-6
mnway10_cell66 ML10 gate_way10_cell66 GND GND n1 W=1e-6 L=1e-6
mpway10_cell66 ML10 gate_way10_cell66 GND ML10 p1 W=2.4e-6 L=1e-6
mnway10_cell67 ML10 gate_way10_cell67 GND GND n1 W=1e-6 L=1e-6
mpway10_cell67 ML10 gate_way10_cell67 GND ML10 p1 W=2.4e-6 L=1e-6
mnway10_cell68 ML10 gate_way10_cell68 GND GND n1 W=1e-6 L=1e-6
mpway10_cell68 ML10 gate_way10_cell68 GND ML10 p1 W=2.4e-6 L=1e-6
mnway10_cell69 ML10 gate_way10_cell69 GND GND n1 W=1e-6 L=1e-6
mpway10_cell69 ML10 gate_way10_cell69 GND ML10 p1 W=2.4e-6 L=1e-6
mnway10_cell70 ML10 gate_way10_cell70 GND GND n1 W=1e-6 L=1e-6
mpway10_cell70 ML10 gate_way10_cell70 GND ML10 p1 W=2.4e-6 L=1e-6
mnway10_cell71 ML10 gate_way10_cell71 GND GND n1 W=1e-6 L=1e-6
mpway10_cell71 ML10 gate_way10_cell71 GND ML10 p1 W=2.4e-6 L=1e-6
mnway10_cell72 ML10 gate_way10_cell72 GND GND n1 W=1e-6 L=1e-6
mpway10_cell72 ML10 gate_way10_cell72 GND ML10 p1 W=2.4e-6 L=1e-6
mnway10_cell73 ML10 gate_way10_cell73 GND GND n1 W=1e-6 L=1e-6
mpway10_cell73 ML10 gate_way10_cell73 GND ML10 p1 W=2.4e-6 L=1e-6
mnway10_cell74 ML10 gate_way10_cell74 GND GND n1 W=1e-6 L=1e-6
mpway10_cell74 ML10 gate_way10_cell74 GND ML10 p1 W=2.4e-6 L=1e-6
mnway10_cell75 ML10 gate_way10_cell75 GND GND n1 W=1e-6 L=1e-6
mpway10_cell75 ML10 gate_way10_cell75 GND ML10 p1 W=2.4e-6 L=1e-6
mnway10_cell76 ML10 gate_way10_cell76 GND GND n1 W=1e-6 L=1e-6
mpway10_cell76 ML10 gate_way10_cell76 GND ML10 p1 W=2.4e-6 L=1e-6
mnway10_cell77 ML10 gate_way10_cell77 GND GND n1 W=1e-6 L=1e-6
mpway10_cell77 ML10 gate_way10_cell77 GND ML10 p1 W=2.4e-6 L=1e-6
mnway10_cell78 ML10 gate_way10_cell78 GND GND n1 W=1e-6 L=1e-6
mpway10_cell78 ML10 gate_way10_cell78 GND ML10 p1 W=2.4e-6 L=1e-6
mnway10_cell79 ML10 gate_way10_cell79 GND GND n1 W=1e-6 L=1e-6
mpway10_cell79 ML10 gate_way10_cell79 GND ML10 p1 W=2.4e-6 L=1e-6
mnway10_cell80 ML10 gate_way10_cell80 GND GND n1 W=1e-6 L=1e-6
mpway10_cell80 ML10 gate_way10_cell80 GND ML10 p1 W=2.4e-6 L=1e-6
mnway10_cell81 ML10 gate_way10_cell81 GND GND n1 W=1e-6 L=1e-6
mpway10_cell81 ML10 gate_way10_cell81 GND ML10 p1 W=2.4e-6 L=1e-6
mnway10_cell82 ML10 gate_way10_cell82 GND GND n1 W=1e-6 L=1e-6
mpway10_cell82 ML10 gate_way10_cell82 GND ML10 p1 W=2.4e-6 L=1e-6
mnway10_cell83 ML10 gate_way10_cell83 GND GND n1 W=1e-6 L=1e-6
mpway10_cell83 ML10 gate_way10_cell83 GND ML10 p1 W=2.4e-6 L=1e-6
mnway10_cell84 ML10 gate_way10_cell84 GND GND n1 W=1e-6 L=1e-6
mpway10_cell84 ML10 gate_way10_cell84 GND ML10 p1 W=2.4e-6 L=1e-6
mnway10_cell85 ML10 gate_way10_cell85 GND GND n1 W=1e-6 L=1e-6
mpway10_cell85 ML10 gate_way10_cell85 GND ML10 p1 W=2.4e-6 L=1e-6
mnway10_cell86 ML10 gate_way10_cell86 GND GND n1 W=1e-6 L=1e-6
mpway10_cell86 ML10 gate_way10_cell86 GND ML10 p1 W=2.4e-6 L=1e-6
mnway10_cell87 ML10 gate_way10_cell87 GND GND n1 W=1e-6 L=1e-6
mpway10_cell87 ML10 gate_way10_cell87 GND ML10 p1 W=2.4e-6 L=1e-6
mnway10_cell88 ML10 gate_way10_cell88 GND GND n1 W=1e-6 L=1e-6
mpway10_cell88 ML10 gate_way10_cell88 GND ML10 p1 W=2.4e-6 L=1e-6
mnway10_cell89 ML10 gate_way10_cell89 GND GND n1 W=1e-6 L=1e-6
mpway10_cell89 ML10 gate_way10_cell89 GND ML10 p1 W=2.4e-6 L=1e-6
mnway10_cell90 ML10 gate_way10_cell90 GND GND n1 W=1e-6 L=1e-6
mpway10_cell90 ML10 gate_way10_cell90 GND ML10 p1 W=2.4e-6 L=1e-6
mnway10_cell91 ML10 gate_way10_cell91 GND GND n1 W=1e-6 L=1e-6
mpway10_cell91 ML10 gate_way10_cell91 GND ML10 p1 W=2.4e-6 L=1e-6
mnway10_cell92 ML10 gate_way10_cell92 GND GND n1 W=1e-6 L=1e-6
mpway10_cell92 ML10 gate_way10_cell92 GND ML10 p1 W=2.4e-6 L=1e-6
mnway10_cell93 ML10 gate_way10_cell93 GND GND n1 W=1e-6 L=1e-6
mpway10_cell93 ML10 gate_way10_cell93 GND ML10 p1 W=2.4e-6 L=1e-6
mnway10_cell94 ML10 gate_way10_cell94 GND GND n1 W=1e-6 L=1e-6
mpway10_cell94 ML10 gate_way10_cell94 GND ML10 p1 W=2.4e-6 L=1e-6
mnway10_cell95 ML10 gate_way10_cell95 GND GND n1 W=1e-6 L=1e-6
mpway10_cell95 ML10 gate_way10_cell95 GND ML10 p1 W=2.4e-6 L=1e-6
mnway10_cell96 ML10 gate_way10_cell96 GND GND n1 W=1e-6 L=1e-6
mpway10_cell96 ML10 gate_way10_cell96 GND ML10 p1 W=2.4e-6 L=1e-6
mnway10_cell97 ML10 gate_way10_cell97 GND GND n1 W=1e-6 L=1e-6
mpway10_cell97 ML10 gate_way10_cell97 GND ML10 p1 W=2.4e-6 L=1e-6
mnway10_cell98 ML10 gate_way10_cell98 GND GND n1 W=1e-6 L=1e-6
mpway10_cell98 ML10 gate_way10_cell98 GND ML10 p1 W=2.4e-6 L=1e-6
mnway10_cell99 ML10 gate_way10_cell99 GND GND n1 W=1e-6 L=1e-6
mpway10_cell99 ML10 gate_way10_cell99 GND ML10 p1 W=2.4e-6 L=1e-6
mnway11_cell0 ML11 gate_way11_cell0 GND GND n1 W=1e-6 L=1e-6
mpway11_cell0 ML11 gate_way11_cell0 GND ML11 p1 W=2.4e-6 L=1e-6
mnway11_cell1 ML11 gate_way11_cell1 GND GND n1 W=1e-6 L=1e-6
mpway11_cell1 ML11 gate_way11_cell1 GND ML11 p1 W=2.4e-6 L=1e-6
mnway11_cell2 ML11 gate_way11_cell2 GND GND n1 W=1e-6 L=1e-6
mpway11_cell2 ML11 gate_way11_cell2 GND ML11 p1 W=2.4e-6 L=1e-6
mnway11_cell3 ML11 gate_way11_cell3 GND GND n1 W=1e-6 L=1e-6
mpway11_cell3 ML11 gate_way11_cell3 GND ML11 p1 W=2.4e-6 L=1e-6
mnway11_cell4 ML11 gate_way11_cell4 GND GND n1 W=1e-6 L=1e-6
mpway11_cell4 ML11 gate_way11_cell4 GND ML11 p1 W=2.4e-6 L=1e-6
mnway11_cell5 ML11 gate_way11_cell5 GND GND n1 W=1e-6 L=1e-6
mpway11_cell5 ML11 gate_way11_cell5 GND ML11 p1 W=2.4e-6 L=1e-6
mnway11_cell6 ML11 gate_way11_cell6 GND GND n1 W=1e-6 L=1e-6
mpway11_cell6 ML11 gate_way11_cell6 GND ML11 p1 W=2.4e-6 L=1e-6
mnway11_cell7 ML11 gate_way11_cell7 GND GND n1 W=1e-6 L=1e-6
mpway11_cell7 ML11 gate_way11_cell7 GND ML11 p1 W=2.4e-6 L=1e-6
mnway11_cell8 ML11 gate_way11_cell8 GND GND n1 W=1e-6 L=1e-6
mpway11_cell8 ML11 gate_way11_cell8 GND ML11 p1 W=2.4e-6 L=1e-6
mnway11_cell9 ML11 gate_way11_cell9 GND GND n1 W=1e-6 L=1e-6
mpway11_cell9 ML11 gate_way11_cell9 GND ML11 p1 W=2.4e-6 L=1e-6
mnway11_cell10 ML11 gate_way11_cell10 GND GND n1 W=1e-6 L=1e-6
mpway11_cell10 ML11 gate_way11_cell10 GND ML11 p1 W=2.4e-6 L=1e-6
mnway11_cell11 ML11 gate_way11_cell11 GND GND n1 W=1e-6 L=1e-6
mpway11_cell11 ML11 gate_way11_cell11 GND ML11 p1 W=2.4e-6 L=1e-6
mnway11_cell12 ML11 gate_way11_cell12 GND GND n1 W=1e-6 L=1e-6
mpway11_cell12 ML11 gate_way11_cell12 GND ML11 p1 W=2.4e-6 L=1e-6
mnway11_cell13 ML11 gate_way11_cell13 GND GND n1 W=1e-6 L=1e-6
mpway11_cell13 ML11 gate_way11_cell13 GND ML11 p1 W=2.4e-6 L=1e-6
mnway11_cell14 ML11 gate_way11_cell14 GND GND n1 W=1e-6 L=1e-6
mpway11_cell14 ML11 gate_way11_cell14 GND ML11 p1 W=2.4e-6 L=1e-6
mnway11_cell15 ML11 gate_way11_cell15 GND GND n1 W=1e-6 L=1e-6
mpway11_cell15 ML11 gate_way11_cell15 GND ML11 p1 W=2.4e-6 L=1e-6
mnway11_cell16 ML11 gate_way11_cell16 GND GND n1 W=1e-6 L=1e-6
mpway11_cell16 ML11 gate_way11_cell16 GND ML11 p1 W=2.4e-6 L=1e-6
mnway11_cell17 ML11 gate_way11_cell17 GND GND n1 W=1e-6 L=1e-6
mpway11_cell17 ML11 gate_way11_cell17 GND ML11 p1 W=2.4e-6 L=1e-6
mnway11_cell18 ML11 gate_way11_cell18 GND GND n1 W=1e-6 L=1e-6
mpway11_cell18 ML11 gate_way11_cell18 GND ML11 p1 W=2.4e-6 L=1e-6
mnway11_cell19 ML11 gate_way11_cell19 GND GND n1 W=1e-6 L=1e-6
mpway11_cell19 ML11 gate_way11_cell19 GND ML11 p1 W=2.4e-6 L=1e-6
mnway11_cell20 ML11 gate_way11_cell20 GND GND n1 W=1e-6 L=1e-6
mpway11_cell20 ML11 gate_way11_cell20 GND ML11 p1 W=2.4e-6 L=1e-6
mnway11_cell21 ML11 gate_way11_cell21 GND GND n1 W=1e-6 L=1e-6
mpway11_cell21 ML11 gate_way11_cell21 GND ML11 p1 W=2.4e-6 L=1e-6
mnway11_cell22 ML11 gate_way11_cell22 GND GND n1 W=1e-6 L=1e-6
mpway11_cell22 ML11 gate_way11_cell22 GND ML11 p1 W=2.4e-6 L=1e-6
mnway11_cell23 ML11 gate_way11_cell23 GND GND n1 W=1e-6 L=1e-6
mpway11_cell23 ML11 gate_way11_cell23 GND ML11 p1 W=2.4e-6 L=1e-6
mnway11_cell24 ML11 gate_way11_cell24 GND GND n1 W=1e-6 L=1e-6
mpway11_cell24 ML11 gate_way11_cell24 GND ML11 p1 W=2.4e-6 L=1e-6
mnway11_cell25 ML11 gate_way11_cell25 GND GND n1 W=1e-6 L=1e-6
mpway11_cell25 ML11 gate_way11_cell25 GND ML11 p1 W=2.4e-6 L=1e-6
mnway11_cell26 ML11 gate_way11_cell26 GND GND n1 W=1e-6 L=1e-6
mpway11_cell26 ML11 gate_way11_cell26 GND ML11 p1 W=2.4e-6 L=1e-6
mnway11_cell27 ML11 gate_way11_cell27 GND GND n1 W=1e-6 L=1e-6
mpway11_cell27 ML11 gate_way11_cell27 GND ML11 p1 W=2.4e-6 L=1e-6
mnway11_cell28 ML11 gate_way11_cell28 GND GND n1 W=1e-6 L=1e-6
mpway11_cell28 ML11 gate_way11_cell28 GND ML11 p1 W=2.4e-6 L=1e-6
mnway11_cell29 ML11 gate_way11_cell29 GND GND n1 W=1e-6 L=1e-6
mpway11_cell29 ML11 gate_way11_cell29 GND ML11 p1 W=2.4e-6 L=1e-6
mnway11_cell30 ML11 gate_way11_cell30 GND GND n1 W=1e-6 L=1e-6
mpway11_cell30 ML11 gate_way11_cell30 GND ML11 p1 W=2.4e-6 L=1e-6
mnway11_cell31 ML11 gate_way11_cell31 GND GND n1 W=1e-6 L=1e-6
mpway11_cell31 ML11 gate_way11_cell31 GND ML11 p1 W=2.4e-6 L=1e-6
mnway11_cell32 ML11 gate_way11_cell32 GND GND n1 W=1e-6 L=1e-6
mpway11_cell32 ML11 gate_way11_cell32 GND ML11 p1 W=2.4e-6 L=1e-6
mnway11_cell33 ML11 gate_way11_cell33 GND GND n1 W=1e-6 L=1e-6
mpway11_cell33 ML11 gate_way11_cell33 GND ML11 p1 W=2.4e-6 L=1e-6
mnway11_cell34 ML11 gate_way11_cell34 GND GND n1 W=1e-6 L=1e-6
mpway11_cell34 ML11 gate_way11_cell34 GND ML11 p1 W=2.4e-6 L=1e-6
mnway11_cell35 ML11 gate_way11_cell35 GND GND n1 W=1e-6 L=1e-6
mpway11_cell35 ML11 gate_way11_cell35 GND ML11 p1 W=2.4e-6 L=1e-6
mnway11_cell36 ML11 gate_way11_cell36 GND GND n1 W=1e-6 L=1e-6
mpway11_cell36 ML11 gate_way11_cell36 GND ML11 p1 W=2.4e-6 L=1e-6
mnway11_cell37 ML11 gate_way11_cell37 GND GND n1 W=1e-6 L=1e-6
mpway11_cell37 ML11 gate_way11_cell37 GND ML11 p1 W=2.4e-6 L=1e-6
mnway11_cell38 ML11 gate_way11_cell38 GND GND n1 W=1e-6 L=1e-6
mpway11_cell38 ML11 gate_way11_cell38 GND ML11 p1 W=2.4e-6 L=1e-6
mnway11_cell39 ML11 gate_way11_cell39 GND GND n1 W=1e-6 L=1e-6
mpway11_cell39 ML11 gate_way11_cell39 GND ML11 p1 W=2.4e-6 L=1e-6
mnway11_cell40 ML11 gate_way11_cell40 GND GND n1 W=1e-6 L=1e-6
mpway11_cell40 ML11 gate_way11_cell40 GND ML11 p1 W=2.4e-6 L=1e-6
mnway11_cell41 ML11 gate_way11_cell41 GND GND n1 W=1e-6 L=1e-6
mpway11_cell41 ML11 gate_way11_cell41 GND ML11 p1 W=2.4e-6 L=1e-6
mnway11_cell42 ML11 gate_way11_cell42 GND GND n1 W=1e-6 L=1e-6
mpway11_cell42 ML11 gate_way11_cell42 GND ML11 p1 W=2.4e-6 L=1e-6
mnway11_cell43 ML11 gate_way11_cell43 GND GND n1 W=1e-6 L=1e-6
mpway11_cell43 ML11 gate_way11_cell43 GND ML11 p1 W=2.4e-6 L=1e-6
mnway11_cell44 ML11 gate_way11_cell44 GND GND n1 W=1e-6 L=1e-6
mpway11_cell44 ML11 gate_way11_cell44 GND ML11 p1 W=2.4e-6 L=1e-6
mnway11_cell45 ML11 gate_way11_cell45 GND GND n1 W=1e-6 L=1e-6
mpway11_cell45 ML11 gate_way11_cell45 GND ML11 p1 W=2.4e-6 L=1e-6
mnway11_cell46 ML11 gate_way11_cell46 GND GND n1 W=1e-6 L=1e-6
mpway11_cell46 ML11 gate_way11_cell46 GND ML11 p1 W=2.4e-6 L=1e-6
mnway11_cell47 ML11 gate_way11_cell47 GND GND n1 W=1e-6 L=1e-6
mpway11_cell47 ML11 gate_way11_cell47 GND ML11 p1 W=2.4e-6 L=1e-6
mnway11_cell48 ML11 gate_way11_cell48 GND GND n1 W=1e-6 L=1e-6
mpway11_cell48 ML11 gate_way11_cell48 GND ML11 p1 W=2.4e-6 L=1e-6
mnway11_cell49 ML11 gate_way11_cell49 GND GND n1 W=1e-6 L=1e-6
mpway11_cell49 ML11 gate_way11_cell49 GND ML11 p1 W=2.4e-6 L=1e-6
mnway11_cell50 ML11 gate_way11_cell50 GND GND n1 W=1e-6 L=1e-6
mpway11_cell50 ML11 gate_way11_cell50 GND ML11 p1 W=2.4e-6 L=1e-6
mnway11_cell51 ML11 gate_way11_cell51 GND GND n1 W=1e-6 L=1e-6
mpway11_cell51 ML11 gate_way11_cell51 GND ML11 p1 W=2.4e-6 L=1e-6
mnway11_cell52 ML11 gate_way11_cell52 GND GND n1 W=1e-6 L=1e-6
mpway11_cell52 ML11 gate_way11_cell52 GND ML11 p1 W=2.4e-6 L=1e-6
mnway11_cell53 ML11 gate_way11_cell53 GND GND n1 W=1e-6 L=1e-6
mpway11_cell53 ML11 gate_way11_cell53 GND ML11 p1 W=2.4e-6 L=1e-6
mnway11_cell54 ML11 gate_way11_cell54 GND GND n1 W=1e-6 L=1e-6
mpway11_cell54 ML11 gate_way11_cell54 GND ML11 p1 W=2.4e-6 L=1e-6
mnway11_cell55 ML11 gate_way11_cell55 GND GND n1 W=1e-6 L=1e-6
mpway11_cell55 ML11 gate_way11_cell55 GND ML11 p1 W=2.4e-6 L=1e-6
mnway11_cell56 ML11 gate_way11_cell56 GND GND n1 W=1e-6 L=1e-6
mpway11_cell56 ML11 gate_way11_cell56 GND ML11 p1 W=2.4e-6 L=1e-6
mnway11_cell57 ML11 gate_way11_cell57 GND GND n1 W=1e-6 L=1e-6
mpway11_cell57 ML11 gate_way11_cell57 GND ML11 p1 W=2.4e-6 L=1e-6
mnway11_cell58 ML11 gate_way11_cell58 GND GND n1 W=1e-6 L=1e-6
mpway11_cell58 ML11 gate_way11_cell58 GND ML11 p1 W=2.4e-6 L=1e-6
mnway11_cell59 ML11 gate_way11_cell59 GND GND n1 W=1e-6 L=1e-6
mpway11_cell59 ML11 gate_way11_cell59 GND ML11 p1 W=2.4e-6 L=1e-6
mnway11_cell60 ML11 gate_way11_cell60 GND GND n1 W=1e-6 L=1e-6
mpway11_cell60 ML11 gate_way11_cell60 GND ML11 p1 W=2.4e-6 L=1e-6
mnway11_cell61 ML11 gate_way11_cell61 GND GND n1 W=1e-6 L=1e-6
mpway11_cell61 ML11 gate_way11_cell61 GND ML11 p1 W=2.4e-6 L=1e-6
mnway11_cell62 ML11 gate_way11_cell62 GND GND n1 W=1e-6 L=1e-6
mpway11_cell62 ML11 gate_way11_cell62 GND ML11 p1 W=2.4e-6 L=1e-6
mnway11_cell63 ML11 gate_way11_cell63 GND GND n1 W=1e-6 L=1e-6
mpway11_cell63 ML11 gate_way11_cell63 GND ML11 p1 W=2.4e-6 L=1e-6
mnway11_cell64 ML11 gate_way11_cell64 GND GND n1 W=1e-6 L=1e-6
mpway11_cell64 ML11 gate_way11_cell64 GND ML11 p1 W=2.4e-6 L=1e-6
mnway11_cell65 ML11 gate_way11_cell65 GND GND n1 W=1e-6 L=1e-6
mpway11_cell65 ML11 gate_way11_cell65 GND ML11 p1 W=2.4e-6 L=1e-6
mnway11_cell66 ML11 gate_way11_cell66 GND GND n1 W=1e-6 L=1e-6
mpway11_cell66 ML11 gate_way11_cell66 GND ML11 p1 W=2.4e-6 L=1e-6
mnway11_cell67 ML11 gate_way11_cell67 GND GND n1 W=1e-6 L=1e-6
mpway11_cell67 ML11 gate_way11_cell67 GND ML11 p1 W=2.4e-6 L=1e-6
mnway11_cell68 ML11 gate_way11_cell68 GND GND n1 W=1e-6 L=1e-6
mpway11_cell68 ML11 gate_way11_cell68 GND ML11 p1 W=2.4e-6 L=1e-6
mnway11_cell69 ML11 gate_way11_cell69 GND GND n1 W=1e-6 L=1e-6
mpway11_cell69 ML11 gate_way11_cell69 GND ML11 p1 W=2.4e-6 L=1e-6
mnway11_cell70 ML11 gate_way11_cell70 GND GND n1 W=1e-6 L=1e-6
mpway11_cell70 ML11 gate_way11_cell70 GND ML11 p1 W=2.4e-6 L=1e-6
mnway11_cell71 ML11 gate_way11_cell71 GND GND n1 W=1e-6 L=1e-6
mpway11_cell71 ML11 gate_way11_cell71 GND ML11 p1 W=2.4e-6 L=1e-6
mnway11_cell72 ML11 gate_way11_cell72 GND GND n1 W=1e-6 L=1e-6
mpway11_cell72 ML11 gate_way11_cell72 GND ML11 p1 W=2.4e-6 L=1e-6
mnway11_cell73 ML11 gate_way11_cell73 GND GND n1 W=1e-6 L=1e-6
mpway11_cell73 ML11 gate_way11_cell73 GND ML11 p1 W=2.4e-6 L=1e-6
mnway11_cell74 ML11 gate_way11_cell74 GND GND n1 W=1e-6 L=1e-6
mpway11_cell74 ML11 gate_way11_cell74 GND ML11 p1 W=2.4e-6 L=1e-6
mnway11_cell75 ML11 gate_way11_cell75 GND GND n1 W=1e-6 L=1e-6
mpway11_cell75 ML11 gate_way11_cell75 GND ML11 p1 W=2.4e-6 L=1e-6
mnway11_cell76 ML11 gate_way11_cell76 GND GND n1 W=1e-6 L=1e-6
mpway11_cell76 ML11 gate_way11_cell76 GND ML11 p1 W=2.4e-6 L=1e-6
mnway11_cell77 ML11 gate_way11_cell77 GND GND n1 W=1e-6 L=1e-6
mpway11_cell77 ML11 gate_way11_cell77 GND ML11 p1 W=2.4e-6 L=1e-6
mnway11_cell78 ML11 gate_way11_cell78 GND GND n1 W=1e-6 L=1e-6
mpway11_cell78 ML11 gate_way11_cell78 GND ML11 p1 W=2.4e-6 L=1e-6
mnway11_cell79 ML11 gate_way11_cell79 GND GND n1 W=1e-6 L=1e-6
mpway11_cell79 ML11 gate_way11_cell79 GND ML11 p1 W=2.4e-6 L=1e-6
mnway11_cell80 ML11 gate_way11_cell80 GND GND n1 W=1e-6 L=1e-6
mpway11_cell80 ML11 gate_way11_cell80 GND ML11 p1 W=2.4e-6 L=1e-6
mnway11_cell81 ML11 gate_way11_cell81 GND GND n1 W=1e-6 L=1e-6
mpway11_cell81 ML11 gate_way11_cell81 GND ML11 p1 W=2.4e-6 L=1e-6
mnway11_cell82 ML11 gate_way11_cell82 GND GND n1 W=1e-6 L=1e-6
mpway11_cell82 ML11 gate_way11_cell82 GND ML11 p1 W=2.4e-6 L=1e-6
mnway11_cell83 ML11 gate_way11_cell83 GND GND n1 W=1e-6 L=1e-6
mpway11_cell83 ML11 gate_way11_cell83 GND ML11 p1 W=2.4e-6 L=1e-6
mnway11_cell84 ML11 gate_way11_cell84 GND GND n1 W=1e-6 L=1e-6
mpway11_cell84 ML11 gate_way11_cell84 GND ML11 p1 W=2.4e-6 L=1e-6
mnway11_cell85 ML11 gate_way11_cell85 GND GND n1 W=1e-6 L=1e-6
mpway11_cell85 ML11 gate_way11_cell85 GND ML11 p1 W=2.4e-6 L=1e-6
mnway11_cell86 ML11 gate_way11_cell86 GND GND n1 W=1e-6 L=1e-6
mpway11_cell86 ML11 gate_way11_cell86 GND ML11 p1 W=2.4e-6 L=1e-6
mnway11_cell87 ML11 gate_way11_cell87 GND GND n1 W=1e-6 L=1e-6
mpway11_cell87 ML11 gate_way11_cell87 GND ML11 p1 W=2.4e-6 L=1e-6
mnway11_cell88 ML11 gate_way11_cell88 GND GND n1 W=1e-6 L=1e-6
mpway11_cell88 ML11 gate_way11_cell88 GND ML11 p1 W=2.4e-6 L=1e-6
mnway11_cell89 ML11 gate_way11_cell89 GND GND n1 W=1e-6 L=1e-6
mpway11_cell89 ML11 gate_way11_cell89 GND ML11 p1 W=2.4e-6 L=1e-6
mnway11_cell90 ML11 gate_way11_cell90 GND GND n1 W=1e-6 L=1e-6
mpway11_cell90 ML11 gate_way11_cell90 GND ML11 p1 W=2.4e-6 L=1e-6
mnway11_cell91 ML11 gate_way11_cell91 GND GND n1 W=1e-6 L=1e-6
mpway11_cell91 ML11 gate_way11_cell91 GND ML11 p1 W=2.4e-6 L=1e-6
mnway11_cell92 ML11 gate_way11_cell92 GND GND n1 W=1e-6 L=1e-6
mpway11_cell92 ML11 gate_way11_cell92 GND ML11 p1 W=2.4e-6 L=1e-6
mnway11_cell93 ML11 gate_way11_cell93 GND GND n1 W=1e-6 L=1e-6
mpway11_cell93 ML11 gate_way11_cell93 GND ML11 p1 W=2.4e-6 L=1e-6
mnway11_cell94 ML11 gate_way11_cell94 GND GND n1 W=1e-6 L=1e-6
mpway11_cell94 ML11 gate_way11_cell94 GND ML11 p1 W=2.4e-6 L=1e-6
mnway11_cell95 ML11 gate_way11_cell95 GND GND n1 W=1e-6 L=1e-6
mpway11_cell95 ML11 gate_way11_cell95 GND ML11 p1 W=2.4e-6 L=1e-6
mnway11_cell96 ML11 gate_way11_cell96 GND GND n1 W=1e-6 L=1e-6
mpway11_cell96 ML11 gate_way11_cell96 GND ML11 p1 W=2.4e-6 L=1e-6
mnway11_cell97 ML11 gate_way11_cell97 GND GND n1 W=1e-6 L=1e-6
mpway11_cell97 ML11 gate_way11_cell97 GND ML11 p1 W=2.4e-6 L=1e-6
mnway11_cell98 ML11 gate_way11_cell98 GND GND n1 W=1e-6 L=1e-6
mpway11_cell98 ML11 gate_way11_cell98 GND ML11 p1 W=2.4e-6 L=1e-6
mnway11_cell99 ML11 gate_way11_cell99 GND GND n1 W=1e-6 L=1e-6
mpway11_cell99 ML11 gate_way11_cell99 GND ML11 p1 W=2.4e-6 L=1e-6
mnway12_cell0 ML12 gate_way12_cell0 GND GND n1 W=1e-6 L=1e-6
mpway12_cell0 ML12 gate_way12_cell0 GND ML12 p1 W=2.4e-6 L=1e-6
mnway12_cell1 ML12 gate_way12_cell1 GND GND n1 W=1e-6 L=1e-6
mpway12_cell1 ML12 gate_way12_cell1 GND ML12 p1 W=2.4e-6 L=1e-6
mnway12_cell2 ML12 gate_way12_cell2 GND GND n1 W=1e-6 L=1e-6
mpway12_cell2 ML12 gate_way12_cell2 GND ML12 p1 W=2.4e-6 L=1e-6
mnway12_cell3 ML12 gate_way12_cell3 GND GND n1 W=1e-6 L=1e-6
mpway12_cell3 ML12 gate_way12_cell3 GND ML12 p1 W=2.4e-6 L=1e-6
mnway12_cell4 ML12 gate_way12_cell4 GND GND n1 W=1e-6 L=1e-6
mpway12_cell4 ML12 gate_way12_cell4 GND ML12 p1 W=2.4e-6 L=1e-6
mnway12_cell5 ML12 gate_way12_cell5 GND GND n1 W=1e-6 L=1e-6
mpway12_cell5 ML12 gate_way12_cell5 GND ML12 p1 W=2.4e-6 L=1e-6
mnway12_cell6 ML12 gate_way12_cell6 GND GND n1 W=1e-6 L=1e-6
mpway12_cell6 ML12 gate_way12_cell6 GND ML12 p1 W=2.4e-6 L=1e-6
mnway12_cell7 ML12 gate_way12_cell7 GND GND n1 W=1e-6 L=1e-6
mpway12_cell7 ML12 gate_way12_cell7 GND ML12 p1 W=2.4e-6 L=1e-6
mnway12_cell8 ML12 gate_way12_cell8 GND GND n1 W=1e-6 L=1e-6
mpway12_cell8 ML12 gate_way12_cell8 GND ML12 p1 W=2.4e-6 L=1e-6
mnway12_cell9 ML12 gate_way12_cell9 GND GND n1 W=1e-6 L=1e-6
mpway12_cell9 ML12 gate_way12_cell9 GND ML12 p1 W=2.4e-6 L=1e-6
mnway12_cell10 ML12 gate_way12_cell10 GND GND n1 W=1e-6 L=1e-6
mpway12_cell10 ML12 gate_way12_cell10 GND ML12 p1 W=2.4e-6 L=1e-6
mnway12_cell11 ML12 gate_way12_cell11 GND GND n1 W=1e-6 L=1e-6
mpway12_cell11 ML12 gate_way12_cell11 GND ML12 p1 W=2.4e-6 L=1e-6
mnway12_cell12 ML12 gate_way12_cell12 GND GND n1 W=1e-6 L=1e-6
mpway12_cell12 ML12 gate_way12_cell12 GND ML12 p1 W=2.4e-6 L=1e-6
mnway12_cell13 ML12 gate_way12_cell13 GND GND n1 W=1e-6 L=1e-6
mpway12_cell13 ML12 gate_way12_cell13 GND ML12 p1 W=2.4e-6 L=1e-6
mnway12_cell14 ML12 gate_way12_cell14 GND GND n1 W=1e-6 L=1e-6
mpway12_cell14 ML12 gate_way12_cell14 GND ML12 p1 W=2.4e-6 L=1e-6
mnway12_cell15 ML12 gate_way12_cell15 GND GND n1 W=1e-6 L=1e-6
mpway12_cell15 ML12 gate_way12_cell15 GND ML12 p1 W=2.4e-6 L=1e-6
mnway12_cell16 ML12 gate_way12_cell16 GND GND n1 W=1e-6 L=1e-6
mpway12_cell16 ML12 gate_way12_cell16 GND ML12 p1 W=2.4e-6 L=1e-6
mnway12_cell17 ML12 gate_way12_cell17 GND GND n1 W=1e-6 L=1e-6
mpway12_cell17 ML12 gate_way12_cell17 GND ML12 p1 W=2.4e-6 L=1e-6
mnway12_cell18 ML12 gate_way12_cell18 GND GND n1 W=1e-6 L=1e-6
mpway12_cell18 ML12 gate_way12_cell18 GND ML12 p1 W=2.4e-6 L=1e-6
mnway12_cell19 ML12 gate_way12_cell19 GND GND n1 W=1e-6 L=1e-6
mpway12_cell19 ML12 gate_way12_cell19 GND ML12 p1 W=2.4e-6 L=1e-6
mnway12_cell20 ML12 gate_way12_cell20 GND GND n1 W=1e-6 L=1e-6
mpway12_cell20 ML12 gate_way12_cell20 GND ML12 p1 W=2.4e-6 L=1e-6
mnway12_cell21 ML12 gate_way12_cell21 GND GND n1 W=1e-6 L=1e-6
mpway12_cell21 ML12 gate_way12_cell21 GND ML12 p1 W=2.4e-6 L=1e-6
mnway12_cell22 ML12 gate_way12_cell22 GND GND n1 W=1e-6 L=1e-6
mpway12_cell22 ML12 gate_way12_cell22 GND ML12 p1 W=2.4e-6 L=1e-6
mnway12_cell23 ML12 gate_way12_cell23 GND GND n1 W=1e-6 L=1e-6
mpway12_cell23 ML12 gate_way12_cell23 GND ML12 p1 W=2.4e-6 L=1e-6
mnway12_cell24 ML12 gate_way12_cell24 GND GND n1 W=1e-6 L=1e-6
mpway12_cell24 ML12 gate_way12_cell24 GND ML12 p1 W=2.4e-6 L=1e-6
mnway12_cell25 ML12 gate_way12_cell25 GND GND n1 W=1e-6 L=1e-6
mpway12_cell25 ML12 gate_way12_cell25 GND ML12 p1 W=2.4e-6 L=1e-6
mnway12_cell26 ML12 gate_way12_cell26 GND GND n1 W=1e-6 L=1e-6
mpway12_cell26 ML12 gate_way12_cell26 GND ML12 p1 W=2.4e-6 L=1e-6
mnway12_cell27 ML12 gate_way12_cell27 GND GND n1 W=1e-6 L=1e-6
mpway12_cell27 ML12 gate_way12_cell27 GND ML12 p1 W=2.4e-6 L=1e-6
mnway12_cell28 ML12 gate_way12_cell28 GND GND n1 W=1e-6 L=1e-6
mpway12_cell28 ML12 gate_way12_cell28 GND ML12 p1 W=2.4e-6 L=1e-6
mnway12_cell29 ML12 gate_way12_cell29 GND GND n1 W=1e-6 L=1e-6
mpway12_cell29 ML12 gate_way12_cell29 GND ML12 p1 W=2.4e-6 L=1e-6
mnway12_cell30 ML12 gate_way12_cell30 GND GND n1 W=1e-6 L=1e-6
mpway12_cell30 ML12 gate_way12_cell30 GND ML12 p1 W=2.4e-6 L=1e-6
mnway12_cell31 ML12 gate_way12_cell31 GND GND n1 W=1e-6 L=1e-6
mpway12_cell31 ML12 gate_way12_cell31 GND ML12 p1 W=2.4e-6 L=1e-6
mnway12_cell32 ML12 gate_way12_cell32 GND GND n1 W=1e-6 L=1e-6
mpway12_cell32 ML12 gate_way12_cell32 GND ML12 p1 W=2.4e-6 L=1e-6
mnway12_cell33 ML12 gate_way12_cell33 GND GND n1 W=1e-6 L=1e-6
mpway12_cell33 ML12 gate_way12_cell33 GND ML12 p1 W=2.4e-6 L=1e-6
mnway12_cell34 ML12 gate_way12_cell34 GND GND n1 W=1e-6 L=1e-6
mpway12_cell34 ML12 gate_way12_cell34 GND ML12 p1 W=2.4e-6 L=1e-6
mnway12_cell35 ML12 gate_way12_cell35 GND GND n1 W=1e-6 L=1e-6
mpway12_cell35 ML12 gate_way12_cell35 GND ML12 p1 W=2.4e-6 L=1e-6
mnway12_cell36 ML12 gate_way12_cell36 GND GND n1 W=1e-6 L=1e-6
mpway12_cell36 ML12 gate_way12_cell36 GND ML12 p1 W=2.4e-6 L=1e-6
mnway12_cell37 ML12 gate_way12_cell37 GND GND n1 W=1e-6 L=1e-6
mpway12_cell37 ML12 gate_way12_cell37 GND ML12 p1 W=2.4e-6 L=1e-6
mnway12_cell38 ML12 gate_way12_cell38 GND GND n1 W=1e-6 L=1e-6
mpway12_cell38 ML12 gate_way12_cell38 GND ML12 p1 W=2.4e-6 L=1e-6
mnway12_cell39 ML12 gate_way12_cell39 GND GND n1 W=1e-6 L=1e-6
mpway12_cell39 ML12 gate_way12_cell39 GND ML12 p1 W=2.4e-6 L=1e-6
mnway12_cell40 ML12 gate_way12_cell40 GND GND n1 W=1e-6 L=1e-6
mpway12_cell40 ML12 gate_way12_cell40 GND ML12 p1 W=2.4e-6 L=1e-6
mnway12_cell41 ML12 gate_way12_cell41 GND GND n1 W=1e-6 L=1e-6
mpway12_cell41 ML12 gate_way12_cell41 GND ML12 p1 W=2.4e-6 L=1e-6
mnway12_cell42 ML12 gate_way12_cell42 GND GND n1 W=1e-6 L=1e-6
mpway12_cell42 ML12 gate_way12_cell42 GND ML12 p1 W=2.4e-6 L=1e-6
mnway12_cell43 ML12 gate_way12_cell43 GND GND n1 W=1e-6 L=1e-6
mpway12_cell43 ML12 gate_way12_cell43 GND ML12 p1 W=2.4e-6 L=1e-6
mnway12_cell44 ML12 gate_way12_cell44 GND GND n1 W=1e-6 L=1e-6
mpway12_cell44 ML12 gate_way12_cell44 GND ML12 p1 W=2.4e-6 L=1e-6
mnway12_cell45 ML12 gate_way12_cell45 GND GND n1 W=1e-6 L=1e-6
mpway12_cell45 ML12 gate_way12_cell45 GND ML12 p1 W=2.4e-6 L=1e-6
mnway12_cell46 ML12 gate_way12_cell46 GND GND n1 W=1e-6 L=1e-6
mpway12_cell46 ML12 gate_way12_cell46 GND ML12 p1 W=2.4e-6 L=1e-6
mnway12_cell47 ML12 gate_way12_cell47 GND GND n1 W=1e-6 L=1e-6
mpway12_cell47 ML12 gate_way12_cell47 GND ML12 p1 W=2.4e-6 L=1e-6
mnway12_cell48 ML12 gate_way12_cell48 GND GND n1 W=1e-6 L=1e-6
mpway12_cell48 ML12 gate_way12_cell48 GND ML12 p1 W=2.4e-6 L=1e-6
mnway12_cell49 ML12 gate_way12_cell49 GND GND n1 W=1e-6 L=1e-6
mpway12_cell49 ML12 gate_way12_cell49 GND ML12 p1 W=2.4e-6 L=1e-6
mnway12_cell50 ML12 gate_way12_cell50 GND GND n1 W=1e-6 L=1e-6
mpway12_cell50 ML12 gate_way12_cell50 GND ML12 p1 W=2.4e-6 L=1e-6
mnway12_cell51 ML12 gate_way12_cell51 GND GND n1 W=1e-6 L=1e-6
mpway12_cell51 ML12 gate_way12_cell51 GND ML12 p1 W=2.4e-6 L=1e-6
mnway12_cell52 ML12 gate_way12_cell52 GND GND n1 W=1e-6 L=1e-6
mpway12_cell52 ML12 gate_way12_cell52 GND ML12 p1 W=2.4e-6 L=1e-6
mnway12_cell53 ML12 gate_way12_cell53 GND GND n1 W=1e-6 L=1e-6
mpway12_cell53 ML12 gate_way12_cell53 GND ML12 p1 W=2.4e-6 L=1e-6
mnway12_cell54 ML12 gate_way12_cell54 GND GND n1 W=1e-6 L=1e-6
mpway12_cell54 ML12 gate_way12_cell54 GND ML12 p1 W=2.4e-6 L=1e-6
mnway12_cell55 ML12 gate_way12_cell55 GND GND n1 W=1e-6 L=1e-6
mpway12_cell55 ML12 gate_way12_cell55 GND ML12 p1 W=2.4e-6 L=1e-6
mnway12_cell56 ML12 gate_way12_cell56 GND GND n1 W=1e-6 L=1e-6
mpway12_cell56 ML12 gate_way12_cell56 GND ML12 p1 W=2.4e-6 L=1e-6
mnway12_cell57 ML12 gate_way12_cell57 GND GND n1 W=1e-6 L=1e-6
mpway12_cell57 ML12 gate_way12_cell57 GND ML12 p1 W=2.4e-6 L=1e-6
mnway12_cell58 ML12 gate_way12_cell58 GND GND n1 W=1e-6 L=1e-6
mpway12_cell58 ML12 gate_way12_cell58 GND ML12 p1 W=2.4e-6 L=1e-6
mnway12_cell59 ML12 gate_way12_cell59 GND GND n1 W=1e-6 L=1e-6
mpway12_cell59 ML12 gate_way12_cell59 GND ML12 p1 W=2.4e-6 L=1e-6
mnway12_cell60 ML12 gate_way12_cell60 GND GND n1 W=1e-6 L=1e-6
mpway12_cell60 ML12 gate_way12_cell60 GND ML12 p1 W=2.4e-6 L=1e-6
mnway12_cell61 ML12 gate_way12_cell61 GND GND n1 W=1e-6 L=1e-6
mpway12_cell61 ML12 gate_way12_cell61 GND ML12 p1 W=2.4e-6 L=1e-6
mnway12_cell62 ML12 gate_way12_cell62 GND GND n1 W=1e-6 L=1e-6
mpway12_cell62 ML12 gate_way12_cell62 GND ML12 p1 W=2.4e-6 L=1e-6
mnway12_cell63 ML12 gate_way12_cell63 GND GND n1 W=1e-6 L=1e-6
mpway12_cell63 ML12 gate_way12_cell63 GND ML12 p1 W=2.4e-6 L=1e-6
mnway12_cell64 ML12 gate_way12_cell64 GND GND n1 W=1e-6 L=1e-6
mpway12_cell64 ML12 gate_way12_cell64 GND ML12 p1 W=2.4e-6 L=1e-6
mnway12_cell65 ML12 gate_way12_cell65 GND GND n1 W=1e-6 L=1e-6
mpway12_cell65 ML12 gate_way12_cell65 GND ML12 p1 W=2.4e-6 L=1e-6
mnway12_cell66 ML12 gate_way12_cell66 GND GND n1 W=1e-6 L=1e-6
mpway12_cell66 ML12 gate_way12_cell66 GND ML12 p1 W=2.4e-6 L=1e-6
mnway12_cell67 ML12 gate_way12_cell67 GND GND n1 W=1e-6 L=1e-6
mpway12_cell67 ML12 gate_way12_cell67 GND ML12 p1 W=2.4e-6 L=1e-6
mnway12_cell68 ML12 gate_way12_cell68 GND GND n1 W=1e-6 L=1e-6
mpway12_cell68 ML12 gate_way12_cell68 GND ML12 p1 W=2.4e-6 L=1e-6
mnway12_cell69 ML12 gate_way12_cell69 GND GND n1 W=1e-6 L=1e-6
mpway12_cell69 ML12 gate_way12_cell69 GND ML12 p1 W=2.4e-6 L=1e-6
mnway12_cell70 ML12 gate_way12_cell70 GND GND n1 W=1e-6 L=1e-6
mpway12_cell70 ML12 gate_way12_cell70 GND ML12 p1 W=2.4e-6 L=1e-6
mnway12_cell71 ML12 gate_way12_cell71 GND GND n1 W=1e-6 L=1e-6
mpway12_cell71 ML12 gate_way12_cell71 GND ML12 p1 W=2.4e-6 L=1e-6
mnway12_cell72 ML12 gate_way12_cell72 GND GND n1 W=1e-6 L=1e-6
mpway12_cell72 ML12 gate_way12_cell72 GND ML12 p1 W=2.4e-6 L=1e-6
mnway12_cell73 ML12 gate_way12_cell73 GND GND n1 W=1e-6 L=1e-6
mpway12_cell73 ML12 gate_way12_cell73 GND ML12 p1 W=2.4e-6 L=1e-6
mnway12_cell74 ML12 gate_way12_cell74 GND GND n1 W=1e-6 L=1e-6
mpway12_cell74 ML12 gate_way12_cell74 GND ML12 p1 W=2.4e-6 L=1e-6
mnway12_cell75 ML12 gate_way12_cell75 GND GND n1 W=1e-6 L=1e-6
mpway12_cell75 ML12 gate_way12_cell75 GND ML12 p1 W=2.4e-6 L=1e-6
mnway12_cell76 ML12 gate_way12_cell76 GND GND n1 W=1e-6 L=1e-6
mpway12_cell76 ML12 gate_way12_cell76 GND ML12 p1 W=2.4e-6 L=1e-6
mnway12_cell77 ML12 gate_way12_cell77 GND GND n1 W=1e-6 L=1e-6
mpway12_cell77 ML12 gate_way12_cell77 GND ML12 p1 W=2.4e-6 L=1e-6
mnway12_cell78 ML12 gate_way12_cell78 GND GND n1 W=1e-6 L=1e-6
mpway12_cell78 ML12 gate_way12_cell78 GND ML12 p1 W=2.4e-6 L=1e-6
mnway12_cell79 ML12 gate_way12_cell79 GND GND n1 W=1e-6 L=1e-6
mpway12_cell79 ML12 gate_way12_cell79 GND ML12 p1 W=2.4e-6 L=1e-6
mnway12_cell80 ML12 gate_way12_cell80 GND GND n1 W=1e-6 L=1e-6
mpway12_cell80 ML12 gate_way12_cell80 GND ML12 p1 W=2.4e-6 L=1e-6
mnway12_cell81 ML12 gate_way12_cell81 GND GND n1 W=1e-6 L=1e-6
mpway12_cell81 ML12 gate_way12_cell81 GND ML12 p1 W=2.4e-6 L=1e-6
mnway12_cell82 ML12 gate_way12_cell82 GND GND n1 W=1e-6 L=1e-6
mpway12_cell82 ML12 gate_way12_cell82 GND ML12 p1 W=2.4e-6 L=1e-6
mnway12_cell83 ML12 gate_way12_cell83 GND GND n1 W=1e-6 L=1e-6
mpway12_cell83 ML12 gate_way12_cell83 GND ML12 p1 W=2.4e-6 L=1e-6
mnway12_cell84 ML12 gate_way12_cell84 GND GND n1 W=1e-6 L=1e-6
mpway12_cell84 ML12 gate_way12_cell84 GND ML12 p1 W=2.4e-6 L=1e-6
mnway12_cell85 ML12 gate_way12_cell85 GND GND n1 W=1e-6 L=1e-6
mpway12_cell85 ML12 gate_way12_cell85 GND ML12 p1 W=2.4e-6 L=1e-6
mnway12_cell86 ML12 gate_way12_cell86 GND GND n1 W=1e-6 L=1e-6
mpway12_cell86 ML12 gate_way12_cell86 GND ML12 p1 W=2.4e-6 L=1e-6
mnway12_cell87 ML12 gate_way12_cell87 GND GND n1 W=1e-6 L=1e-6
mpway12_cell87 ML12 gate_way12_cell87 GND ML12 p1 W=2.4e-6 L=1e-6
mnway12_cell88 ML12 gate_way12_cell88 GND GND n1 W=1e-6 L=1e-6
mpway12_cell88 ML12 gate_way12_cell88 GND ML12 p1 W=2.4e-6 L=1e-6
mnway12_cell89 ML12 gate_way12_cell89 GND GND n1 W=1e-6 L=1e-6
mpway12_cell89 ML12 gate_way12_cell89 GND ML12 p1 W=2.4e-6 L=1e-6
mnway12_cell90 ML12 gate_way12_cell90 GND GND n1 W=1e-6 L=1e-6
mpway12_cell90 ML12 gate_way12_cell90 GND ML12 p1 W=2.4e-6 L=1e-6
mnway12_cell91 ML12 gate_way12_cell91 GND GND n1 W=1e-6 L=1e-6
mpway12_cell91 ML12 gate_way12_cell91 GND ML12 p1 W=2.4e-6 L=1e-6
mnway12_cell92 ML12 gate_way12_cell92 GND GND n1 W=1e-6 L=1e-6
mpway12_cell92 ML12 gate_way12_cell92 GND ML12 p1 W=2.4e-6 L=1e-6
mnway12_cell93 ML12 gate_way12_cell93 GND GND n1 W=1e-6 L=1e-6
mpway12_cell93 ML12 gate_way12_cell93 GND ML12 p1 W=2.4e-6 L=1e-6
mnway12_cell94 ML12 gate_way12_cell94 GND GND n1 W=1e-6 L=1e-6
mpway12_cell94 ML12 gate_way12_cell94 GND ML12 p1 W=2.4e-6 L=1e-6
mnway12_cell95 ML12 gate_way12_cell95 GND GND n1 W=1e-6 L=1e-6
mpway12_cell95 ML12 gate_way12_cell95 GND ML12 p1 W=2.4e-6 L=1e-6
mnway12_cell96 ML12 gate_way12_cell96 GND GND n1 W=1e-6 L=1e-6
mpway12_cell96 ML12 gate_way12_cell96 GND ML12 p1 W=2.4e-6 L=1e-6
mnway12_cell97 ML12 gate_way12_cell97 GND GND n1 W=1e-6 L=1e-6
mpway12_cell97 ML12 gate_way12_cell97 GND ML12 p1 W=2.4e-6 L=1e-6
mnway12_cell98 ML12 gate_way12_cell98 GND GND n1 W=1e-6 L=1e-6
mpway12_cell98 ML12 gate_way12_cell98 GND ML12 p1 W=2.4e-6 L=1e-6
mnway12_cell99 ML12 gate_way12_cell99 GND GND n1 W=1e-6 L=1e-6
mpway12_cell99 ML12 gate_way12_cell99 GND ML12 p1 W=2.4e-6 L=1e-6
mnway13_cell0 ML13 gate_way13_cell0 GND GND n1 W=1e-6 L=1e-6
mpway13_cell0 ML13 gate_way13_cell0 GND ML13 p1 W=2.4e-6 L=1e-6
mnway13_cell1 ML13 gate_way13_cell1 GND GND n1 W=1e-6 L=1e-6
mpway13_cell1 ML13 gate_way13_cell1 GND ML13 p1 W=2.4e-6 L=1e-6
mnway13_cell2 ML13 gate_way13_cell2 GND GND n1 W=1e-6 L=1e-6
mpway13_cell2 ML13 gate_way13_cell2 GND ML13 p1 W=2.4e-6 L=1e-6
mnway13_cell3 ML13 gate_way13_cell3 GND GND n1 W=1e-6 L=1e-6
mpway13_cell3 ML13 gate_way13_cell3 GND ML13 p1 W=2.4e-6 L=1e-6
mnway13_cell4 ML13 gate_way13_cell4 GND GND n1 W=1e-6 L=1e-6
mpway13_cell4 ML13 gate_way13_cell4 GND ML13 p1 W=2.4e-6 L=1e-6
mnway13_cell5 ML13 gate_way13_cell5 GND GND n1 W=1e-6 L=1e-6
mpway13_cell5 ML13 gate_way13_cell5 GND ML13 p1 W=2.4e-6 L=1e-6
mnway13_cell6 ML13 gate_way13_cell6 GND GND n1 W=1e-6 L=1e-6
mpway13_cell6 ML13 gate_way13_cell6 GND ML13 p1 W=2.4e-6 L=1e-6
mnway13_cell7 ML13 gate_way13_cell7 GND GND n1 W=1e-6 L=1e-6
mpway13_cell7 ML13 gate_way13_cell7 GND ML13 p1 W=2.4e-6 L=1e-6
mnway13_cell8 ML13 gate_way13_cell8 GND GND n1 W=1e-6 L=1e-6
mpway13_cell8 ML13 gate_way13_cell8 GND ML13 p1 W=2.4e-6 L=1e-6
mnway13_cell9 ML13 gate_way13_cell9 GND GND n1 W=1e-6 L=1e-6
mpway13_cell9 ML13 gate_way13_cell9 GND ML13 p1 W=2.4e-6 L=1e-6
mnway13_cell10 ML13 gate_way13_cell10 GND GND n1 W=1e-6 L=1e-6
mpway13_cell10 ML13 gate_way13_cell10 GND ML13 p1 W=2.4e-6 L=1e-6
mnway13_cell11 ML13 gate_way13_cell11 GND GND n1 W=1e-6 L=1e-6
mpway13_cell11 ML13 gate_way13_cell11 GND ML13 p1 W=2.4e-6 L=1e-6
mnway13_cell12 ML13 gate_way13_cell12 GND GND n1 W=1e-6 L=1e-6
mpway13_cell12 ML13 gate_way13_cell12 GND ML13 p1 W=2.4e-6 L=1e-6
mnway13_cell13 ML13 gate_way13_cell13 GND GND n1 W=1e-6 L=1e-6
mpway13_cell13 ML13 gate_way13_cell13 GND ML13 p1 W=2.4e-6 L=1e-6
mnway13_cell14 ML13 gate_way13_cell14 GND GND n1 W=1e-6 L=1e-6
mpway13_cell14 ML13 gate_way13_cell14 GND ML13 p1 W=2.4e-6 L=1e-6
mnway13_cell15 ML13 gate_way13_cell15 GND GND n1 W=1e-6 L=1e-6
mpway13_cell15 ML13 gate_way13_cell15 GND ML13 p1 W=2.4e-6 L=1e-6
mnway13_cell16 ML13 gate_way13_cell16 GND GND n1 W=1e-6 L=1e-6
mpway13_cell16 ML13 gate_way13_cell16 GND ML13 p1 W=2.4e-6 L=1e-6
mnway13_cell17 ML13 gate_way13_cell17 GND GND n1 W=1e-6 L=1e-6
mpway13_cell17 ML13 gate_way13_cell17 GND ML13 p1 W=2.4e-6 L=1e-6
mnway13_cell18 ML13 gate_way13_cell18 GND GND n1 W=1e-6 L=1e-6
mpway13_cell18 ML13 gate_way13_cell18 GND ML13 p1 W=2.4e-6 L=1e-6
mnway13_cell19 ML13 gate_way13_cell19 GND GND n1 W=1e-6 L=1e-6
mpway13_cell19 ML13 gate_way13_cell19 GND ML13 p1 W=2.4e-6 L=1e-6
mnway13_cell20 ML13 gate_way13_cell20 GND GND n1 W=1e-6 L=1e-6
mpway13_cell20 ML13 gate_way13_cell20 GND ML13 p1 W=2.4e-6 L=1e-6
mnway13_cell21 ML13 gate_way13_cell21 GND GND n1 W=1e-6 L=1e-6
mpway13_cell21 ML13 gate_way13_cell21 GND ML13 p1 W=2.4e-6 L=1e-6
mnway13_cell22 ML13 gate_way13_cell22 GND GND n1 W=1e-6 L=1e-6
mpway13_cell22 ML13 gate_way13_cell22 GND ML13 p1 W=2.4e-6 L=1e-6
mnway13_cell23 ML13 gate_way13_cell23 GND GND n1 W=1e-6 L=1e-6
mpway13_cell23 ML13 gate_way13_cell23 GND ML13 p1 W=2.4e-6 L=1e-6
mnway13_cell24 ML13 gate_way13_cell24 GND GND n1 W=1e-6 L=1e-6
mpway13_cell24 ML13 gate_way13_cell24 GND ML13 p1 W=2.4e-6 L=1e-6
mnway13_cell25 ML13 gate_way13_cell25 GND GND n1 W=1e-6 L=1e-6
mpway13_cell25 ML13 gate_way13_cell25 GND ML13 p1 W=2.4e-6 L=1e-6
mnway13_cell26 ML13 gate_way13_cell26 GND GND n1 W=1e-6 L=1e-6
mpway13_cell26 ML13 gate_way13_cell26 GND ML13 p1 W=2.4e-6 L=1e-6
mnway13_cell27 ML13 gate_way13_cell27 GND GND n1 W=1e-6 L=1e-6
mpway13_cell27 ML13 gate_way13_cell27 GND ML13 p1 W=2.4e-6 L=1e-6
mnway13_cell28 ML13 gate_way13_cell28 GND GND n1 W=1e-6 L=1e-6
mpway13_cell28 ML13 gate_way13_cell28 GND ML13 p1 W=2.4e-6 L=1e-6
mnway13_cell29 ML13 gate_way13_cell29 GND GND n1 W=1e-6 L=1e-6
mpway13_cell29 ML13 gate_way13_cell29 GND ML13 p1 W=2.4e-6 L=1e-6
mnway13_cell30 ML13 gate_way13_cell30 GND GND n1 W=1e-6 L=1e-6
mpway13_cell30 ML13 gate_way13_cell30 GND ML13 p1 W=2.4e-6 L=1e-6
mnway13_cell31 ML13 gate_way13_cell31 GND GND n1 W=1e-6 L=1e-6
mpway13_cell31 ML13 gate_way13_cell31 GND ML13 p1 W=2.4e-6 L=1e-6
mnway13_cell32 ML13 gate_way13_cell32 GND GND n1 W=1e-6 L=1e-6
mpway13_cell32 ML13 gate_way13_cell32 GND ML13 p1 W=2.4e-6 L=1e-6
mnway13_cell33 ML13 gate_way13_cell33 GND GND n1 W=1e-6 L=1e-6
mpway13_cell33 ML13 gate_way13_cell33 GND ML13 p1 W=2.4e-6 L=1e-6
mnway13_cell34 ML13 gate_way13_cell34 GND GND n1 W=1e-6 L=1e-6
mpway13_cell34 ML13 gate_way13_cell34 GND ML13 p1 W=2.4e-6 L=1e-6
mnway13_cell35 ML13 gate_way13_cell35 GND GND n1 W=1e-6 L=1e-6
mpway13_cell35 ML13 gate_way13_cell35 GND ML13 p1 W=2.4e-6 L=1e-6
mnway13_cell36 ML13 gate_way13_cell36 GND GND n1 W=1e-6 L=1e-6
mpway13_cell36 ML13 gate_way13_cell36 GND ML13 p1 W=2.4e-6 L=1e-6
mnway13_cell37 ML13 gate_way13_cell37 GND GND n1 W=1e-6 L=1e-6
mpway13_cell37 ML13 gate_way13_cell37 GND ML13 p1 W=2.4e-6 L=1e-6
mnway13_cell38 ML13 gate_way13_cell38 GND GND n1 W=1e-6 L=1e-6
mpway13_cell38 ML13 gate_way13_cell38 GND ML13 p1 W=2.4e-6 L=1e-6
mnway13_cell39 ML13 gate_way13_cell39 GND GND n1 W=1e-6 L=1e-6
mpway13_cell39 ML13 gate_way13_cell39 GND ML13 p1 W=2.4e-6 L=1e-6
mnway13_cell40 ML13 gate_way13_cell40 GND GND n1 W=1e-6 L=1e-6
mpway13_cell40 ML13 gate_way13_cell40 GND ML13 p1 W=2.4e-6 L=1e-6
mnway13_cell41 ML13 gate_way13_cell41 GND GND n1 W=1e-6 L=1e-6
mpway13_cell41 ML13 gate_way13_cell41 GND ML13 p1 W=2.4e-6 L=1e-6
mnway13_cell42 ML13 gate_way13_cell42 GND GND n1 W=1e-6 L=1e-6
mpway13_cell42 ML13 gate_way13_cell42 GND ML13 p1 W=2.4e-6 L=1e-6
mnway13_cell43 ML13 gate_way13_cell43 GND GND n1 W=1e-6 L=1e-6
mpway13_cell43 ML13 gate_way13_cell43 GND ML13 p1 W=2.4e-6 L=1e-6
mnway13_cell44 ML13 gate_way13_cell44 GND GND n1 W=1e-6 L=1e-6
mpway13_cell44 ML13 gate_way13_cell44 GND ML13 p1 W=2.4e-6 L=1e-6
mnway13_cell45 ML13 gate_way13_cell45 GND GND n1 W=1e-6 L=1e-6
mpway13_cell45 ML13 gate_way13_cell45 GND ML13 p1 W=2.4e-6 L=1e-6
mnway13_cell46 ML13 gate_way13_cell46 GND GND n1 W=1e-6 L=1e-6
mpway13_cell46 ML13 gate_way13_cell46 GND ML13 p1 W=2.4e-6 L=1e-6
mnway13_cell47 ML13 gate_way13_cell47 GND GND n1 W=1e-6 L=1e-6
mpway13_cell47 ML13 gate_way13_cell47 GND ML13 p1 W=2.4e-6 L=1e-6
mnway13_cell48 ML13 gate_way13_cell48 GND GND n1 W=1e-6 L=1e-6
mpway13_cell48 ML13 gate_way13_cell48 GND ML13 p1 W=2.4e-6 L=1e-6
mnway13_cell49 ML13 gate_way13_cell49 GND GND n1 W=1e-6 L=1e-6
mpway13_cell49 ML13 gate_way13_cell49 GND ML13 p1 W=2.4e-6 L=1e-6
mnway13_cell50 ML13 gate_way13_cell50 GND GND n1 W=1e-6 L=1e-6
mpway13_cell50 ML13 gate_way13_cell50 GND ML13 p1 W=2.4e-6 L=1e-6
mnway13_cell51 ML13 gate_way13_cell51 GND GND n1 W=1e-6 L=1e-6
mpway13_cell51 ML13 gate_way13_cell51 GND ML13 p1 W=2.4e-6 L=1e-6
mnway13_cell52 ML13 gate_way13_cell52 GND GND n1 W=1e-6 L=1e-6
mpway13_cell52 ML13 gate_way13_cell52 GND ML13 p1 W=2.4e-6 L=1e-6
mnway13_cell53 ML13 gate_way13_cell53 GND GND n1 W=1e-6 L=1e-6
mpway13_cell53 ML13 gate_way13_cell53 GND ML13 p1 W=2.4e-6 L=1e-6
mnway13_cell54 ML13 gate_way13_cell54 GND GND n1 W=1e-6 L=1e-6
mpway13_cell54 ML13 gate_way13_cell54 GND ML13 p1 W=2.4e-6 L=1e-6
mnway13_cell55 ML13 gate_way13_cell55 GND GND n1 W=1e-6 L=1e-6
mpway13_cell55 ML13 gate_way13_cell55 GND ML13 p1 W=2.4e-6 L=1e-6
mnway13_cell56 ML13 gate_way13_cell56 GND GND n1 W=1e-6 L=1e-6
mpway13_cell56 ML13 gate_way13_cell56 GND ML13 p1 W=2.4e-6 L=1e-6
mnway13_cell57 ML13 gate_way13_cell57 GND GND n1 W=1e-6 L=1e-6
mpway13_cell57 ML13 gate_way13_cell57 GND ML13 p1 W=2.4e-6 L=1e-6
mnway13_cell58 ML13 gate_way13_cell58 GND GND n1 W=1e-6 L=1e-6
mpway13_cell58 ML13 gate_way13_cell58 GND ML13 p1 W=2.4e-6 L=1e-6
mnway13_cell59 ML13 gate_way13_cell59 GND GND n1 W=1e-6 L=1e-6
mpway13_cell59 ML13 gate_way13_cell59 GND ML13 p1 W=2.4e-6 L=1e-6
mnway13_cell60 ML13 gate_way13_cell60 GND GND n1 W=1e-6 L=1e-6
mpway13_cell60 ML13 gate_way13_cell60 GND ML13 p1 W=2.4e-6 L=1e-6
mnway13_cell61 ML13 gate_way13_cell61 GND GND n1 W=1e-6 L=1e-6
mpway13_cell61 ML13 gate_way13_cell61 GND ML13 p1 W=2.4e-6 L=1e-6
mnway13_cell62 ML13 gate_way13_cell62 GND GND n1 W=1e-6 L=1e-6
mpway13_cell62 ML13 gate_way13_cell62 GND ML13 p1 W=2.4e-6 L=1e-6
mnway13_cell63 ML13 gate_way13_cell63 GND GND n1 W=1e-6 L=1e-6
mpway13_cell63 ML13 gate_way13_cell63 GND ML13 p1 W=2.4e-6 L=1e-6
mnway13_cell64 ML13 gate_way13_cell64 GND GND n1 W=1e-6 L=1e-6
mpway13_cell64 ML13 gate_way13_cell64 GND ML13 p1 W=2.4e-6 L=1e-6
mnway13_cell65 ML13 gate_way13_cell65 GND GND n1 W=1e-6 L=1e-6
mpway13_cell65 ML13 gate_way13_cell65 GND ML13 p1 W=2.4e-6 L=1e-6
mnway13_cell66 ML13 gate_way13_cell66 GND GND n1 W=1e-6 L=1e-6
mpway13_cell66 ML13 gate_way13_cell66 GND ML13 p1 W=2.4e-6 L=1e-6
mnway13_cell67 ML13 gate_way13_cell67 GND GND n1 W=1e-6 L=1e-6
mpway13_cell67 ML13 gate_way13_cell67 GND ML13 p1 W=2.4e-6 L=1e-6
mnway13_cell68 ML13 gate_way13_cell68 GND GND n1 W=1e-6 L=1e-6
mpway13_cell68 ML13 gate_way13_cell68 GND ML13 p1 W=2.4e-6 L=1e-6
mnway13_cell69 ML13 gate_way13_cell69 GND GND n1 W=1e-6 L=1e-6
mpway13_cell69 ML13 gate_way13_cell69 GND ML13 p1 W=2.4e-6 L=1e-6
mnway13_cell70 ML13 gate_way13_cell70 GND GND n1 W=1e-6 L=1e-6
mpway13_cell70 ML13 gate_way13_cell70 GND ML13 p1 W=2.4e-6 L=1e-6
mnway13_cell71 ML13 gate_way13_cell71 GND GND n1 W=1e-6 L=1e-6
mpway13_cell71 ML13 gate_way13_cell71 GND ML13 p1 W=2.4e-6 L=1e-6
mnway13_cell72 ML13 gate_way13_cell72 GND GND n1 W=1e-6 L=1e-6
mpway13_cell72 ML13 gate_way13_cell72 GND ML13 p1 W=2.4e-6 L=1e-6
mnway13_cell73 ML13 gate_way13_cell73 GND GND n1 W=1e-6 L=1e-6
mpway13_cell73 ML13 gate_way13_cell73 GND ML13 p1 W=2.4e-6 L=1e-6
mnway13_cell74 ML13 gate_way13_cell74 GND GND n1 W=1e-6 L=1e-6
mpway13_cell74 ML13 gate_way13_cell74 GND ML13 p1 W=2.4e-6 L=1e-6
mnway13_cell75 ML13 gate_way13_cell75 GND GND n1 W=1e-6 L=1e-6
mpway13_cell75 ML13 gate_way13_cell75 GND ML13 p1 W=2.4e-6 L=1e-6
mnway13_cell76 ML13 gate_way13_cell76 GND GND n1 W=1e-6 L=1e-6
mpway13_cell76 ML13 gate_way13_cell76 GND ML13 p1 W=2.4e-6 L=1e-6
mnway13_cell77 ML13 gate_way13_cell77 GND GND n1 W=1e-6 L=1e-6
mpway13_cell77 ML13 gate_way13_cell77 GND ML13 p1 W=2.4e-6 L=1e-6
mnway13_cell78 ML13 gate_way13_cell78 GND GND n1 W=1e-6 L=1e-6
mpway13_cell78 ML13 gate_way13_cell78 GND ML13 p1 W=2.4e-6 L=1e-6
mnway13_cell79 ML13 gate_way13_cell79 GND GND n1 W=1e-6 L=1e-6
mpway13_cell79 ML13 gate_way13_cell79 GND ML13 p1 W=2.4e-6 L=1e-6
mnway13_cell80 ML13 gate_way13_cell80 GND GND n1 W=1e-6 L=1e-6
mpway13_cell80 ML13 gate_way13_cell80 GND ML13 p1 W=2.4e-6 L=1e-6
mnway13_cell81 ML13 gate_way13_cell81 GND GND n1 W=1e-6 L=1e-6
mpway13_cell81 ML13 gate_way13_cell81 GND ML13 p1 W=2.4e-6 L=1e-6
mnway13_cell82 ML13 gate_way13_cell82 GND GND n1 W=1e-6 L=1e-6
mpway13_cell82 ML13 gate_way13_cell82 GND ML13 p1 W=2.4e-6 L=1e-6
mnway13_cell83 ML13 gate_way13_cell83 GND GND n1 W=1e-6 L=1e-6
mpway13_cell83 ML13 gate_way13_cell83 GND ML13 p1 W=2.4e-6 L=1e-6
mnway13_cell84 ML13 gate_way13_cell84 GND GND n1 W=1e-6 L=1e-6
mpway13_cell84 ML13 gate_way13_cell84 GND ML13 p1 W=2.4e-6 L=1e-6
mnway13_cell85 ML13 gate_way13_cell85 GND GND n1 W=1e-6 L=1e-6
mpway13_cell85 ML13 gate_way13_cell85 GND ML13 p1 W=2.4e-6 L=1e-6
mnway13_cell86 ML13 gate_way13_cell86 GND GND n1 W=1e-6 L=1e-6
mpway13_cell86 ML13 gate_way13_cell86 GND ML13 p1 W=2.4e-6 L=1e-6
mnway13_cell87 ML13 gate_way13_cell87 GND GND n1 W=1e-6 L=1e-6
mpway13_cell87 ML13 gate_way13_cell87 GND ML13 p1 W=2.4e-6 L=1e-6
mnway13_cell88 ML13 gate_way13_cell88 GND GND n1 W=1e-6 L=1e-6
mpway13_cell88 ML13 gate_way13_cell88 GND ML13 p1 W=2.4e-6 L=1e-6
mnway13_cell89 ML13 gate_way13_cell89 GND GND n1 W=1e-6 L=1e-6
mpway13_cell89 ML13 gate_way13_cell89 GND ML13 p1 W=2.4e-6 L=1e-6
mnway13_cell90 ML13 gate_way13_cell90 GND GND n1 W=1e-6 L=1e-6
mpway13_cell90 ML13 gate_way13_cell90 GND ML13 p1 W=2.4e-6 L=1e-6
mnway13_cell91 ML13 gate_way13_cell91 GND GND n1 W=1e-6 L=1e-6
mpway13_cell91 ML13 gate_way13_cell91 GND ML13 p1 W=2.4e-6 L=1e-6
mnway13_cell92 ML13 gate_way13_cell92 GND GND n1 W=1e-6 L=1e-6
mpway13_cell92 ML13 gate_way13_cell92 GND ML13 p1 W=2.4e-6 L=1e-6
mnway13_cell93 ML13 gate_way13_cell93 GND GND n1 W=1e-6 L=1e-6
mpway13_cell93 ML13 gate_way13_cell93 GND ML13 p1 W=2.4e-6 L=1e-6
mnway13_cell94 ML13 gate_way13_cell94 GND GND n1 W=1e-6 L=1e-6
mpway13_cell94 ML13 gate_way13_cell94 GND ML13 p1 W=2.4e-6 L=1e-6
mnway13_cell95 ML13 gate_way13_cell95 GND GND n1 W=1e-6 L=1e-6
mpway13_cell95 ML13 gate_way13_cell95 GND ML13 p1 W=2.4e-6 L=1e-6
mnway13_cell96 ML13 gate_way13_cell96 GND GND n1 W=1e-6 L=1e-6
mpway13_cell96 ML13 gate_way13_cell96 GND ML13 p1 W=2.4e-6 L=1e-6
mnway13_cell97 ML13 gate_way13_cell97 GND GND n1 W=1e-6 L=1e-6
mpway13_cell97 ML13 gate_way13_cell97 GND ML13 p1 W=2.4e-6 L=1e-6
mnway13_cell98 ML13 gate_way13_cell98 GND GND n1 W=1e-6 L=1e-6
mpway13_cell98 ML13 gate_way13_cell98 GND ML13 p1 W=2.4e-6 L=1e-6
mnway13_cell99 ML13 gate_way13_cell99 GND GND n1 W=1e-6 L=1e-6
mpway13_cell99 ML13 gate_way13_cell99 GND ML13 p1 W=2.4e-6 L=1e-6
mnway14_cell0 ML14 gate_way14_cell0 GND GND n1 W=1e-6 L=1e-6
mpway14_cell0 ML14 gate_way14_cell0 GND ML14 p1 W=2.4e-6 L=1e-6
mnway14_cell1 ML14 gate_way14_cell1 GND GND n1 W=1e-6 L=1e-6
mpway14_cell1 ML14 gate_way14_cell1 GND ML14 p1 W=2.4e-6 L=1e-6
mnway14_cell2 ML14 gate_way14_cell2 GND GND n1 W=1e-6 L=1e-6
mpway14_cell2 ML14 gate_way14_cell2 GND ML14 p1 W=2.4e-6 L=1e-6
mnway14_cell3 ML14 gate_way14_cell3 GND GND n1 W=1e-6 L=1e-6
mpway14_cell3 ML14 gate_way14_cell3 GND ML14 p1 W=2.4e-6 L=1e-6
mnway14_cell4 ML14 gate_way14_cell4 GND GND n1 W=1e-6 L=1e-6
mpway14_cell4 ML14 gate_way14_cell4 GND ML14 p1 W=2.4e-6 L=1e-6
mnway14_cell5 ML14 gate_way14_cell5 GND GND n1 W=1e-6 L=1e-6
mpway14_cell5 ML14 gate_way14_cell5 GND ML14 p1 W=2.4e-6 L=1e-6
mnway14_cell6 ML14 gate_way14_cell6 GND GND n1 W=1e-6 L=1e-6
mpway14_cell6 ML14 gate_way14_cell6 GND ML14 p1 W=2.4e-6 L=1e-6
mnway14_cell7 ML14 gate_way14_cell7 GND GND n1 W=1e-6 L=1e-6
mpway14_cell7 ML14 gate_way14_cell7 GND ML14 p1 W=2.4e-6 L=1e-6
mnway14_cell8 ML14 gate_way14_cell8 GND GND n1 W=1e-6 L=1e-6
mpway14_cell8 ML14 gate_way14_cell8 GND ML14 p1 W=2.4e-6 L=1e-6
mnway14_cell9 ML14 gate_way14_cell9 GND GND n1 W=1e-6 L=1e-6
mpway14_cell9 ML14 gate_way14_cell9 GND ML14 p1 W=2.4e-6 L=1e-6
mnway14_cell10 ML14 gate_way14_cell10 GND GND n1 W=1e-6 L=1e-6
mpway14_cell10 ML14 gate_way14_cell10 GND ML14 p1 W=2.4e-6 L=1e-6
mnway14_cell11 ML14 gate_way14_cell11 GND GND n1 W=1e-6 L=1e-6
mpway14_cell11 ML14 gate_way14_cell11 GND ML14 p1 W=2.4e-6 L=1e-6
mnway14_cell12 ML14 gate_way14_cell12 GND GND n1 W=1e-6 L=1e-6
mpway14_cell12 ML14 gate_way14_cell12 GND ML14 p1 W=2.4e-6 L=1e-6
mnway14_cell13 ML14 gate_way14_cell13 GND GND n1 W=1e-6 L=1e-6
mpway14_cell13 ML14 gate_way14_cell13 GND ML14 p1 W=2.4e-6 L=1e-6
mnway14_cell14 ML14 gate_way14_cell14 GND GND n1 W=1e-6 L=1e-6
mpway14_cell14 ML14 gate_way14_cell14 GND ML14 p1 W=2.4e-6 L=1e-6
mnway14_cell15 ML14 gate_way14_cell15 GND GND n1 W=1e-6 L=1e-6
mpway14_cell15 ML14 gate_way14_cell15 GND ML14 p1 W=2.4e-6 L=1e-6
mnway14_cell16 ML14 gate_way14_cell16 GND GND n1 W=1e-6 L=1e-6
mpway14_cell16 ML14 gate_way14_cell16 GND ML14 p1 W=2.4e-6 L=1e-6
mnway14_cell17 ML14 gate_way14_cell17 GND GND n1 W=1e-6 L=1e-6
mpway14_cell17 ML14 gate_way14_cell17 GND ML14 p1 W=2.4e-6 L=1e-6
mnway14_cell18 ML14 gate_way14_cell18 GND GND n1 W=1e-6 L=1e-6
mpway14_cell18 ML14 gate_way14_cell18 GND ML14 p1 W=2.4e-6 L=1e-6
mnway14_cell19 ML14 gate_way14_cell19 GND GND n1 W=1e-6 L=1e-6
mpway14_cell19 ML14 gate_way14_cell19 GND ML14 p1 W=2.4e-6 L=1e-6
mnway14_cell20 ML14 gate_way14_cell20 GND GND n1 W=1e-6 L=1e-6
mpway14_cell20 ML14 gate_way14_cell20 GND ML14 p1 W=2.4e-6 L=1e-6
mnway14_cell21 ML14 gate_way14_cell21 GND GND n1 W=1e-6 L=1e-6
mpway14_cell21 ML14 gate_way14_cell21 GND ML14 p1 W=2.4e-6 L=1e-6
mnway14_cell22 ML14 gate_way14_cell22 GND GND n1 W=1e-6 L=1e-6
mpway14_cell22 ML14 gate_way14_cell22 GND ML14 p1 W=2.4e-6 L=1e-6
mnway14_cell23 ML14 gate_way14_cell23 GND GND n1 W=1e-6 L=1e-6
mpway14_cell23 ML14 gate_way14_cell23 GND ML14 p1 W=2.4e-6 L=1e-6
mnway14_cell24 ML14 gate_way14_cell24 GND GND n1 W=1e-6 L=1e-6
mpway14_cell24 ML14 gate_way14_cell24 GND ML14 p1 W=2.4e-6 L=1e-6
mnway14_cell25 ML14 gate_way14_cell25 GND GND n1 W=1e-6 L=1e-6
mpway14_cell25 ML14 gate_way14_cell25 GND ML14 p1 W=2.4e-6 L=1e-6
mnway14_cell26 ML14 gate_way14_cell26 GND GND n1 W=1e-6 L=1e-6
mpway14_cell26 ML14 gate_way14_cell26 GND ML14 p1 W=2.4e-6 L=1e-6
mnway14_cell27 ML14 gate_way14_cell27 GND GND n1 W=1e-6 L=1e-6
mpway14_cell27 ML14 gate_way14_cell27 GND ML14 p1 W=2.4e-6 L=1e-6
mnway14_cell28 ML14 gate_way14_cell28 GND GND n1 W=1e-6 L=1e-6
mpway14_cell28 ML14 gate_way14_cell28 GND ML14 p1 W=2.4e-6 L=1e-6
mnway14_cell29 ML14 gate_way14_cell29 GND GND n1 W=1e-6 L=1e-6
mpway14_cell29 ML14 gate_way14_cell29 GND ML14 p1 W=2.4e-6 L=1e-6
mnway14_cell30 ML14 gate_way14_cell30 GND GND n1 W=1e-6 L=1e-6
mpway14_cell30 ML14 gate_way14_cell30 GND ML14 p1 W=2.4e-6 L=1e-6
mnway14_cell31 ML14 gate_way14_cell31 GND GND n1 W=1e-6 L=1e-6
mpway14_cell31 ML14 gate_way14_cell31 GND ML14 p1 W=2.4e-6 L=1e-6
mnway14_cell32 ML14 gate_way14_cell32 GND GND n1 W=1e-6 L=1e-6
mpway14_cell32 ML14 gate_way14_cell32 GND ML14 p1 W=2.4e-6 L=1e-6
mnway14_cell33 ML14 gate_way14_cell33 GND GND n1 W=1e-6 L=1e-6
mpway14_cell33 ML14 gate_way14_cell33 GND ML14 p1 W=2.4e-6 L=1e-6
mnway14_cell34 ML14 gate_way14_cell34 GND GND n1 W=1e-6 L=1e-6
mpway14_cell34 ML14 gate_way14_cell34 GND ML14 p1 W=2.4e-6 L=1e-6
mnway14_cell35 ML14 gate_way14_cell35 GND GND n1 W=1e-6 L=1e-6
mpway14_cell35 ML14 gate_way14_cell35 GND ML14 p1 W=2.4e-6 L=1e-6
mnway14_cell36 ML14 gate_way14_cell36 GND GND n1 W=1e-6 L=1e-6
mpway14_cell36 ML14 gate_way14_cell36 GND ML14 p1 W=2.4e-6 L=1e-6
mnway14_cell37 ML14 gate_way14_cell37 GND GND n1 W=1e-6 L=1e-6
mpway14_cell37 ML14 gate_way14_cell37 GND ML14 p1 W=2.4e-6 L=1e-6
mnway14_cell38 ML14 gate_way14_cell38 GND GND n1 W=1e-6 L=1e-6
mpway14_cell38 ML14 gate_way14_cell38 GND ML14 p1 W=2.4e-6 L=1e-6
mnway14_cell39 ML14 gate_way14_cell39 GND GND n1 W=1e-6 L=1e-6
mpway14_cell39 ML14 gate_way14_cell39 GND ML14 p1 W=2.4e-6 L=1e-6
mnway14_cell40 ML14 gate_way14_cell40 GND GND n1 W=1e-6 L=1e-6
mpway14_cell40 ML14 gate_way14_cell40 GND ML14 p1 W=2.4e-6 L=1e-6
mnway14_cell41 ML14 gate_way14_cell41 GND GND n1 W=1e-6 L=1e-6
mpway14_cell41 ML14 gate_way14_cell41 GND ML14 p1 W=2.4e-6 L=1e-6
mnway14_cell42 ML14 gate_way14_cell42 GND GND n1 W=1e-6 L=1e-6
mpway14_cell42 ML14 gate_way14_cell42 GND ML14 p1 W=2.4e-6 L=1e-6
mnway14_cell43 ML14 gate_way14_cell43 GND GND n1 W=1e-6 L=1e-6
mpway14_cell43 ML14 gate_way14_cell43 GND ML14 p1 W=2.4e-6 L=1e-6
mnway14_cell44 ML14 gate_way14_cell44 GND GND n1 W=1e-6 L=1e-6
mpway14_cell44 ML14 gate_way14_cell44 GND ML14 p1 W=2.4e-6 L=1e-6
mnway14_cell45 ML14 gate_way14_cell45 GND GND n1 W=1e-6 L=1e-6
mpway14_cell45 ML14 gate_way14_cell45 GND ML14 p1 W=2.4e-6 L=1e-6
mnway14_cell46 ML14 gate_way14_cell46 GND GND n1 W=1e-6 L=1e-6
mpway14_cell46 ML14 gate_way14_cell46 GND ML14 p1 W=2.4e-6 L=1e-6
mnway14_cell47 ML14 gate_way14_cell47 GND GND n1 W=1e-6 L=1e-6
mpway14_cell47 ML14 gate_way14_cell47 GND ML14 p1 W=2.4e-6 L=1e-6
mnway14_cell48 ML14 gate_way14_cell48 GND GND n1 W=1e-6 L=1e-6
mpway14_cell48 ML14 gate_way14_cell48 GND ML14 p1 W=2.4e-6 L=1e-6
mnway14_cell49 ML14 gate_way14_cell49 GND GND n1 W=1e-6 L=1e-6
mpway14_cell49 ML14 gate_way14_cell49 GND ML14 p1 W=2.4e-6 L=1e-6
mnway14_cell50 ML14 gate_way14_cell50 GND GND n1 W=1e-6 L=1e-6
mpway14_cell50 ML14 gate_way14_cell50 GND ML14 p1 W=2.4e-6 L=1e-6
mnway14_cell51 ML14 gate_way14_cell51 GND GND n1 W=1e-6 L=1e-6
mpway14_cell51 ML14 gate_way14_cell51 GND ML14 p1 W=2.4e-6 L=1e-6
mnway14_cell52 ML14 gate_way14_cell52 GND GND n1 W=1e-6 L=1e-6
mpway14_cell52 ML14 gate_way14_cell52 GND ML14 p1 W=2.4e-6 L=1e-6
mnway14_cell53 ML14 gate_way14_cell53 GND GND n1 W=1e-6 L=1e-6
mpway14_cell53 ML14 gate_way14_cell53 GND ML14 p1 W=2.4e-6 L=1e-6
mnway14_cell54 ML14 gate_way14_cell54 GND GND n1 W=1e-6 L=1e-6
mpway14_cell54 ML14 gate_way14_cell54 GND ML14 p1 W=2.4e-6 L=1e-6
mnway14_cell55 ML14 gate_way14_cell55 GND GND n1 W=1e-6 L=1e-6
mpway14_cell55 ML14 gate_way14_cell55 GND ML14 p1 W=2.4e-6 L=1e-6
mnway14_cell56 ML14 gate_way14_cell56 GND GND n1 W=1e-6 L=1e-6
mpway14_cell56 ML14 gate_way14_cell56 GND ML14 p1 W=2.4e-6 L=1e-6
mnway14_cell57 ML14 gate_way14_cell57 GND GND n1 W=1e-6 L=1e-6
mpway14_cell57 ML14 gate_way14_cell57 GND ML14 p1 W=2.4e-6 L=1e-6
mnway14_cell58 ML14 gate_way14_cell58 GND GND n1 W=1e-6 L=1e-6
mpway14_cell58 ML14 gate_way14_cell58 GND ML14 p1 W=2.4e-6 L=1e-6
mnway14_cell59 ML14 gate_way14_cell59 GND GND n1 W=1e-6 L=1e-6
mpway14_cell59 ML14 gate_way14_cell59 GND ML14 p1 W=2.4e-6 L=1e-6
mnway14_cell60 ML14 gate_way14_cell60 GND GND n1 W=1e-6 L=1e-6
mpway14_cell60 ML14 gate_way14_cell60 GND ML14 p1 W=2.4e-6 L=1e-6
mnway14_cell61 ML14 gate_way14_cell61 GND GND n1 W=1e-6 L=1e-6
mpway14_cell61 ML14 gate_way14_cell61 GND ML14 p1 W=2.4e-6 L=1e-6
mnway14_cell62 ML14 gate_way14_cell62 GND GND n1 W=1e-6 L=1e-6
mpway14_cell62 ML14 gate_way14_cell62 GND ML14 p1 W=2.4e-6 L=1e-6
mnway14_cell63 ML14 gate_way14_cell63 GND GND n1 W=1e-6 L=1e-6
mpway14_cell63 ML14 gate_way14_cell63 GND ML14 p1 W=2.4e-6 L=1e-6
mnway14_cell64 ML14 gate_way14_cell64 GND GND n1 W=1e-6 L=1e-6
mpway14_cell64 ML14 gate_way14_cell64 GND ML14 p1 W=2.4e-6 L=1e-6
mnway14_cell65 ML14 gate_way14_cell65 GND GND n1 W=1e-6 L=1e-6
mpway14_cell65 ML14 gate_way14_cell65 GND ML14 p1 W=2.4e-6 L=1e-6
mnway14_cell66 ML14 gate_way14_cell66 GND GND n1 W=1e-6 L=1e-6
mpway14_cell66 ML14 gate_way14_cell66 GND ML14 p1 W=2.4e-6 L=1e-6
mnway14_cell67 ML14 gate_way14_cell67 GND GND n1 W=1e-6 L=1e-6
mpway14_cell67 ML14 gate_way14_cell67 GND ML14 p1 W=2.4e-6 L=1e-6
mnway14_cell68 ML14 gate_way14_cell68 GND GND n1 W=1e-6 L=1e-6
mpway14_cell68 ML14 gate_way14_cell68 GND ML14 p1 W=2.4e-6 L=1e-6
mnway14_cell69 ML14 gate_way14_cell69 GND GND n1 W=1e-6 L=1e-6
mpway14_cell69 ML14 gate_way14_cell69 GND ML14 p1 W=2.4e-6 L=1e-6
mnway14_cell70 ML14 gate_way14_cell70 GND GND n1 W=1e-6 L=1e-6
mpway14_cell70 ML14 gate_way14_cell70 GND ML14 p1 W=2.4e-6 L=1e-6
mnway14_cell71 ML14 gate_way14_cell71 GND GND n1 W=1e-6 L=1e-6
mpway14_cell71 ML14 gate_way14_cell71 GND ML14 p1 W=2.4e-6 L=1e-6
mnway14_cell72 ML14 gate_way14_cell72 GND GND n1 W=1e-6 L=1e-6
mpway14_cell72 ML14 gate_way14_cell72 GND ML14 p1 W=2.4e-6 L=1e-6
mnway14_cell73 ML14 gate_way14_cell73 GND GND n1 W=1e-6 L=1e-6
mpway14_cell73 ML14 gate_way14_cell73 GND ML14 p1 W=2.4e-6 L=1e-6
mnway14_cell74 ML14 gate_way14_cell74 GND GND n1 W=1e-6 L=1e-6
mpway14_cell74 ML14 gate_way14_cell74 GND ML14 p1 W=2.4e-6 L=1e-6
mnway14_cell75 ML14 gate_way14_cell75 GND GND n1 W=1e-6 L=1e-6
mpway14_cell75 ML14 gate_way14_cell75 GND ML14 p1 W=2.4e-6 L=1e-6
mnway14_cell76 ML14 gate_way14_cell76 GND GND n1 W=1e-6 L=1e-6
mpway14_cell76 ML14 gate_way14_cell76 GND ML14 p1 W=2.4e-6 L=1e-6
mnway14_cell77 ML14 gate_way14_cell77 GND GND n1 W=1e-6 L=1e-6
mpway14_cell77 ML14 gate_way14_cell77 GND ML14 p1 W=2.4e-6 L=1e-6
mnway14_cell78 ML14 gate_way14_cell78 GND GND n1 W=1e-6 L=1e-6
mpway14_cell78 ML14 gate_way14_cell78 GND ML14 p1 W=2.4e-6 L=1e-6
mnway14_cell79 ML14 gate_way14_cell79 GND GND n1 W=1e-6 L=1e-6
mpway14_cell79 ML14 gate_way14_cell79 GND ML14 p1 W=2.4e-6 L=1e-6
mnway14_cell80 ML14 gate_way14_cell80 GND GND n1 W=1e-6 L=1e-6
mpway14_cell80 ML14 gate_way14_cell80 GND ML14 p1 W=2.4e-6 L=1e-6
mnway14_cell81 ML14 gate_way14_cell81 GND GND n1 W=1e-6 L=1e-6
mpway14_cell81 ML14 gate_way14_cell81 GND ML14 p1 W=2.4e-6 L=1e-6
mnway14_cell82 ML14 gate_way14_cell82 GND GND n1 W=1e-6 L=1e-6
mpway14_cell82 ML14 gate_way14_cell82 GND ML14 p1 W=2.4e-6 L=1e-6
mnway14_cell83 ML14 gate_way14_cell83 GND GND n1 W=1e-6 L=1e-6
mpway14_cell83 ML14 gate_way14_cell83 GND ML14 p1 W=2.4e-6 L=1e-6
mnway14_cell84 ML14 gate_way14_cell84 GND GND n1 W=1e-6 L=1e-6
mpway14_cell84 ML14 gate_way14_cell84 GND ML14 p1 W=2.4e-6 L=1e-6
mnway14_cell85 ML14 gate_way14_cell85 GND GND n1 W=1e-6 L=1e-6
mpway14_cell85 ML14 gate_way14_cell85 GND ML14 p1 W=2.4e-6 L=1e-6
mnway14_cell86 ML14 gate_way14_cell86 GND GND n1 W=1e-6 L=1e-6
mpway14_cell86 ML14 gate_way14_cell86 GND ML14 p1 W=2.4e-6 L=1e-6
mnway14_cell87 ML14 gate_way14_cell87 GND GND n1 W=1e-6 L=1e-6
mpway14_cell87 ML14 gate_way14_cell87 GND ML14 p1 W=2.4e-6 L=1e-6
mnway14_cell88 ML14 gate_way14_cell88 GND GND n1 W=1e-6 L=1e-6
mpway14_cell88 ML14 gate_way14_cell88 GND ML14 p1 W=2.4e-6 L=1e-6
mnway14_cell89 ML14 gate_way14_cell89 GND GND n1 W=1e-6 L=1e-6
mpway14_cell89 ML14 gate_way14_cell89 GND ML14 p1 W=2.4e-6 L=1e-6
mnway14_cell90 ML14 gate_way14_cell90 GND GND n1 W=1e-6 L=1e-6
mpway14_cell90 ML14 gate_way14_cell90 GND ML14 p1 W=2.4e-6 L=1e-6
mnway14_cell91 ML14 gate_way14_cell91 GND GND n1 W=1e-6 L=1e-6
mpway14_cell91 ML14 gate_way14_cell91 GND ML14 p1 W=2.4e-6 L=1e-6
mnway14_cell92 ML14 gate_way14_cell92 GND GND n1 W=1e-6 L=1e-6
mpway14_cell92 ML14 gate_way14_cell92 GND ML14 p1 W=2.4e-6 L=1e-6
mnway14_cell93 ML14 gate_way14_cell93 GND GND n1 W=1e-6 L=1e-6
mpway14_cell93 ML14 gate_way14_cell93 GND ML14 p1 W=2.4e-6 L=1e-6
mnway14_cell94 ML14 gate_way14_cell94 GND GND n1 W=1e-6 L=1e-6
mpway14_cell94 ML14 gate_way14_cell94 GND ML14 p1 W=2.4e-6 L=1e-6
mnway14_cell95 ML14 gate_way14_cell95 GND GND n1 W=1e-6 L=1e-6
mpway14_cell95 ML14 gate_way14_cell95 GND ML14 p1 W=2.4e-6 L=1e-6
mnway14_cell96 ML14 gate_way14_cell96 GND GND n1 W=1e-6 L=1e-6
mpway14_cell96 ML14 gate_way14_cell96 GND ML14 p1 W=2.4e-6 L=1e-6
mnway14_cell97 ML14 gate_way14_cell97 GND GND n1 W=1e-6 L=1e-6
mpway14_cell97 ML14 gate_way14_cell97 GND ML14 p1 W=2.4e-6 L=1e-6
mnway14_cell98 ML14 gate_way14_cell98 GND GND n1 W=1e-6 L=1e-6
mpway14_cell98 ML14 gate_way14_cell98 GND ML14 p1 W=2.4e-6 L=1e-6
mnway14_cell99 ML14 gate_way14_cell99 GND GND n1 W=1e-6 L=1e-6
mpway14_cell99 ML14 gate_way14_cell99 GND ML14 p1 W=2.4e-6 L=1e-6
mnway15_cell0 ML15 gate_way15_cell0 GND GND n1 W=1e-6 L=1e-6
mpway15_cell0 ML15 gate_way15_cell0 GND ML15 p1 W=2.4e-6 L=1e-6
mnway15_cell1 ML15 gate_way15_cell1 GND GND n1 W=1e-6 L=1e-6
mpway15_cell1 ML15 gate_way15_cell1 GND ML15 p1 W=2.4e-6 L=1e-6
mnway15_cell2 ML15 gate_way15_cell2 GND GND n1 W=1e-6 L=1e-6
mpway15_cell2 ML15 gate_way15_cell2 GND ML15 p1 W=2.4e-6 L=1e-6
mnway15_cell3 ML15 gate_way15_cell3 GND GND n1 W=1e-6 L=1e-6
mpway15_cell3 ML15 gate_way15_cell3 GND ML15 p1 W=2.4e-6 L=1e-6
mnway15_cell4 ML15 gate_way15_cell4 GND GND n1 W=1e-6 L=1e-6
mpway15_cell4 ML15 gate_way15_cell4 GND ML15 p1 W=2.4e-6 L=1e-6
mnway15_cell5 ML15 gate_way15_cell5 GND GND n1 W=1e-6 L=1e-6
mpway15_cell5 ML15 gate_way15_cell5 GND ML15 p1 W=2.4e-6 L=1e-6
mnway15_cell6 ML15 gate_way15_cell6 GND GND n1 W=1e-6 L=1e-6
mpway15_cell6 ML15 gate_way15_cell6 GND ML15 p1 W=2.4e-6 L=1e-6
mnway15_cell7 ML15 gate_way15_cell7 GND GND n1 W=1e-6 L=1e-6
mpway15_cell7 ML15 gate_way15_cell7 GND ML15 p1 W=2.4e-6 L=1e-6
mnway15_cell8 ML15 gate_way15_cell8 GND GND n1 W=1e-6 L=1e-6
mpway15_cell8 ML15 gate_way15_cell8 GND ML15 p1 W=2.4e-6 L=1e-6
mnway15_cell9 ML15 gate_way15_cell9 GND GND n1 W=1e-6 L=1e-6
mpway15_cell9 ML15 gate_way15_cell9 GND ML15 p1 W=2.4e-6 L=1e-6
mnway15_cell10 ML15 gate_way15_cell10 GND GND n1 W=1e-6 L=1e-6
mpway15_cell10 ML15 gate_way15_cell10 GND ML15 p1 W=2.4e-6 L=1e-6
mnway15_cell11 ML15 gate_way15_cell11 GND GND n1 W=1e-6 L=1e-6
mpway15_cell11 ML15 gate_way15_cell11 GND ML15 p1 W=2.4e-6 L=1e-6
mnway15_cell12 ML15 gate_way15_cell12 GND GND n1 W=1e-6 L=1e-6
mpway15_cell12 ML15 gate_way15_cell12 GND ML15 p1 W=2.4e-6 L=1e-6
mnway15_cell13 ML15 gate_way15_cell13 GND GND n1 W=1e-6 L=1e-6
mpway15_cell13 ML15 gate_way15_cell13 GND ML15 p1 W=2.4e-6 L=1e-6
mnway15_cell14 ML15 gate_way15_cell14 GND GND n1 W=1e-6 L=1e-6
mpway15_cell14 ML15 gate_way15_cell14 GND ML15 p1 W=2.4e-6 L=1e-6
mnway15_cell15 ML15 gate_way15_cell15 GND GND n1 W=1e-6 L=1e-6
mpway15_cell15 ML15 gate_way15_cell15 GND ML15 p1 W=2.4e-6 L=1e-6
mnway15_cell16 ML15 gate_way15_cell16 GND GND n1 W=1e-6 L=1e-6
mpway15_cell16 ML15 gate_way15_cell16 GND ML15 p1 W=2.4e-6 L=1e-6
mnway15_cell17 ML15 gate_way15_cell17 GND GND n1 W=1e-6 L=1e-6
mpway15_cell17 ML15 gate_way15_cell17 GND ML15 p1 W=2.4e-6 L=1e-6
mnway15_cell18 ML15 gate_way15_cell18 GND GND n1 W=1e-6 L=1e-6
mpway15_cell18 ML15 gate_way15_cell18 GND ML15 p1 W=2.4e-6 L=1e-6
mnway15_cell19 ML15 gate_way15_cell19 GND GND n1 W=1e-6 L=1e-6
mpway15_cell19 ML15 gate_way15_cell19 GND ML15 p1 W=2.4e-6 L=1e-6
mnway15_cell20 ML15 gate_way15_cell20 GND GND n1 W=1e-6 L=1e-6
mpway15_cell20 ML15 gate_way15_cell20 GND ML15 p1 W=2.4e-6 L=1e-6
mnway15_cell21 ML15 gate_way15_cell21 GND GND n1 W=1e-6 L=1e-6
mpway15_cell21 ML15 gate_way15_cell21 GND ML15 p1 W=2.4e-6 L=1e-6
mnway15_cell22 ML15 gate_way15_cell22 GND GND n1 W=1e-6 L=1e-6
mpway15_cell22 ML15 gate_way15_cell22 GND ML15 p1 W=2.4e-6 L=1e-6
mnway15_cell23 ML15 gate_way15_cell23 GND GND n1 W=1e-6 L=1e-6
mpway15_cell23 ML15 gate_way15_cell23 GND ML15 p1 W=2.4e-6 L=1e-6
mnway15_cell24 ML15 gate_way15_cell24 GND GND n1 W=1e-6 L=1e-6
mpway15_cell24 ML15 gate_way15_cell24 GND ML15 p1 W=2.4e-6 L=1e-6
mnway15_cell25 ML15 gate_way15_cell25 GND GND n1 W=1e-6 L=1e-6
mpway15_cell25 ML15 gate_way15_cell25 GND ML15 p1 W=2.4e-6 L=1e-6
mnway15_cell26 ML15 gate_way15_cell26 GND GND n1 W=1e-6 L=1e-6
mpway15_cell26 ML15 gate_way15_cell26 GND ML15 p1 W=2.4e-6 L=1e-6
mnway15_cell27 ML15 gate_way15_cell27 GND GND n1 W=1e-6 L=1e-6
mpway15_cell27 ML15 gate_way15_cell27 GND ML15 p1 W=2.4e-6 L=1e-6
mnway15_cell28 ML15 gate_way15_cell28 GND GND n1 W=1e-6 L=1e-6
mpway15_cell28 ML15 gate_way15_cell28 GND ML15 p1 W=2.4e-6 L=1e-6
mnway15_cell29 ML15 gate_way15_cell29 GND GND n1 W=1e-6 L=1e-6
mpway15_cell29 ML15 gate_way15_cell29 GND ML15 p1 W=2.4e-6 L=1e-6
mnway15_cell30 ML15 gate_way15_cell30 GND GND n1 W=1e-6 L=1e-6
mpway15_cell30 ML15 gate_way15_cell30 GND ML15 p1 W=2.4e-6 L=1e-6
mnway15_cell31 ML15 gate_way15_cell31 GND GND n1 W=1e-6 L=1e-6
mpway15_cell31 ML15 gate_way15_cell31 GND ML15 p1 W=2.4e-6 L=1e-6
mnway15_cell32 ML15 gate_way15_cell32 GND GND n1 W=1e-6 L=1e-6
mpway15_cell32 ML15 gate_way15_cell32 GND ML15 p1 W=2.4e-6 L=1e-6
mnway15_cell33 ML15 gate_way15_cell33 GND GND n1 W=1e-6 L=1e-6
mpway15_cell33 ML15 gate_way15_cell33 GND ML15 p1 W=2.4e-6 L=1e-6
mnway15_cell34 ML15 gate_way15_cell34 GND GND n1 W=1e-6 L=1e-6
mpway15_cell34 ML15 gate_way15_cell34 GND ML15 p1 W=2.4e-6 L=1e-6
mnway15_cell35 ML15 gate_way15_cell35 GND GND n1 W=1e-6 L=1e-6
mpway15_cell35 ML15 gate_way15_cell35 GND ML15 p1 W=2.4e-6 L=1e-6
mnway15_cell36 ML15 gate_way15_cell36 GND GND n1 W=1e-6 L=1e-6
mpway15_cell36 ML15 gate_way15_cell36 GND ML15 p1 W=2.4e-6 L=1e-6
mnway15_cell37 ML15 gate_way15_cell37 GND GND n1 W=1e-6 L=1e-6
mpway15_cell37 ML15 gate_way15_cell37 GND ML15 p1 W=2.4e-6 L=1e-6
mnway15_cell38 ML15 gate_way15_cell38 GND GND n1 W=1e-6 L=1e-6
mpway15_cell38 ML15 gate_way15_cell38 GND ML15 p1 W=2.4e-6 L=1e-6
mnway15_cell39 ML15 gate_way15_cell39 GND GND n1 W=1e-6 L=1e-6
mpway15_cell39 ML15 gate_way15_cell39 GND ML15 p1 W=2.4e-6 L=1e-6
mnway15_cell40 ML15 gate_way15_cell40 GND GND n1 W=1e-6 L=1e-6
mpway15_cell40 ML15 gate_way15_cell40 GND ML15 p1 W=2.4e-6 L=1e-6
mnway15_cell41 ML15 gate_way15_cell41 GND GND n1 W=1e-6 L=1e-6
mpway15_cell41 ML15 gate_way15_cell41 GND ML15 p1 W=2.4e-6 L=1e-6
mnway15_cell42 ML15 gate_way15_cell42 GND GND n1 W=1e-6 L=1e-6
mpway15_cell42 ML15 gate_way15_cell42 GND ML15 p1 W=2.4e-6 L=1e-6
mnway15_cell43 ML15 gate_way15_cell43 GND GND n1 W=1e-6 L=1e-6
mpway15_cell43 ML15 gate_way15_cell43 GND ML15 p1 W=2.4e-6 L=1e-6
mnway15_cell44 ML15 gate_way15_cell44 GND GND n1 W=1e-6 L=1e-6
mpway15_cell44 ML15 gate_way15_cell44 GND ML15 p1 W=2.4e-6 L=1e-6
mnway15_cell45 ML15 gate_way15_cell45 GND GND n1 W=1e-6 L=1e-6
mpway15_cell45 ML15 gate_way15_cell45 GND ML15 p1 W=2.4e-6 L=1e-6
mnway15_cell46 ML15 gate_way15_cell46 GND GND n1 W=1e-6 L=1e-6
mpway15_cell46 ML15 gate_way15_cell46 GND ML15 p1 W=2.4e-6 L=1e-6
mnway15_cell47 ML15 gate_way15_cell47 GND GND n1 W=1e-6 L=1e-6
mpway15_cell47 ML15 gate_way15_cell47 GND ML15 p1 W=2.4e-6 L=1e-6
mnway15_cell48 ML15 gate_way15_cell48 GND GND n1 W=1e-6 L=1e-6
mpway15_cell48 ML15 gate_way15_cell48 GND ML15 p1 W=2.4e-6 L=1e-6
mnway15_cell49 ML15 gate_way15_cell49 GND GND n1 W=1e-6 L=1e-6
mpway15_cell49 ML15 gate_way15_cell49 GND ML15 p1 W=2.4e-6 L=1e-6
mnway15_cell50 ML15 gate_way15_cell50 GND GND n1 W=1e-6 L=1e-6
mpway15_cell50 ML15 gate_way15_cell50 GND ML15 p1 W=2.4e-6 L=1e-6
mnway15_cell51 ML15 gate_way15_cell51 GND GND n1 W=1e-6 L=1e-6
mpway15_cell51 ML15 gate_way15_cell51 GND ML15 p1 W=2.4e-6 L=1e-6
mnway15_cell52 ML15 gate_way15_cell52 GND GND n1 W=1e-6 L=1e-6
mpway15_cell52 ML15 gate_way15_cell52 GND ML15 p1 W=2.4e-6 L=1e-6
mnway15_cell53 ML15 gate_way15_cell53 GND GND n1 W=1e-6 L=1e-6
mpway15_cell53 ML15 gate_way15_cell53 GND ML15 p1 W=2.4e-6 L=1e-6
mnway15_cell54 ML15 gate_way15_cell54 GND GND n1 W=1e-6 L=1e-6
mpway15_cell54 ML15 gate_way15_cell54 GND ML15 p1 W=2.4e-6 L=1e-6
mnway15_cell55 ML15 gate_way15_cell55 GND GND n1 W=1e-6 L=1e-6
mpway15_cell55 ML15 gate_way15_cell55 GND ML15 p1 W=2.4e-6 L=1e-6
mnway15_cell56 ML15 gate_way15_cell56 GND GND n1 W=1e-6 L=1e-6
mpway15_cell56 ML15 gate_way15_cell56 GND ML15 p1 W=2.4e-6 L=1e-6
mnway15_cell57 ML15 gate_way15_cell57 GND GND n1 W=1e-6 L=1e-6
mpway15_cell57 ML15 gate_way15_cell57 GND ML15 p1 W=2.4e-6 L=1e-6
mnway15_cell58 ML15 gate_way15_cell58 GND GND n1 W=1e-6 L=1e-6
mpway15_cell58 ML15 gate_way15_cell58 GND ML15 p1 W=2.4e-6 L=1e-6
mnway15_cell59 ML15 gate_way15_cell59 GND GND n1 W=1e-6 L=1e-6
mpway15_cell59 ML15 gate_way15_cell59 GND ML15 p1 W=2.4e-6 L=1e-6
mnway15_cell60 ML15 gate_way15_cell60 GND GND n1 W=1e-6 L=1e-6
mpway15_cell60 ML15 gate_way15_cell60 GND ML15 p1 W=2.4e-6 L=1e-6
mnway15_cell61 ML15 gate_way15_cell61 GND GND n1 W=1e-6 L=1e-6
mpway15_cell61 ML15 gate_way15_cell61 GND ML15 p1 W=2.4e-6 L=1e-6
mnway15_cell62 ML15 gate_way15_cell62 GND GND n1 W=1e-6 L=1e-6
mpway15_cell62 ML15 gate_way15_cell62 GND ML15 p1 W=2.4e-6 L=1e-6
mnway15_cell63 ML15 gate_way15_cell63 GND GND n1 W=1e-6 L=1e-6
mpway15_cell63 ML15 gate_way15_cell63 GND ML15 p1 W=2.4e-6 L=1e-6
mnway15_cell64 ML15 gate_way15_cell64 GND GND n1 W=1e-6 L=1e-6
mpway15_cell64 ML15 gate_way15_cell64 GND ML15 p1 W=2.4e-6 L=1e-6
mnway15_cell65 ML15 gate_way15_cell65 GND GND n1 W=1e-6 L=1e-6
mpway15_cell65 ML15 gate_way15_cell65 GND ML15 p1 W=2.4e-6 L=1e-6
mnway15_cell66 ML15 gate_way15_cell66 GND GND n1 W=1e-6 L=1e-6
mpway15_cell66 ML15 gate_way15_cell66 GND ML15 p1 W=2.4e-6 L=1e-6
mnway15_cell67 ML15 gate_way15_cell67 GND GND n1 W=1e-6 L=1e-6
mpway15_cell67 ML15 gate_way15_cell67 GND ML15 p1 W=2.4e-6 L=1e-6
mnway15_cell68 ML15 gate_way15_cell68 GND GND n1 W=1e-6 L=1e-6
mpway15_cell68 ML15 gate_way15_cell68 GND ML15 p1 W=2.4e-6 L=1e-6
mnway15_cell69 ML15 gate_way15_cell69 GND GND n1 W=1e-6 L=1e-6
mpway15_cell69 ML15 gate_way15_cell69 GND ML15 p1 W=2.4e-6 L=1e-6
mnway15_cell70 ML15 gate_way15_cell70 GND GND n1 W=1e-6 L=1e-6
mpway15_cell70 ML15 gate_way15_cell70 GND ML15 p1 W=2.4e-6 L=1e-6
mnway15_cell71 ML15 gate_way15_cell71 GND GND n1 W=1e-6 L=1e-6
mpway15_cell71 ML15 gate_way15_cell71 GND ML15 p1 W=2.4e-6 L=1e-6
mnway15_cell72 ML15 gate_way15_cell72 GND GND n1 W=1e-6 L=1e-6
mpway15_cell72 ML15 gate_way15_cell72 GND ML15 p1 W=2.4e-6 L=1e-6
mnway15_cell73 ML15 gate_way15_cell73 GND GND n1 W=1e-6 L=1e-6
mpway15_cell73 ML15 gate_way15_cell73 GND ML15 p1 W=2.4e-6 L=1e-6
mnway15_cell74 ML15 gate_way15_cell74 GND GND n1 W=1e-6 L=1e-6
mpway15_cell74 ML15 gate_way15_cell74 GND ML15 p1 W=2.4e-6 L=1e-6
mnway15_cell75 ML15 gate_way15_cell75 GND GND n1 W=1e-6 L=1e-6
mpway15_cell75 ML15 gate_way15_cell75 GND ML15 p1 W=2.4e-6 L=1e-6
mnway15_cell76 ML15 gate_way15_cell76 GND GND n1 W=1e-6 L=1e-6
mpway15_cell76 ML15 gate_way15_cell76 GND ML15 p1 W=2.4e-6 L=1e-6
mnway15_cell77 ML15 gate_way15_cell77 GND GND n1 W=1e-6 L=1e-6
mpway15_cell77 ML15 gate_way15_cell77 GND ML15 p1 W=2.4e-6 L=1e-6
mnway15_cell78 ML15 gate_way15_cell78 GND GND n1 W=1e-6 L=1e-6
mpway15_cell78 ML15 gate_way15_cell78 GND ML15 p1 W=2.4e-6 L=1e-6
mnway15_cell79 ML15 gate_way15_cell79 GND GND n1 W=1e-6 L=1e-6
mpway15_cell79 ML15 gate_way15_cell79 GND ML15 p1 W=2.4e-6 L=1e-6
mnway15_cell80 ML15 gate_way15_cell80 GND GND n1 W=1e-6 L=1e-6
mpway15_cell80 ML15 gate_way15_cell80 GND ML15 p1 W=2.4e-6 L=1e-6
mnway15_cell81 ML15 gate_way15_cell81 GND GND n1 W=1e-6 L=1e-6
mpway15_cell81 ML15 gate_way15_cell81 GND ML15 p1 W=2.4e-6 L=1e-6
mnway15_cell82 ML15 gate_way15_cell82 GND GND n1 W=1e-6 L=1e-6
mpway15_cell82 ML15 gate_way15_cell82 GND ML15 p1 W=2.4e-6 L=1e-6
mnway15_cell83 ML15 gate_way15_cell83 GND GND n1 W=1e-6 L=1e-6
mpway15_cell83 ML15 gate_way15_cell83 GND ML15 p1 W=2.4e-6 L=1e-6
mnway15_cell84 ML15 gate_way15_cell84 GND GND n1 W=1e-6 L=1e-6
mpway15_cell84 ML15 gate_way15_cell84 GND ML15 p1 W=2.4e-6 L=1e-6
mnway15_cell85 ML15 gate_way15_cell85 GND GND n1 W=1e-6 L=1e-6
mpway15_cell85 ML15 gate_way15_cell85 GND ML15 p1 W=2.4e-6 L=1e-6
mnway15_cell86 ML15 gate_way15_cell86 GND GND n1 W=1e-6 L=1e-6
mpway15_cell86 ML15 gate_way15_cell86 GND ML15 p1 W=2.4e-6 L=1e-6
mnway15_cell87 ML15 gate_way15_cell87 GND GND n1 W=1e-6 L=1e-6
mpway15_cell87 ML15 gate_way15_cell87 GND ML15 p1 W=2.4e-6 L=1e-6
mnway15_cell88 ML15 gate_way15_cell88 GND GND n1 W=1e-6 L=1e-6
mpway15_cell88 ML15 gate_way15_cell88 GND ML15 p1 W=2.4e-6 L=1e-6
mnway15_cell89 ML15 gate_way15_cell89 GND GND n1 W=1e-6 L=1e-6
mpway15_cell89 ML15 gate_way15_cell89 GND ML15 p1 W=2.4e-6 L=1e-6
mnway15_cell90 ML15 gate_way15_cell90 GND GND n1 W=1e-6 L=1e-6
mpway15_cell90 ML15 gate_way15_cell90 GND ML15 p1 W=2.4e-6 L=1e-6
mnway15_cell91 ML15 gate_way15_cell91 GND GND n1 W=1e-6 L=1e-6
mpway15_cell91 ML15 gate_way15_cell91 GND ML15 p1 W=2.4e-6 L=1e-6
mnway15_cell92 ML15 gate_way15_cell92 GND GND n1 W=1e-6 L=1e-6
mpway15_cell92 ML15 gate_way15_cell92 GND ML15 p1 W=2.4e-6 L=1e-6
mnway15_cell93 ML15 gate_way15_cell93 GND GND n1 W=1e-6 L=1e-6
mpway15_cell93 ML15 gate_way15_cell93 GND ML15 p1 W=2.4e-6 L=1e-6
mnway15_cell94 ML15 gate_way15_cell94 GND GND n1 W=1e-6 L=1e-6
mpway15_cell94 ML15 gate_way15_cell94 GND ML15 p1 W=2.4e-6 L=1e-6
mnway15_cell95 ML15 gate_way15_cell95 GND GND n1 W=1e-6 L=1e-6
mpway15_cell95 ML15 gate_way15_cell95 GND ML15 p1 W=2.4e-6 L=1e-6
mnway15_cell96 ML15 gate_way15_cell96 GND GND n1 W=1e-6 L=1e-6
mpway15_cell96 ML15 gate_way15_cell96 GND ML15 p1 W=2.4e-6 L=1e-6
mnway15_cell97 ML15 gate_way15_cell97 GND GND n1 W=1e-6 L=1e-6
mpway15_cell97 ML15 gate_way15_cell97 GND ML15 p1 W=2.4e-6 L=1e-6
mnway15_cell98 ML15 gate_way15_cell98 GND GND n1 W=1e-6 L=1e-6
mpway15_cell98 ML15 gate_way15_cell98 GND ML15 p1 W=2.4e-6 L=1e-6
mnway15_cell99 ML15 gate_way15_cell99 GND GND n1 W=1e-6 L=1e-6
mpway15_cell99 ML15 gate_way15_cell99 GND ML15 p1 W=2.4e-6 L=1e-6
mnway16_cell0 ML16 gate_way16_cell0 GND GND n1 W=1e-6 L=1e-6
mpway16_cell0 ML16 gate_way16_cell0 GND ML16 p1 W=2.4e-6 L=1e-6
mnway16_cell1 ML16 gate_way16_cell1 GND GND n1 W=1e-6 L=1e-6
mpway16_cell1 ML16 gate_way16_cell1 GND ML16 p1 W=2.4e-6 L=1e-6
mnway16_cell2 ML16 gate_way16_cell2 GND GND n1 W=1e-6 L=1e-6
mpway16_cell2 ML16 gate_way16_cell2 GND ML16 p1 W=2.4e-6 L=1e-6
mnway16_cell3 ML16 gate_way16_cell3 GND GND n1 W=1e-6 L=1e-6
mpway16_cell3 ML16 gate_way16_cell3 GND ML16 p1 W=2.4e-6 L=1e-6
mnway16_cell4 ML16 gate_way16_cell4 GND GND n1 W=1e-6 L=1e-6
mpway16_cell4 ML16 gate_way16_cell4 GND ML16 p1 W=2.4e-6 L=1e-6
mnway16_cell5 ML16 gate_way16_cell5 GND GND n1 W=1e-6 L=1e-6
mpway16_cell5 ML16 gate_way16_cell5 GND ML16 p1 W=2.4e-6 L=1e-6
mnway16_cell6 ML16 gate_way16_cell6 GND GND n1 W=1e-6 L=1e-6
mpway16_cell6 ML16 gate_way16_cell6 GND ML16 p1 W=2.4e-6 L=1e-6
mnway16_cell7 ML16 gate_way16_cell7 GND GND n1 W=1e-6 L=1e-6
mpway16_cell7 ML16 gate_way16_cell7 GND ML16 p1 W=2.4e-6 L=1e-6
mnway16_cell8 ML16 gate_way16_cell8 GND GND n1 W=1e-6 L=1e-6
mpway16_cell8 ML16 gate_way16_cell8 GND ML16 p1 W=2.4e-6 L=1e-6
mnway16_cell9 ML16 gate_way16_cell9 GND GND n1 W=1e-6 L=1e-6
mpway16_cell9 ML16 gate_way16_cell9 GND ML16 p1 W=2.4e-6 L=1e-6
mnway16_cell10 ML16 gate_way16_cell10 GND GND n1 W=1e-6 L=1e-6
mpway16_cell10 ML16 gate_way16_cell10 GND ML16 p1 W=2.4e-6 L=1e-6
mnway16_cell11 ML16 gate_way16_cell11 GND GND n1 W=1e-6 L=1e-6
mpway16_cell11 ML16 gate_way16_cell11 GND ML16 p1 W=2.4e-6 L=1e-6
mnway16_cell12 ML16 gate_way16_cell12 GND GND n1 W=1e-6 L=1e-6
mpway16_cell12 ML16 gate_way16_cell12 GND ML16 p1 W=2.4e-6 L=1e-6
mnway16_cell13 ML16 gate_way16_cell13 GND GND n1 W=1e-6 L=1e-6
mpway16_cell13 ML16 gate_way16_cell13 GND ML16 p1 W=2.4e-6 L=1e-6
mnway16_cell14 ML16 gate_way16_cell14 GND GND n1 W=1e-6 L=1e-6
mpway16_cell14 ML16 gate_way16_cell14 GND ML16 p1 W=2.4e-6 L=1e-6
mnway16_cell15 ML16 gate_way16_cell15 GND GND n1 W=1e-6 L=1e-6
mpway16_cell15 ML16 gate_way16_cell15 GND ML16 p1 W=2.4e-6 L=1e-6
mnway16_cell16 ML16 gate_way16_cell16 GND GND n1 W=1e-6 L=1e-6
mpway16_cell16 ML16 gate_way16_cell16 GND ML16 p1 W=2.4e-6 L=1e-6
mnway16_cell17 ML16 gate_way16_cell17 GND GND n1 W=1e-6 L=1e-6
mpway16_cell17 ML16 gate_way16_cell17 GND ML16 p1 W=2.4e-6 L=1e-6
mnway16_cell18 ML16 gate_way16_cell18 GND GND n1 W=1e-6 L=1e-6
mpway16_cell18 ML16 gate_way16_cell18 GND ML16 p1 W=2.4e-6 L=1e-6
mnway16_cell19 ML16 gate_way16_cell19 GND GND n1 W=1e-6 L=1e-6
mpway16_cell19 ML16 gate_way16_cell19 GND ML16 p1 W=2.4e-6 L=1e-6
mnway16_cell20 ML16 gate_way16_cell20 GND GND n1 W=1e-6 L=1e-6
mpway16_cell20 ML16 gate_way16_cell20 GND ML16 p1 W=2.4e-6 L=1e-6
mnway16_cell21 ML16 gate_way16_cell21 GND GND n1 W=1e-6 L=1e-6
mpway16_cell21 ML16 gate_way16_cell21 GND ML16 p1 W=2.4e-6 L=1e-6
mnway16_cell22 ML16 gate_way16_cell22 GND GND n1 W=1e-6 L=1e-6
mpway16_cell22 ML16 gate_way16_cell22 GND ML16 p1 W=2.4e-6 L=1e-6
mnway16_cell23 ML16 gate_way16_cell23 GND GND n1 W=1e-6 L=1e-6
mpway16_cell23 ML16 gate_way16_cell23 GND ML16 p1 W=2.4e-6 L=1e-6
mnway16_cell24 ML16 gate_way16_cell24 GND GND n1 W=1e-6 L=1e-6
mpway16_cell24 ML16 gate_way16_cell24 GND ML16 p1 W=2.4e-6 L=1e-6
mnway16_cell25 ML16 gate_way16_cell25 GND GND n1 W=1e-6 L=1e-6
mpway16_cell25 ML16 gate_way16_cell25 GND ML16 p1 W=2.4e-6 L=1e-6
mnway16_cell26 ML16 gate_way16_cell26 GND GND n1 W=1e-6 L=1e-6
mpway16_cell26 ML16 gate_way16_cell26 GND ML16 p1 W=2.4e-6 L=1e-6
mnway16_cell27 ML16 gate_way16_cell27 GND GND n1 W=1e-6 L=1e-6
mpway16_cell27 ML16 gate_way16_cell27 GND ML16 p1 W=2.4e-6 L=1e-6
mnway16_cell28 ML16 gate_way16_cell28 GND GND n1 W=1e-6 L=1e-6
mpway16_cell28 ML16 gate_way16_cell28 GND ML16 p1 W=2.4e-6 L=1e-6
mnway16_cell29 ML16 gate_way16_cell29 GND GND n1 W=1e-6 L=1e-6
mpway16_cell29 ML16 gate_way16_cell29 GND ML16 p1 W=2.4e-6 L=1e-6
mnway16_cell30 ML16 gate_way16_cell30 GND GND n1 W=1e-6 L=1e-6
mpway16_cell30 ML16 gate_way16_cell30 GND ML16 p1 W=2.4e-6 L=1e-6
mnway16_cell31 ML16 gate_way16_cell31 GND GND n1 W=1e-6 L=1e-6
mpway16_cell31 ML16 gate_way16_cell31 GND ML16 p1 W=2.4e-6 L=1e-6
mnway16_cell32 ML16 gate_way16_cell32 GND GND n1 W=1e-6 L=1e-6
mpway16_cell32 ML16 gate_way16_cell32 GND ML16 p1 W=2.4e-6 L=1e-6
mnway16_cell33 ML16 gate_way16_cell33 GND GND n1 W=1e-6 L=1e-6
mpway16_cell33 ML16 gate_way16_cell33 GND ML16 p1 W=2.4e-6 L=1e-6
mnway16_cell34 ML16 gate_way16_cell34 GND GND n1 W=1e-6 L=1e-6
mpway16_cell34 ML16 gate_way16_cell34 GND ML16 p1 W=2.4e-6 L=1e-6
mnway16_cell35 ML16 gate_way16_cell35 GND GND n1 W=1e-6 L=1e-6
mpway16_cell35 ML16 gate_way16_cell35 GND ML16 p1 W=2.4e-6 L=1e-6
mnway16_cell36 ML16 gate_way16_cell36 GND GND n1 W=1e-6 L=1e-6
mpway16_cell36 ML16 gate_way16_cell36 GND ML16 p1 W=2.4e-6 L=1e-6
mnway16_cell37 ML16 gate_way16_cell37 GND GND n1 W=1e-6 L=1e-6
mpway16_cell37 ML16 gate_way16_cell37 GND ML16 p1 W=2.4e-6 L=1e-6
mnway16_cell38 ML16 gate_way16_cell38 GND GND n1 W=1e-6 L=1e-6
mpway16_cell38 ML16 gate_way16_cell38 GND ML16 p1 W=2.4e-6 L=1e-6
mnway16_cell39 ML16 gate_way16_cell39 GND GND n1 W=1e-6 L=1e-6
mpway16_cell39 ML16 gate_way16_cell39 GND ML16 p1 W=2.4e-6 L=1e-6
mnway16_cell40 ML16 gate_way16_cell40 GND GND n1 W=1e-6 L=1e-6
mpway16_cell40 ML16 gate_way16_cell40 GND ML16 p1 W=2.4e-6 L=1e-6
mnway16_cell41 ML16 gate_way16_cell41 GND GND n1 W=1e-6 L=1e-6
mpway16_cell41 ML16 gate_way16_cell41 GND ML16 p1 W=2.4e-6 L=1e-6
mnway16_cell42 ML16 gate_way16_cell42 GND GND n1 W=1e-6 L=1e-6
mpway16_cell42 ML16 gate_way16_cell42 GND ML16 p1 W=2.4e-6 L=1e-6
mnway16_cell43 ML16 gate_way16_cell43 GND GND n1 W=1e-6 L=1e-6
mpway16_cell43 ML16 gate_way16_cell43 GND ML16 p1 W=2.4e-6 L=1e-6
mnway16_cell44 ML16 gate_way16_cell44 GND GND n1 W=1e-6 L=1e-6
mpway16_cell44 ML16 gate_way16_cell44 GND ML16 p1 W=2.4e-6 L=1e-6
mnway16_cell45 ML16 gate_way16_cell45 GND GND n1 W=1e-6 L=1e-6
mpway16_cell45 ML16 gate_way16_cell45 GND ML16 p1 W=2.4e-6 L=1e-6
mnway16_cell46 ML16 gate_way16_cell46 GND GND n1 W=1e-6 L=1e-6
mpway16_cell46 ML16 gate_way16_cell46 GND ML16 p1 W=2.4e-6 L=1e-6
mnway16_cell47 ML16 gate_way16_cell47 GND GND n1 W=1e-6 L=1e-6
mpway16_cell47 ML16 gate_way16_cell47 GND ML16 p1 W=2.4e-6 L=1e-6
mnway16_cell48 ML16 gate_way16_cell48 GND GND n1 W=1e-6 L=1e-6
mpway16_cell48 ML16 gate_way16_cell48 GND ML16 p1 W=2.4e-6 L=1e-6
mnway16_cell49 ML16 gate_way16_cell49 GND GND n1 W=1e-6 L=1e-6
mpway16_cell49 ML16 gate_way16_cell49 GND ML16 p1 W=2.4e-6 L=1e-6
mnway16_cell50 ML16 gate_way16_cell50 GND GND n1 W=1e-6 L=1e-6
mpway16_cell50 ML16 gate_way16_cell50 GND ML16 p1 W=2.4e-6 L=1e-6
mnway16_cell51 ML16 gate_way16_cell51 GND GND n1 W=1e-6 L=1e-6
mpway16_cell51 ML16 gate_way16_cell51 GND ML16 p1 W=2.4e-6 L=1e-6
mnway16_cell52 ML16 gate_way16_cell52 GND GND n1 W=1e-6 L=1e-6
mpway16_cell52 ML16 gate_way16_cell52 GND ML16 p1 W=2.4e-6 L=1e-6
mnway16_cell53 ML16 gate_way16_cell53 GND GND n1 W=1e-6 L=1e-6
mpway16_cell53 ML16 gate_way16_cell53 GND ML16 p1 W=2.4e-6 L=1e-6
mnway16_cell54 ML16 gate_way16_cell54 GND GND n1 W=1e-6 L=1e-6
mpway16_cell54 ML16 gate_way16_cell54 GND ML16 p1 W=2.4e-6 L=1e-6
mnway16_cell55 ML16 gate_way16_cell55 GND GND n1 W=1e-6 L=1e-6
mpway16_cell55 ML16 gate_way16_cell55 GND ML16 p1 W=2.4e-6 L=1e-6
mnway16_cell56 ML16 gate_way16_cell56 GND GND n1 W=1e-6 L=1e-6
mpway16_cell56 ML16 gate_way16_cell56 GND ML16 p1 W=2.4e-6 L=1e-6
mnway16_cell57 ML16 gate_way16_cell57 GND GND n1 W=1e-6 L=1e-6
mpway16_cell57 ML16 gate_way16_cell57 GND ML16 p1 W=2.4e-6 L=1e-6
mnway16_cell58 ML16 gate_way16_cell58 GND GND n1 W=1e-6 L=1e-6
mpway16_cell58 ML16 gate_way16_cell58 GND ML16 p1 W=2.4e-6 L=1e-6
mnway16_cell59 ML16 gate_way16_cell59 GND GND n1 W=1e-6 L=1e-6
mpway16_cell59 ML16 gate_way16_cell59 GND ML16 p1 W=2.4e-6 L=1e-6
mnway16_cell60 ML16 gate_way16_cell60 GND GND n1 W=1e-6 L=1e-6
mpway16_cell60 ML16 gate_way16_cell60 GND ML16 p1 W=2.4e-6 L=1e-6
mnway16_cell61 ML16 gate_way16_cell61 GND GND n1 W=1e-6 L=1e-6
mpway16_cell61 ML16 gate_way16_cell61 GND ML16 p1 W=2.4e-6 L=1e-6
mnway16_cell62 ML16 gate_way16_cell62 GND GND n1 W=1e-6 L=1e-6
mpway16_cell62 ML16 gate_way16_cell62 GND ML16 p1 W=2.4e-6 L=1e-6
mnway16_cell63 ML16 gate_way16_cell63 GND GND n1 W=1e-6 L=1e-6
mpway16_cell63 ML16 gate_way16_cell63 GND ML16 p1 W=2.4e-6 L=1e-6
mnway16_cell64 ML16 gate_way16_cell64 GND GND n1 W=1e-6 L=1e-6
mpway16_cell64 ML16 gate_way16_cell64 GND ML16 p1 W=2.4e-6 L=1e-6
mnway16_cell65 ML16 gate_way16_cell65 GND GND n1 W=1e-6 L=1e-6
mpway16_cell65 ML16 gate_way16_cell65 GND ML16 p1 W=2.4e-6 L=1e-6
mnway16_cell66 ML16 gate_way16_cell66 GND GND n1 W=1e-6 L=1e-6
mpway16_cell66 ML16 gate_way16_cell66 GND ML16 p1 W=2.4e-6 L=1e-6
mnway16_cell67 ML16 gate_way16_cell67 GND GND n1 W=1e-6 L=1e-6
mpway16_cell67 ML16 gate_way16_cell67 GND ML16 p1 W=2.4e-6 L=1e-6
mnway16_cell68 ML16 gate_way16_cell68 GND GND n1 W=1e-6 L=1e-6
mpway16_cell68 ML16 gate_way16_cell68 GND ML16 p1 W=2.4e-6 L=1e-6
mnway16_cell69 ML16 gate_way16_cell69 GND GND n1 W=1e-6 L=1e-6
mpway16_cell69 ML16 gate_way16_cell69 GND ML16 p1 W=2.4e-6 L=1e-6
mnway16_cell70 ML16 gate_way16_cell70 GND GND n1 W=1e-6 L=1e-6
mpway16_cell70 ML16 gate_way16_cell70 GND ML16 p1 W=2.4e-6 L=1e-6
mnway16_cell71 ML16 gate_way16_cell71 GND GND n1 W=1e-6 L=1e-6
mpway16_cell71 ML16 gate_way16_cell71 GND ML16 p1 W=2.4e-6 L=1e-6
mnway16_cell72 ML16 gate_way16_cell72 GND GND n1 W=1e-6 L=1e-6
mpway16_cell72 ML16 gate_way16_cell72 GND ML16 p1 W=2.4e-6 L=1e-6
mnway16_cell73 ML16 gate_way16_cell73 GND GND n1 W=1e-6 L=1e-6
mpway16_cell73 ML16 gate_way16_cell73 GND ML16 p1 W=2.4e-6 L=1e-6
mnway16_cell74 ML16 gate_way16_cell74 GND GND n1 W=1e-6 L=1e-6
mpway16_cell74 ML16 gate_way16_cell74 GND ML16 p1 W=2.4e-6 L=1e-6
mnway16_cell75 ML16 gate_way16_cell75 GND GND n1 W=1e-6 L=1e-6
mpway16_cell75 ML16 gate_way16_cell75 GND ML16 p1 W=2.4e-6 L=1e-6
mnway16_cell76 ML16 gate_way16_cell76 GND GND n1 W=1e-6 L=1e-6
mpway16_cell76 ML16 gate_way16_cell76 GND ML16 p1 W=2.4e-6 L=1e-6
mnway16_cell77 ML16 gate_way16_cell77 GND GND n1 W=1e-6 L=1e-6
mpway16_cell77 ML16 gate_way16_cell77 GND ML16 p1 W=2.4e-6 L=1e-6
mnway16_cell78 ML16 gate_way16_cell78 GND GND n1 W=1e-6 L=1e-6
mpway16_cell78 ML16 gate_way16_cell78 GND ML16 p1 W=2.4e-6 L=1e-6
mnway16_cell79 ML16 gate_way16_cell79 GND GND n1 W=1e-6 L=1e-6
mpway16_cell79 ML16 gate_way16_cell79 GND ML16 p1 W=2.4e-6 L=1e-6
mnway16_cell80 ML16 gate_way16_cell80 GND GND n1 W=1e-6 L=1e-6
mpway16_cell80 ML16 gate_way16_cell80 GND ML16 p1 W=2.4e-6 L=1e-6
mnway16_cell81 ML16 gate_way16_cell81 GND GND n1 W=1e-6 L=1e-6
mpway16_cell81 ML16 gate_way16_cell81 GND ML16 p1 W=2.4e-6 L=1e-6
mnway16_cell82 ML16 gate_way16_cell82 GND GND n1 W=1e-6 L=1e-6
mpway16_cell82 ML16 gate_way16_cell82 GND ML16 p1 W=2.4e-6 L=1e-6
mnway16_cell83 ML16 gate_way16_cell83 GND GND n1 W=1e-6 L=1e-6
mpway16_cell83 ML16 gate_way16_cell83 GND ML16 p1 W=2.4e-6 L=1e-6
mnway16_cell84 ML16 gate_way16_cell84 GND GND n1 W=1e-6 L=1e-6
mpway16_cell84 ML16 gate_way16_cell84 GND ML16 p1 W=2.4e-6 L=1e-6
mnway16_cell85 ML16 gate_way16_cell85 GND GND n1 W=1e-6 L=1e-6
mpway16_cell85 ML16 gate_way16_cell85 GND ML16 p1 W=2.4e-6 L=1e-6
mnway16_cell86 ML16 gate_way16_cell86 GND GND n1 W=1e-6 L=1e-6
mpway16_cell86 ML16 gate_way16_cell86 GND ML16 p1 W=2.4e-6 L=1e-6
mnway16_cell87 ML16 gate_way16_cell87 GND GND n1 W=1e-6 L=1e-6
mpway16_cell87 ML16 gate_way16_cell87 GND ML16 p1 W=2.4e-6 L=1e-6
mnway16_cell88 ML16 gate_way16_cell88 GND GND n1 W=1e-6 L=1e-6
mpway16_cell88 ML16 gate_way16_cell88 GND ML16 p1 W=2.4e-6 L=1e-6
mnway16_cell89 ML16 gate_way16_cell89 GND GND n1 W=1e-6 L=1e-6
mpway16_cell89 ML16 gate_way16_cell89 GND ML16 p1 W=2.4e-6 L=1e-6
mnway16_cell90 ML16 gate_way16_cell90 GND GND n1 W=1e-6 L=1e-6
mpway16_cell90 ML16 gate_way16_cell90 GND ML16 p1 W=2.4e-6 L=1e-6
mnway16_cell91 ML16 gate_way16_cell91 GND GND n1 W=1e-6 L=1e-6
mpway16_cell91 ML16 gate_way16_cell91 GND ML16 p1 W=2.4e-6 L=1e-6
mnway16_cell92 ML16 gate_way16_cell92 GND GND n1 W=1e-6 L=1e-6
mpway16_cell92 ML16 gate_way16_cell92 GND ML16 p1 W=2.4e-6 L=1e-6
mnway16_cell93 ML16 gate_way16_cell93 GND GND n1 W=1e-6 L=1e-6
mpway16_cell93 ML16 gate_way16_cell93 GND ML16 p1 W=2.4e-6 L=1e-6
mnway16_cell94 ML16 gate_way16_cell94 GND GND n1 W=1e-6 L=1e-6
mpway16_cell94 ML16 gate_way16_cell94 GND ML16 p1 W=2.4e-6 L=1e-6
mnway16_cell95 ML16 gate_way16_cell95 GND GND n1 W=1e-6 L=1e-6
mpway16_cell95 ML16 gate_way16_cell95 GND ML16 p1 W=2.4e-6 L=1e-6
mnway16_cell96 ML16 gate_way16_cell96 GND GND n1 W=1e-6 L=1e-6
mpway16_cell96 ML16 gate_way16_cell96 GND ML16 p1 W=2.4e-6 L=1e-6
mnway16_cell97 ML16 gate_way16_cell97 GND GND n1 W=1e-6 L=1e-6
mpway16_cell97 ML16 gate_way16_cell97 GND ML16 p1 W=2.4e-6 L=1e-6
mnway16_cell98 ML16 gate_way16_cell98 GND GND n1 W=1e-6 L=1e-6
mpway16_cell98 ML16 gate_way16_cell98 GND ML16 p1 W=2.4e-6 L=1e-6
mnway16_cell99 ML16 gate_way16_cell99 GND GND n1 W=1e-6 L=1e-6
mpway16_cell99 ML16 gate_way16_cell99 GND ML16 p1 W=2.4e-6 L=1e-6
mnway17_cell0 ML17 gate_way17_cell0 GND GND n1 W=1e-6 L=1e-6
mpway17_cell0 ML17 gate_way17_cell0 GND ML17 p1 W=2.4e-6 L=1e-6
mnway17_cell1 ML17 gate_way17_cell1 GND GND n1 W=1e-6 L=1e-6
mpway17_cell1 ML17 gate_way17_cell1 GND ML17 p1 W=2.4e-6 L=1e-6
mnway17_cell2 ML17 gate_way17_cell2 GND GND n1 W=1e-6 L=1e-6
mpway17_cell2 ML17 gate_way17_cell2 GND ML17 p1 W=2.4e-6 L=1e-6
mnway17_cell3 ML17 gate_way17_cell3 GND GND n1 W=1e-6 L=1e-6
mpway17_cell3 ML17 gate_way17_cell3 GND ML17 p1 W=2.4e-6 L=1e-6
mnway17_cell4 ML17 gate_way17_cell4 GND GND n1 W=1e-6 L=1e-6
mpway17_cell4 ML17 gate_way17_cell4 GND ML17 p1 W=2.4e-6 L=1e-6
mnway17_cell5 ML17 gate_way17_cell5 GND GND n1 W=1e-6 L=1e-6
mpway17_cell5 ML17 gate_way17_cell5 GND ML17 p1 W=2.4e-6 L=1e-6
mnway17_cell6 ML17 gate_way17_cell6 GND GND n1 W=1e-6 L=1e-6
mpway17_cell6 ML17 gate_way17_cell6 GND ML17 p1 W=2.4e-6 L=1e-6
mnway17_cell7 ML17 gate_way17_cell7 GND GND n1 W=1e-6 L=1e-6
mpway17_cell7 ML17 gate_way17_cell7 GND ML17 p1 W=2.4e-6 L=1e-6
mnway17_cell8 ML17 gate_way17_cell8 GND GND n1 W=1e-6 L=1e-6
mpway17_cell8 ML17 gate_way17_cell8 GND ML17 p1 W=2.4e-6 L=1e-6
mnway17_cell9 ML17 gate_way17_cell9 GND GND n1 W=1e-6 L=1e-6
mpway17_cell9 ML17 gate_way17_cell9 GND ML17 p1 W=2.4e-6 L=1e-6
mnway17_cell10 ML17 gate_way17_cell10 GND GND n1 W=1e-6 L=1e-6
mpway17_cell10 ML17 gate_way17_cell10 GND ML17 p1 W=2.4e-6 L=1e-6
mnway17_cell11 ML17 gate_way17_cell11 GND GND n1 W=1e-6 L=1e-6
mpway17_cell11 ML17 gate_way17_cell11 GND ML17 p1 W=2.4e-6 L=1e-6
mnway17_cell12 ML17 gate_way17_cell12 GND GND n1 W=1e-6 L=1e-6
mpway17_cell12 ML17 gate_way17_cell12 GND ML17 p1 W=2.4e-6 L=1e-6
mnway17_cell13 ML17 gate_way17_cell13 GND GND n1 W=1e-6 L=1e-6
mpway17_cell13 ML17 gate_way17_cell13 GND ML17 p1 W=2.4e-6 L=1e-6
mnway17_cell14 ML17 gate_way17_cell14 GND GND n1 W=1e-6 L=1e-6
mpway17_cell14 ML17 gate_way17_cell14 GND ML17 p1 W=2.4e-6 L=1e-6
mnway17_cell15 ML17 gate_way17_cell15 GND GND n1 W=1e-6 L=1e-6
mpway17_cell15 ML17 gate_way17_cell15 GND ML17 p1 W=2.4e-6 L=1e-6
mnway17_cell16 ML17 gate_way17_cell16 GND GND n1 W=1e-6 L=1e-6
mpway17_cell16 ML17 gate_way17_cell16 GND ML17 p1 W=2.4e-6 L=1e-6
mnway17_cell17 ML17 gate_way17_cell17 GND GND n1 W=1e-6 L=1e-6
mpway17_cell17 ML17 gate_way17_cell17 GND ML17 p1 W=2.4e-6 L=1e-6
mnway17_cell18 ML17 gate_way17_cell18 GND GND n1 W=1e-6 L=1e-6
mpway17_cell18 ML17 gate_way17_cell18 GND ML17 p1 W=2.4e-6 L=1e-6
mnway17_cell19 ML17 gate_way17_cell19 GND GND n1 W=1e-6 L=1e-6
mpway17_cell19 ML17 gate_way17_cell19 GND ML17 p1 W=2.4e-6 L=1e-6
mnway17_cell20 ML17 gate_way17_cell20 GND GND n1 W=1e-6 L=1e-6
mpway17_cell20 ML17 gate_way17_cell20 GND ML17 p1 W=2.4e-6 L=1e-6
mnway17_cell21 ML17 gate_way17_cell21 GND GND n1 W=1e-6 L=1e-6
mpway17_cell21 ML17 gate_way17_cell21 GND ML17 p1 W=2.4e-6 L=1e-6
mnway17_cell22 ML17 gate_way17_cell22 GND GND n1 W=1e-6 L=1e-6
mpway17_cell22 ML17 gate_way17_cell22 GND ML17 p1 W=2.4e-6 L=1e-6
mnway17_cell23 ML17 gate_way17_cell23 GND GND n1 W=1e-6 L=1e-6
mpway17_cell23 ML17 gate_way17_cell23 GND ML17 p1 W=2.4e-6 L=1e-6
mnway17_cell24 ML17 gate_way17_cell24 GND GND n1 W=1e-6 L=1e-6
mpway17_cell24 ML17 gate_way17_cell24 GND ML17 p1 W=2.4e-6 L=1e-6
mnway17_cell25 ML17 gate_way17_cell25 GND GND n1 W=1e-6 L=1e-6
mpway17_cell25 ML17 gate_way17_cell25 GND ML17 p1 W=2.4e-6 L=1e-6
mnway17_cell26 ML17 gate_way17_cell26 GND GND n1 W=1e-6 L=1e-6
mpway17_cell26 ML17 gate_way17_cell26 GND ML17 p1 W=2.4e-6 L=1e-6
mnway17_cell27 ML17 gate_way17_cell27 GND GND n1 W=1e-6 L=1e-6
mpway17_cell27 ML17 gate_way17_cell27 GND ML17 p1 W=2.4e-6 L=1e-6
mnway17_cell28 ML17 gate_way17_cell28 GND GND n1 W=1e-6 L=1e-6
mpway17_cell28 ML17 gate_way17_cell28 GND ML17 p1 W=2.4e-6 L=1e-6
mnway17_cell29 ML17 gate_way17_cell29 GND GND n1 W=1e-6 L=1e-6
mpway17_cell29 ML17 gate_way17_cell29 GND ML17 p1 W=2.4e-6 L=1e-6
mnway17_cell30 ML17 gate_way17_cell30 GND GND n1 W=1e-6 L=1e-6
mpway17_cell30 ML17 gate_way17_cell30 GND ML17 p1 W=2.4e-6 L=1e-6
mnway17_cell31 ML17 gate_way17_cell31 GND GND n1 W=1e-6 L=1e-6
mpway17_cell31 ML17 gate_way17_cell31 GND ML17 p1 W=2.4e-6 L=1e-6
mnway17_cell32 ML17 gate_way17_cell32 GND GND n1 W=1e-6 L=1e-6
mpway17_cell32 ML17 gate_way17_cell32 GND ML17 p1 W=2.4e-6 L=1e-6
mnway17_cell33 ML17 gate_way17_cell33 GND GND n1 W=1e-6 L=1e-6
mpway17_cell33 ML17 gate_way17_cell33 GND ML17 p1 W=2.4e-6 L=1e-6
mnway17_cell34 ML17 gate_way17_cell34 GND GND n1 W=1e-6 L=1e-6
mpway17_cell34 ML17 gate_way17_cell34 GND ML17 p1 W=2.4e-6 L=1e-6
mnway17_cell35 ML17 gate_way17_cell35 GND GND n1 W=1e-6 L=1e-6
mpway17_cell35 ML17 gate_way17_cell35 GND ML17 p1 W=2.4e-6 L=1e-6
mnway17_cell36 ML17 gate_way17_cell36 GND GND n1 W=1e-6 L=1e-6
mpway17_cell36 ML17 gate_way17_cell36 GND ML17 p1 W=2.4e-6 L=1e-6
mnway17_cell37 ML17 gate_way17_cell37 GND GND n1 W=1e-6 L=1e-6
mpway17_cell37 ML17 gate_way17_cell37 GND ML17 p1 W=2.4e-6 L=1e-6
mnway17_cell38 ML17 gate_way17_cell38 GND GND n1 W=1e-6 L=1e-6
mpway17_cell38 ML17 gate_way17_cell38 GND ML17 p1 W=2.4e-6 L=1e-6
mnway17_cell39 ML17 gate_way17_cell39 GND GND n1 W=1e-6 L=1e-6
mpway17_cell39 ML17 gate_way17_cell39 GND ML17 p1 W=2.4e-6 L=1e-6
mnway17_cell40 ML17 gate_way17_cell40 GND GND n1 W=1e-6 L=1e-6
mpway17_cell40 ML17 gate_way17_cell40 GND ML17 p1 W=2.4e-6 L=1e-6
mnway17_cell41 ML17 gate_way17_cell41 GND GND n1 W=1e-6 L=1e-6
mpway17_cell41 ML17 gate_way17_cell41 GND ML17 p1 W=2.4e-6 L=1e-6
mnway17_cell42 ML17 gate_way17_cell42 GND GND n1 W=1e-6 L=1e-6
mpway17_cell42 ML17 gate_way17_cell42 GND ML17 p1 W=2.4e-6 L=1e-6
mnway17_cell43 ML17 gate_way17_cell43 GND GND n1 W=1e-6 L=1e-6
mpway17_cell43 ML17 gate_way17_cell43 GND ML17 p1 W=2.4e-6 L=1e-6
mnway17_cell44 ML17 gate_way17_cell44 GND GND n1 W=1e-6 L=1e-6
mpway17_cell44 ML17 gate_way17_cell44 GND ML17 p1 W=2.4e-6 L=1e-6
mnway17_cell45 ML17 gate_way17_cell45 GND GND n1 W=1e-6 L=1e-6
mpway17_cell45 ML17 gate_way17_cell45 GND ML17 p1 W=2.4e-6 L=1e-6
mnway17_cell46 ML17 gate_way17_cell46 GND GND n1 W=1e-6 L=1e-6
mpway17_cell46 ML17 gate_way17_cell46 GND ML17 p1 W=2.4e-6 L=1e-6
mnway17_cell47 ML17 gate_way17_cell47 GND GND n1 W=1e-6 L=1e-6
mpway17_cell47 ML17 gate_way17_cell47 GND ML17 p1 W=2.4e-6 L=1e-6
mnway17_cell48 ML17 gate_way17_cell48 GND GND n1 W=1e-6 L=1e-6
mpway17_cell48 ML17 gate_way17_cell48 GND ML17 p1 W=2.4e-6 L=1e-6
mnway17_cell49 ML17 gate_way17_cell49 GND GND n1 W=1e-6 L=1e-6
mpway17_cell49 ML17 gate_way17_cell49 GND ML17 p1 W=2.4e-6 L=1e-6
mnway17_cell50 ML17 gate_way17_cell50 GND GND n1 W=1e-6 L=1e-6
mpway17_cell50 ML17 gate_way17_cell50 GND ML17 p1 W=2.4e-6 L=1e-6
mnway17_cell51 ML17 gate_way17_cell51 GND GND n1 W=1e-6 L=1e-6
mpway17_cell51 ML17 gate_way17_cell51 GND ML17 p1 W=2.4e-6 L=1e-6
mnway17_cell52 ML17 gate_way17_cell52 GND GND n1 W=1e-6 L=1e-6
mpway17_cell52 ML17 gate_way17_cell52 GND ML17 p1 W=2.4e-6 L=1e-6
mnway17_cell53 ML17 gate_way17_cell53 GND GND n1 W=1e-6 L=1e-6
mpway17_cell53 ML17 gate_way17_cell53 GND ML17 p1 W=2.4e-6 L=1e-6
mnway17_cell54 ML17 gate_way17_cell54 GND GND n1 W=1e-6 L=1e-6
mpway17_cell54 ML17 gate_way17_cell54 GND ML17 p1 W=2.4e-6 L=1e-6
mnway17_cell55 ML17 gate_way17_cell55 GND GND n1 W=1e-6 L=1e-6
mpway17_cell55 ML17 gate_way17_cell55 GND ML17 p1 W=2.4e-6 L=1e-6
mnway17_cell56 ML17 gate_way17_cell56 GND GND n1 W=1e-6 L=1e-6
mpway17_cell56 ML17 gate_way17_cell56 GND ML17 p1 W=2.4e-6 L=1e-6
mnway17_cell57 ML17 gate_way17_cell57 GND GND n1 W=1e-6 L=1e-6
mpway17_cell57 ML17 gate_way17_cell57 GND ML17 p1 W=2.4e-6 L=1e-6
mnway17_cell58 ML17 gate_way17_cell58 GND GND n1 W=1e-6 L=1e-6
mpway17_cell58 ML17 gate_way17_cell58 GND ML17 p1 W=2.4e-6 L=1e-6
mnway17_cell59 ML17 gate_way17_cell59 GND GND n1 W=1e-6 L=1e-6
mpway17_cell59 ML17 gate_way17_cell59 GND ML17 p1 W=2.4e-6 L=1e-6
mnway17_cell60 ML17 gate_way17_cell60 GND GND n1 W=1e-6 L=1e-6
mpway17_cell60 ML17 gate_way17_cell60 GND ML17 p1 W=2.4e-6 L=1e-6
mnway17_cell61 ML17 gate_way17_cell61 GND GND n1 W=1e-6 L=1e-6
mpway17_cell61 ML17 gate_way17_cell61 GND ML17 p1 W=2.4e-6 L=1e-6
mnway17_cell62 ML17 gate_way17_cell62 GND GND n1 W=1e-6 L=1e-6
mpway17_cell62 ML17 gate_way17_cell62 GND ML17 p1 W=2.4e-6 L=1e-6
mnway17_cell63 ML17 gate_way17_cell63 GND GND n1 W=1e-6 L=1e-6
mpway17_cell63 ML17 gate_way17_cell63 GND ML17 p1 W=2.4e-6 L=1e-6
mnway17_cell64 ML17 gate_way17_cell64 GND GND n1 W=1e-6 L=1e-6
mpway17_cell64 ML17 gate_way17_cell64 GND ML17 p1 W=2.4e-6 L=1e-6
mnway17_cell65 ML17 gate_way17_cell65 GND GND n1 W=1e-6 L=1e-6
mpway17_cell65 ML17 gate_way17_cell65 GND ML17 p1 W=2.4e-6 L=1e-6
mnway17_cell66 ML17 gate_way17_cell66 GND GND n1 W=1e-6 L=1e-6
mpway17_cell66 ML17 gate_way17_cell66 GND ML17 p1 W=2.4e-6 L=1e-6
mnway17_cell67 ML17 gate_way17_cell67 GND GND n1 W=1e-6 L=1e-6
mpway17_cell67 ML17 gate_way17_cell67 GND ML17 p1 W=2.4e-6 L=1e-6
mnway17_cell68 ML17 gate_way17_cell68 GND GND n1 W=1e-6 L=1e-6
mpway17_cell68 ML17 gate_way17_cell68 GND ML17 p1 W=2.4e-6 L=1e-6
mnway17_cell69 ML17 gate_way17_cell69 GND GND n1 W=1e-6 L=1e-6
mpway17_cell69 ML17 gate_way17_cell69 GND ML17 p1 W=2.4e-6 L=1e-6
mnway17_cell70 ML17 gate_way17_cell70 GND GND n1 W=1e-6 L=1e-6
mpway17_cell70 ML17 gate_way17_cell70 GND ML17 p1 W=2.4e-6 L=1e-6
mnway17_cell71 ML17 gate_way17_cell71 GND GND n1 W=1e-6 L=1e-6
mpway17_cell71 ML17 gate_way17_cell71 GND ML17 p1 W=2.4e-6 L=1e-6
mnway17_cell72 ML17 gate_way17_cell72 GND GND n1 W=1e-6 L=1e-6
mpway17_cell72 ML17 gate_way17_cell72 GND ML17 p1 W=2.4e-6 L=1e-6
mnway17_cell73 ML17 gate_way17_cell73 GND GND n1 W=1e-6 L=1e-6
mpway17_cell73 ML17 gate_way17_cell73 GND ML17 p1 W=2.4e-6 L=1e-6
mnway17_cell74 ML17 gate_way17_cell74 GND GND n1 W=1e-6 L=1e-6
mpway17_cell74 ML17 gate_way17_cell74 GND ML17 p1 W=2.4e-6 L=1e-6
mnway17_cell75 ML17 gate_way17_cell75 GND GND n1 W=1e-6 L=1e-6
mpway17_cell75 ML17 gate_way17_cell75 GND ML17 p1 W=2.4e-6 L=1e-6
mnway17_cell76 ML17 gate_way17_cell76 GND GND n1 W=1e-6 L=1e-6
mpway17_cell76 ML17 gate_way17_cell76 GND ML17 p1 W=2.4e-6 L=1e-6
mnway17_cell77 ML17 gate_way17_cell77 GND GND n1 W=1e-6 L=1e-6
mpway17_cell77 ML17 gate_way17_cell77 GND ML17 p1 W=2.4e-6 L=1e-6
mnway17_cell78 ML17 gate_way17_cell78 GND GND n1 W=1e-6 L=1e-6
mpway17_cell78 ML17 gate_way17_cell78 GND ML17 p1 W=2.4e-6 L=1e-6
mnway17_cell79 ML17 gate_way17_cell79 GND GND n1 W=1e-6 L=1e-6
mpway17_cell79 ML17 gate_way17_cell79 GND ML17 p1 W=2.4e-6 L=1e-6
mnway17_cell80 ML17 gate_way17_cell80 GND GND n1 W=1e-6 L=1e-6
mpway17_cell80 ML17 gate_way17_cell80 GND ML17 p1 W=2.4e-6 L=1e-6
mnway17_cell81 ML17 gate_way17_cell81 GND GND n1 W=1e-6 L=1e-6
mpway17_cell81 ML17 gate_way17_cell81 GND ML17 p1 W=2.4e-6 L=1e-6
mnway17_cell82 ML17 gate_way17_cell82 GND GND n1 W=1e-6 L=1e-6
mpway17_cell82 ML17 gate_way17_cell82 GND ML17 p1 W=2.4e-6 L=1e-6
mnway17_cell83 ML17 gate_way17_cell83 GND GND n1 W=1e-6 L=1e-6
mpway17_cell83 ML17 gate_way17_cell83 GND ML17 p1 W=2.4e-6 L=1e-6
mnway17_cell84 ML17 gate_way17_cell84 GND GND n1 W=1e-6 L=1e-6
mpway17_cell84 ML17 gate_way17_cell84 GND ML17 p1 W=2.4e-6 L=1e-6
mnway17_cell85 ML17 gate_way17_cell85 GND GND n1 W=1e-6 L=1e-6
mpway17_cell85 ML17 gate_way17_cell85 GND ML17 p1 W=2.4e-6 L=1e-6
mnway17_cell86 ML17 gate_way17_cell86 GND GND n1 W=1e-6 L=1e-6
mpway17_cell86 ML17 gate_way17_cell86 GND ML17 p1 W=2.4e-6 L=1e-6
mnway17_cell87 ML17 gate_way17_cell87 GND GND n1 W=1e-6 L=1e-6
mpway17_cell87 ML17 gate_way17_cell87 GND ML17 p1 W=2.4e-6 L=1e-6
mnway17_cell88 ML17 gate_way17_cell88 GND GND n1 W=1e-6 L=1e-6
mpway17_cell88 ML17 gate_way17_cell88 GND ML17 p1 W=2.4e-6 L=1e-6
mnway17_cell89 ML17 gate_way17_cell89 GND GND n1 W=1e-6 L=1e-6
mpway17_cell89 ML17 gate_way17_cell89 GND ML17 p1 W=2.4e-6 L=1e-6
mnway17_cell90 ML17 gate_way17_cell90 GND GND n1 W=1e-6 L=1e-6
mpway17_cell90 ML17 gate_way17_cell90 GND ML17 p1 W=2.4e-6 L=1e-6
mnway17_cell91 ML17 gate_way17_cell91 GND GND n1 W=1e-6 L=1e-6
mpway17_cell91 ML17 gate_way17_cell91 GND ML17 p1 W=2.4e-6 L=1e-6
mnway17_cell92 ML17 gate_way17_cell92 GND GND n1 W=1e-6 L=1e-6
mpway17_cell92 ML17 gate_way17_cell92 GND ML17 p1 W=2.4e-6 L=1e-6
mnway17_cell93 ML17 gate_way17_cell93 GND GND n1 W=1e-6 L=1e-6
mpway17_cell93 ML17 gate_way17_cell93 GND ML17 p1 W=2.4e-6 L=1e-6
mnway17_cell94 ML17 gate_way17_cell94 GND GND n1 W=1e-6 L=1e-6
mpway17_cell94 ML17 gate_way17_cell94 GND ML17 p1 W=2.4e-6 L=1e-6
mnway17_cell95 ML17 gate_way17_cell95 GND GND n1 W=1e-6 L=1e-6
mpway17_cell95 ML17 gate_way17_cell95 GND ML17 p1 W=2.4e-6 L=1e-6
mnway17_cell96 ML17 gate_way17_cell96 GND GND n1 W=1e-6 L=1e-6
mpway17_cell96 ML17 gate_way17_cell96 GND ML17 p1 W=2.4e-6 L=1e-6
mnway17_cell97 ML17 gate_way17_cell97 GND GND n1 W=1e-6 L=1e-6
mpway17_cell97 ML17 gate_way17_cell97 GND ML17 p1 W=2.4e-6 L=1e-6
mnway17_cell98 ML17 gate_way17_cell98 GND GND n1 W=1e-6 L=1e-6
mpway17_cell98 ML17 gate_way17_cell98 GND ML17 p1 W=2.4e-6 L=1e-6
mnway17_cell99 ML17 gate_way17_cell99 GND GND n1 W=1e-6 L=1e-6
mpway17_cell99 ML17 gate_way17_cell99 GND ML17 p1 W=2.4e-6 L=1e-6
mnway18_cell0 ML18 gate_way18_cell0 GND GND n1 W=1e-6 L=1e-6
mpway18_cell0 ML18 gate_way18_cell0 GND ML18 p1 W=2.4e-6 L=1e-6
mnway18_cell1 ML18 gate_way18_cell1 GND GND n1 W=1e-6 L=1e-6
mpway18_cell1 ML18 gate_way18_cell1 GND ML18 p1 W=2.4e-6 L=1e-6
mnway18_cell2 ML18 gate_way18_cell2 GND GND n1 W=1e-6 L=1e-6
mpway18_cell2 ML18 gate_way18_cell2 GND ML18 p1 W=2.4e-6 L=1e-6
mnway18_cell3 ML18 gate_way18_cell3 GND GND n1 W=1e-6 L=1e-6
mpway18_cell3 ML18 gate_way18_cell3 GND ML18 p1 W=2.4e-6 L=1e-6
mnway18_cell4 ML18 gate_way18_cell4 GND GND n1 W=1e-6 L=1e-6
mpway18_cell4 ML18 gate_way18_cell4 GND ML18 p1 W=2.4e-6 L=1e-6
mnway18_cell5 ML18 gate_way18_cell5 GND GND n1 W=1e-6 L=1e-6
mpway18_cell5 ML18 gate_way18_cell5 GND ML18 p1 W=2.4e-6 L=1e-6
mnway18_cell6 ML18 gate_way18_cell6 GND GND n1 W=1e-6 L=1e-6
mpway18_cell6 ML18 gate_way18_cell6 GND ML18 p1 W=2.4e-6 L=1e-6
mnway18_cell7 ML18 gate_way18_cell7 GND GND n1 W=1e-6 L=1e-6
mpway18_cell7 ML18 gate_way18_cell7 GND ML18 p1 W=2.4e-6 L=1e-6
mnway18_cell8 ML18 gate_way18_cell8 GND GND n1 W=1e-6 L=1e-6
mpway18_cell8 ML18 gate_way18_cell8 GND ML18 p1 W=2.4e-6 L=1e-6
mnway18_cell9 ML18 gate_way18_cell9 GND GND n1 W=1e-6 L=1e-6
mpway18_cell9 ML18 gate_way18_cell9 GND ML18 p1 W=2.4e-6 L=1e-6
mnway18_cell10 ML18 gate_way18_cell10 GND GND n1 W=1e-6 L=1e-6
mpway18_cell10 ML18 gate_way18_cell10 GND ML18 p1 W=2.4e-6 L=1e-6
mnway18_cell11 ML18 gate_way18_cell11 GND GND n1 W=1e-6 L=1e-6
mpway18_cell11 ML18 gate_way18_cell11 GND ML18 p1 W=2.4e-6 L=1e-6
mnway18_cell12 ML18 gate_way18_cell12 GND GND n1 W=1e-6 L=1e-6
mpway18_cell12 ML18 gate_way18_cell12 GND ML18 p1 W=2.4e-6 L=1e-6
mnway18_cell13 ML18 gate_way18_cell13 GND GND n1 W=1e-6 L=1e-6
mpway18_cell13 ML18 gate_way18_cell13 GND ML18 p1 W=2.4e-6 L=1e-6
mnway18_cell14 ML18 gate_way18_cell14 GND GND n1 W=1e-6 L=1e-6
mpway18_cell14 ML18 gate_way18_cell14 GND ML18 p1 W=2.4e-6 L=1e-6
mnway18_cell15 ML18 gate_way18_cell15 GND GND n1 W=1e-6 L=1e-6
mpway18_cell15 ML18 gate_way18_cell15 GND ML18 p1 W=2.4e-6 L=1e-6
mnway18_cell16 ML18 gate_way18_cell16 GND GND n1 W=1e-6 L=1e-6
mpway18_cell16 ML18 gate_way18_cell16 GND ML18 p1 W=2.4e-6 L=1e-6
mnway18_cell17 ML18 gate_way18_cell17 GND GND n1 W=1e-6 L=1e-6
mpway18_cell17 ML18 gate_way18_cell17 GND ML18 p1 W=2.4e-6 L=1e-6
mnway18_cell18 ML18 gate_way18_cell18 GND GND n1 W=1e-6 L=1e-6
mpway18_cell18 ML18 gate_way18_cell18 GND ML18 p1 W=2.4e-6 L=1e-6
mnway18_cell19 ML18 gate_way18_cell19 GND GND n1 W=1e-6 L=1e-6
mpway18_cell19 ML18 gate_way18_cell19 GND ML18 p1 W=2.4e-6 L=1e-6
mnway18_cell20 ML18 gate_way18_cell20 GND GND n1 W=1e-6 L=1e-6
mpway18_cell20 ML18 gate_way18_cell20 GND ML18 p1 W=2.4e-6 L=1e-6
mnway18_cell21 ML18 gate_way18_cell21 GND GND n1 W=1e-6 L=1e-6
mpway18_cell21 ML18 gate_way18_cell21 GND ML18 p1 W=2.4e-6 L=1e-6
mnway18_cell22 ML18 gate_way18_cell22 GND GND n1 W=1e-6 L=1e-6
mpway18_cell22 ML18 gate_way18_cell22 GND ML18 p1 W=2.4e-6 L=1e-6
mnway18_cell23 ML18 gate_way18_cell23 GND GND n1 W=1e-6 L=1e-6
mpway18_cell23 ML18 gate_way18_cell23 GND ML18 p1 W=2.4e-6 L=1e-6
mnway18_cell24 ML18 gate_way18_cell24 GND GND n1 W=1e-6 L=1e-6
mpway18_cell24 ML18 gate_way18_cell24 GND ML18 p1 W=2.4e-6 L=1e-6
mnway18_cell25 ML18 gate_way18_cell25 GND GND n1 W=1e-6 L=1e-6
mpway18_cell25 ML18 gate_way18_cell25 GND ML18 p1 W=2.4e-6 L=1e-6
mnway18_cell26 ML18 gate_way18_cell26 GND GND n1 W=1e-6 L=1e-6
mpway18_cell26 ML18 gate_way18_cell26 GND ML18 p1 W=2.4e-6 L=1e-6
mnway18_cell27 ML18 gate_way18_cell27 GND GND n1 W=1e-6 L=1e-6
mpway18_cell27 ML18 gate_way18_cell27 GND ML18 p1 W=2.4e-6 L=1e-6
mnway18_cell28 ML18 gate_way18_cell28 GND GND n1 W=1e-6 L=1e-6
mpway18_cell28 ML18 gate_way18_cell28 GND ML18 p1 W=2.4e-6 L=1e-6
mnway18_cell29 ML18 gate_way18_cell29 GND GND n1 W=1e-6 L=1e-6
mpway18_cell29 ML18 gate_way18_cell29 GND ML18 p1 W=2.4e-6 L=1e-6
mnway18_cell30 ML18 gate_way18_cell30 GND GND n1 W=1e-6 L=1e-6
mpway18_cell30 ML18 gate_way18_cell30 GND ML18 p1 W=2.4e-6 L=1e-6
mnway18_cell31 ML18 gate_way18_cell31 GND GND n1 W=1e-6 L=1e-6
mpway18_cell31 ML18 gate_way18_cell31 GND ML18 p1 W=2.4e-6 L=1e-6
mnway18_cell32 ML18 gate_way18_cell32 GND GND n1 W=1e-6 L=1e-6
mpway18_cell32 ML18 gate_way18_cell32 GND ML18 p1 W=2.4e-6 L=1e-6
mnway18_cell33 ML18 gate_way18_cell33 GND GND n1 W=1e-6 L=1e-6
mpway18_cell33 ML18 gate_way18_cell33 GND ML18 p1 W=2.4e-6 L=1e-6
mnway18_cell34 ML18 gate_way18_cell34 GND GND n1 W=1e-6 L=1e-6
mpway18_cell34 ML18 gate_way18_cell34 GND ML18 p1 W=2.4e-6 L=1e-6
mnway18_cell35 ML18 gate_way18_cell35 GND GND n1 W=1e-6 L=1e-6
mpway18_cell35 ML18 gate_way18_cell35 GND ML18 p1 W=2.4e-6 L=1e-6
mnway18_cell36 ML18 gate_way18_cell36 GND GND n1 W=1e-6 L=1e-6
mpway18_cell36 ML18 gate_way18_cell36 GND ML18 p1 W=2.4e-6 L=1e-6
mnway18_cell37 ML18 gate_way18_cell37 GND GND n1 W=1e-6 L=1e-6
mpway18_cell37 ML18 gate_way18_cell37 GND ML18 p1 W=2.4e-6 L=1e-6
mnway18_cell38 ML18 gate_way18_cell38 GND GND n1 W=1e-6 L=1e-6
mpway18_cell38 ML18 gate_way18_cell38 GND ML18 p1 W=2.4e-6 L=1e-6
mnway18_cell39 ML18 gate_way18_cell39 GND GND n1 W=1e-6 L=1e-6
mpway18_cell39 ML18 gate_way18_cell39 GND ML18 p1 W=2.4e-6 L=1e-6
mnway18_cell40 ML18 gate_way18_cell40 GND GND n1 W=1e-6 L=1e-6
mpway18_cell40 ML18 gate_way18_cell40 GND ML18 p1 W=2.4e-6 L=1e-6
mnway18_cell41 ML18 gate_way18_cell41 GND GND n1 W=1e-6 L=1e-6
mpway18_cell41 ML18 gate_way18_cell41 GND ML18 p1 W=2.4e-6 L=1e-6
mnway18_cell42 ML18 gate_way18_cell42 GND GND n1 W=1e-6 L=1e-6
mpway18_cell42 ML18 gate_way18_cell42 GND ML18 p1 W=2.4e-6 L=1e-6
mnway18_cell43 ML18 gate_way18_cell43 GND GND n1 W=1e-6 L=1e-6
mpway18_cell43 ML18 gate_way18_cell43 GND ML18 p1 W=2.4e-6 L=1e-6
mnway18_cell44 ML18 gate_way18_cell44 GND GND n1 W=1e-6 L=1e-6
mpway18_cell44 ML18 gate_way18_cell44 GND ML18 p1 W=2.4e-6 L=1e-6
mnway18_cell45 ML18 gate_way18_cell45 GND GND n1 W=1e-6 L=1e-6
mpway18_cell45 ML18 gate_way18_cell45 GND ML18 p1 W=2.4e-6 L=1e-6
mnway18_cell46 ML18 gate_way18_cell46 GND GND n1 W=1e-6 L=1e-6
mpway18_cell46 ML18 gate_way18_cell46 GND ML18 p1 W=2.4e-6 L=1e-6
mnway18_cell47 ML18 gate_way18_cell47 GND GND n1 W=1e-6 L=1e-6
mpway18_cell47 ML18 gate_way18_cell47 GND ML18 p1 W=2.4e-6 L=1e-6
mnway18_cell48 ML18 gate_way18_cell48 GND GND n1 W=1e-6 L=1e-6
mpway18_cell48 ML18 gate_way18_cell48 GND ML18 p1 W=2.4e-6 L=1e-6
mnway18_cell49 ML18 gate_way18_cell49 GND GND n1 W=1e-6 L=1e-6
mpway18_cell49 ML18 gate_way18_cell49 GND ML18 p1 W=2.4e-6 L=1e-6
mnway18_cell50 ML18 gate_way18_cell50 GND GND n1 W=1e-6 L=1e-6
mpway18_cell50 ML18 gate_way18_cell50 GND ML18 p1 W=2.4e-6 L=1e-6
mnway18_cell51 ML18 gate_way18_cell51 GND GND n1 W=1e-6 L=1e-6
mpway18_cell51 ML18 gate_way18_cell51 GND ML18 p1 W=2.4e-6 L=1e-6
mnway18_cell52 ML18 gate_way18_cell52 GND GND n1 W=1e-6 L=1e-6
mpway18_cell52 ML18 gate_way18_cell52 GND ML18 p1 W=2.4e-6 L=1e-6
mnway18_cell53 ML18 gate_way18_cell53 GND GND n1 W=1e-6 L=1e-6
mpway18_cell53 ML18 gate_way18_cell53 GND ML18 p1 W=2.4e-6 L=1e-6
mnway18_cell54 ML18 gate_way18_cell54 GND GND n1 W=1e-6 L=1e-6
mpway18_cell54 ML18 gate_way18_cell54 GND ML18 p1 W=2.4e-6 L=1e-6
mnway18_cell55 ML18 gate_way18_cell55 GND GND n1 W=1e-6 L=1e-6
mpway18_cell55 ML18 gate_way18_cell55 GND ML18 p1 W=2.4e-6 L=1e-6
mnway18_cell56 ML18 gate_way18_cell56 GND GND n1 W=1e-6 L=1e-6
mpway18_cell56 ML18 gate_way18_cell56 GND ML18 p1 W=2.4e-6 L=1e-6
mnway18_cell57 ML18 gate_way18_cell57 GND GND n1 W=1e-6 L=1e-6
mpway18_cell57 ML18 gate_way18_cell57 GND ML18 p1 W=2.4e-6 L=1e-6
mnway18_cell58 ML18 gate_way18_cell58 GND GND n1 W=1e-6 L=1e-6
mpway18_cell58 ML18 gate_way18_cell58 GND ML18 p1 W=2.4e-6 L=1e-6
mnway18_cell59 ML18 gate_way18_cell59 GND GND n1 W=1e-6 L=1e-6
mpway18_cell59 ML18 gate_way18_cell59 GND ML18 p1 W=2.4e-6 L=1e-6
mnway18_cell60 ML18 gate_way18_cell60 GND GND n1 W=1e-6 L=1e-6
mpway18_cell60 ML18 gate_way18_cell60 GND ML18 p1 W=2.4e-6 L=1e-6
mnway18_cell61 ML18 gate_way18_cell61 GND GND n1 W=1e-6 L=1e-6
mpway18_cell61 ML18 gate_way18_cell61 GND ML18 p1 W=2.4e-6 L=1e-6
mnway18_cell62 ML18 gate_way18_cell62 GND GND n1 W=1e-6 L=1e-6
mpway18_cell62 ML18 gate_way18_cell62 GND ML18 p1 W=2.4e-6 L=1e-6
mnway18_cell63 ML18 gate_way18_cell63 GND GND n1 W=1e-6 L=1e-6
mpway18_cell63 ML18 gate_way18_cell63 GND ML18 p1 W=2.4e-6 L=1e-6
mnway18_cell64 ML18 gate_way18_cell64 GND GND n1 W=1e-6 L=1e-6
mpway18_cell64 ML18 gate_way18_cell64 GND ML18 p1 W=2.4e-6 L=1e-6
mnway18_cell65 ML18 gate_way18_cell65 GND GND n1 W=1e-6 L=1e-6
mpway18_cell65 ML18 gate_way18_cell65 GND ML18 p1 W=2.4e-6 L=1e-6
mnway18_cell66 ML18 gate_way18_cell66 GND GND n1 W=1e-6 L=1e-6
mpway18_cell66 ML18 gate_way18_cell66 GND ML18 p1 W=2.4e-6 L=1e-6
mnway18_cell67 ML18 gate_way18_cell67 GND GND n1 W=1e-6 L=1e-6
mpway18_cell67 ML18 gate_way18_cell67 GND ML18 p1 W=2.4e-6 L=1e-6
mnway18_cell68 ML18 gate_way18_cell68 GND GND n1 W=1e-6 L=1e-6
mpway18_cell68 ML18 gate_way18_cell68 GND ML18 p1 W=2.4e-6 L=1e-6
mnway18_cell69 ML18 gate_way18_cell69 GND GND n1 W=1e-6 L=1e-6
mpway18_cell69 ML18 gate_way18_cell69 GND ML18 p1 W=2.4e-6 L=1e-6
mnway18_cell70 ML18 gate_way18_cell70 GND GND n1 W=1e-6 L=1e-6
mpway18_cell70 ML18 gate_way18_cell70 GND ML18 p1 W=2.4e-6 L=1e-6
mnway18_cell71 ML18 gate_way18_cell71 GND GND n1 W=1e-6 L=1e-6
mpway18_cell71 ML18 gate_way18_cell71 GND ML18 p1 W=2.4e-6 L=1e-6
mnway18_cell72 ML18 gate_way18_cell72 GND GND n1 W=1e-6 L=1e-6
mpway18_cell72 ML18 gate_way18_cell72 GND ML18 p1 W=2.4e-6 L=1e-6
mnway18_cell73 ML18 gate_way18_cell73 GND GND n1 W=1e-6 L=1e-6
mpway18_cell73 ML18 gate_way18_cell73 GND ML18 p1 W=2.4e-6 L=1e-6
mnway18_cell74 ML18 gate_way18_cell74 GND GND n1 W=1e-6 L=1e-6
mpway18_cell74 ML18 gate_way18_cell74 GND ML18 p1 W=2.4e-6 L=1e-6
mnway18_cell75 ML18 gate_way18_cell75 GND GND n1 W=1e-6 L=1e-6
mpway18_cell75 ML18 gate_way18_cell75 GND ML18 p1 W=2.4e-6 L=1e-6
mnway18_cell76 ML18 gate_way18_cell76 GND GND n1 W=1e-6 L=1e-6
mpway18_cell76 ML18 gate_way18_cell76 GND ML18 p1 W=2.4e-6 L=1e-6
mnway18_cell77 ML18 gate_way18_cell77 GND GND n1 W=1e-6 L=1e-6
mpway18_cell77 ML18 gate_way18_cell77 GND ML18 p1 W=2.4e-6 L=1e-6
mnway18_cell78 ML18 gate_way18_cell78 GND GND n1 W=1e-6 L=1e-6
mpway18_cell78 ML18 gate_way18_cell78 GND ML18 p1 W=2.4e-6 L=1e-6
mnway18_cell79 ML18 gate_way18_cell79 GND GND n1 W=1e-6 L=1e-6
mpway18_cell79 ML18 gate_way18_cell79 GND ML18 p1 W=2.4e-6 L=1e-6
mnway18_cell80 ML18 gate_way18_cell80 GND GND n1 W=1e-6 L=1e-6
mpway18_cell80 ML18 gate_way18_cell80 GND ML18 p1 W=2.4e-6 L=1e-6
mnway18_cell81 ML18 gate_way18_cell81 GND GND n1 W=1e-6 L=1e-6
mpway18_cell81 ML18 gate_way18_cell81 GND ML18 p1 W=2.4e-6 L=1e-6
mnway18_cell82 ML18 gate_way18_cell82 GND GND n1 W=1e-6 L=1e-6
mpway18_cell82 ML18 gate_way18_cell82 GND ML18 p1 W=2.4e-6 L=1e-6
mnway18_cell83 ML18 gate_way18_cell83 GND GND n1 W=1e-6 L=1e-6
mpway18_cell83 ML18 gate_way18_cell83 GND ML18 p1 W=2.4e-6 L=1e-6
mnway18_cell84 ML18 gate_way18_cell84 GND GND n1 W=1e-6 L=1e-6
mpway18_cell84 ML18 gate_way18_cell84 GND ML18 p1 W=2.4e-6 L=1e-6
mnway18_cell85 ML18 gate_way18_cell85 GND GND n1 W=1e-6 L=1e-6
mpway18_cell85 ML18 gate_way18_cell85 GND ML18 p1 W=2.4e-6 L=1e-6
mnway18_cell86 ML18 gate_way18_cell86 GND GND n1 W=1e-6 L=1e-6
mpway18_cell86 ML18 gate_way18_cell86 GND ML18 p1 W=2.4e-6 L=1e-6
mnway18_cell87 ML18 gate_way18_cell87 GND GND n1 W=1e-6 L=1e-6
mpway18_cell87 ML18 gate_way18_cell87 GND ML18 p1 W=2.4e-6 L=1e-6
mnway18_cell88 ML18 gate_way18_cell88 GND GND n1 W=1e-6 L=1e-6
mpway18_cell88 ML18 gate_way18_cell88 GND ML18 p1 W=2.4e-6 L=1e-6
mnway18_cell89 ML18 gate_way18_cell89 GND GND n1 W=1e-6 L=1e-6
mpway18_cell89 ML18 gate_way18_cell89 GND ML18 p1 W=2.4e-6 L=1e-6
mnway18_cell90 ML18 gate_way18_cell90 GND GND n1 W=1e-6 L=1e-6
mpway18_cell90 ML18 gate_way18_cell90 GND ML18 p1 W=2.4e-6 L=1e-6
mnway18_cell91 ML18 gate_way18_cell91 GND GND n1 W=1e-6 L=1e-6
mpway18_cell91 ML18 gate_way18_cell91 GND ML18 p1 W=2.4e-6 L=1e-6
mnway18_cell92 ML18 gate_way18_cell92 GND GND n1 W=1e-6 L=1e-6
mpway18_cell92 ML18 gate_way18_cell92 GND ML18 p1 W=2.4e-6 L=1e-6
mnway18_cell93 ML18 gate_way18_cell93 GND GND n1 W=1e-6 L=1e-6
mpway18_cell93 ML18 gate_way18_cell93 GND ML18 p1 W=2.4e-6 L=1e-6
mnway18_cell94 ML18 gate_way18_cell94 GND GND n1 W=1e-6 L=1e-6
mpway18_cell94 ML18 gate_way18_cell94 GND ML18 p1 W=2.4e-6 L=1e-6
mnway18_cell95 ML18 gate_way18_cell95 GND GND n1 W=1e-6 L=1e-6
mpway18_cell95 ML18 gate_way18_cell95 GND ML18 p1 W=2.4e-6 L=1e-6
mnway18_cell96 ML18 gate_way18_cell96 GND GND n1 W=1e-6 L=1e-6
mpway18_cell96 ML18 gate_way18_cell96 GND ML18 p1 W=2.4e-6 L=1e-6
mnway18_cell97 ML18 gate_way18_cell97 GND GND n1 W=1e-6 L=1e-6
mpway18_cell97 ML18 gate_way18_cell97 GND ML18 p1 W=2.4e-6 L=1e-6
mnway18_cell98 ML18 gate_way18_cell98 GND GND n1 W=1e-6 L=1e-6
mpway18_cell98 ML18 gate_way18_cell98 GND ML18 p1 W=2.4e-6 L=1e-6
mnway18_cell99 ML18 gate_way18_cell99 GND GND n1 W=1e-6 L=1e-6
mpway18_cell99 ML18 gate_way18_cell99 GND ML18 p1 W=2.4e-6 L=1e-6
mnway19_cell0 ML19 gate_way19_cell0 GND GND n1 W=1e-6 L=1e-6
mpway19_cell0 ML19 gate_way19_cell0 GND ML19 p1 W=2.4e-6 L=1e-6
mnway19_cell1 ML19 gate_way19_cell1 GND GND n1 W=1e-6 L=1e-6
mpway19_cell1 ML19 gate_way19_cell1 GND ML19 p1 W=2.4e-6 L=1e-6
mnway19_cell2 ML19 gate_way19_cell2 GND GND n1 W=1e-6 L=1e-6
mpway19_cell2 ML19 gate_way19_cell2 GND ML19 p1 W=2.4e-6 L=1e-6
mnway19_cell3 ML19 gate_way19_cell3 GND GND n1 W=1e-6 L=1e-6
mpway19_cell3 ML19 gate_way19_cell3 GND ML19 p1 W=2.4e-6 L=1e-6
mnway19_cell4 ML19 gate_way19_cell4 GND GND n1 W=1e-6 L=1e-6
mpway19_cell4 ML19 gate_way19_cell4 GND ML19 p1 W=2.4e-6 L=1e-6
mnway19_cell5 ML19 gate_way19_cell5 GND GND n1 W=1e-6 L=1e-6
mpway19_cell5 ML19 gate_way19_cell5 GND ML19 p1 W=2.4e-6 L=1e-6
mnway19_cell6 ML19 gate_way19_cell6 GND GND n1 W=1e-6 L=1e-6
mpway19_cell6 ML19 gate_way19_cell6 GND ML19 p1 W=2.4e-6 L=1e-6
mnway19_cell7 ML19 gate_way19_cell7 GND GND n1 W=1e-6 L=1e-6
mpway19_cell7 ML19 gate_way19_cell7 GND ML19 p1 W=2.4e-6 L=1e-6
mnway19_cell8 ML19 gate_way19_cell8 GND GND n1 W=1e-6 L=1e-6
mpway19_cell8 ML19 gate_way19_cell8 GND ML19 p1 W=2.4e-6 L=1e-6
mnway19_cell9 ML19 gate_way19_cell9 GND GND n1 W=1e-6 L=1e-6
mpway19_cell9 ML19 gate_way19_cell9 GND ML19 p1 W=2.4e-6 L=1e-6
mnway19_cell10 ML19 gate_way19_cell10 GND GND n1 W=1e-6 L=1e-6
mpway19_cell10 ML19 gate_way19_cell10 GND ML19 p1 W=2.4e-6 L=1e-6
mnway19_cell11 ML19 gate_way19_cell11 GND GND n1 W=1e-6 L=1e-6
mpway19_cell11 ML19 gate_way19_cell11 GND ML19 p1 W=2.4e-6 L=1e-6
mnway19_cell12 ML19 gate_way19_cell12 GND GND n1 W=1e-6 L=1e-6
mpway19_cell12 ML19 gate_way19_cell12 GND ML19 p1 W=2.4e-6 L=1e-6
mnway19_cell13 ML19 gate_way19_cell13 GND GND n1 W=1e-6 L=1e-6
mpway19_cell13 ML19 gate_way19_cell13 GND ML19 p1 W=2.4e-6 L=1e-6
mnway19_cell14 ML19 gate_way19_cell14 GND GND n1 W=1e-6 L=1e-6
mpway19_cell14 ML19 gate_way19_cell14 GND ML19 p1 W=2.4e-6 L=1e-6
mnway19_cell15 ML19 gate_way19_cell15 GND GND n1 W=1e-6 L=1e-6
mpway19_cell15 ML19 gate_way19_cell15 GND ML19 p1 W=2.4e-6 L=1e-6
mnway19_cell16 ML19 gate_way19_cell16 GND GND n1 W=1e-6 L=1e-6
mpway19_cell16 ML19 gate_way19_cell16 GND ML19 p1 W=2.4e-6 L=1e-6
mnway19_cell17 ML19 gate_way19_cell17 GND GND n1 W=1e-6 L=1e-6
mpway19_cell17 ML19 gate_way19_cell17 GND ML19 p1 W=2.4e-6 L=1e-6
mnway19_cell18 ML19 gate_way19_cell18 GND GND n1 W=1e-6 L=1e-6
mpway19_cell18 ML19 gate_way19_cell18 GND ML19 p1 W=2.4e-6 L=1e-6
mnway19_cell19 ML19 gate_way19_cell19 GND GND n1 W=1e-6 L=1e-6
mpway19_cell19 ML19 gate_way19_cell19 GND ML19 p1 W=2.4e-6 L=1e-6
mnway19_cell20 ML19 gate_way19_cell20 GND GND n1 W=1e-6 L=1e-6
mpway19_cell20 ML19 gate_way19_cell20 GND ML19 p1 W=2.4e-6 L=1e-6
mnway19_cell21 ML19 gate_way19_cell21 GND GND n1 W=1e-6 L=1e-6
mpway19_cell21 ML19 gate_way19_cell21 GND ML19 p1 W=2.4e-6 L=1e-6
mnway19_cell22 ML19 gate_way19_cell22 GND GND n1 W=1e-6 L=1e-6
mpway19_cell22 ML19 gate_way19_cell22 GND ML19 p1 W=2.4e-6 L=1e-6
mnway19_cell23 ML19 gate_way19_cell23 GND GND n1 W=1e-6 L=1e-6
mpway19_cell23 ML19 gate_way19_cell23 GND ML19 p1 W=2.4e-6 L=1e-6
mnway19_cell24 ML19 gate_way19_cell24 GND GND n1 W=1e-6 L=1e-6
mpway19_cell24 ML19 gate_way19_cell24 GND ML19 p1 W=2.4e-6 L=1e-6
mnway19_cell25 ML19 gate_way19_cell25 GND GND n1 W=1e-6 L=1e-6
mpway19_cell25 ML19 gate_way19_cell25 GND ML19 p1 W=2.4e-6 L=1e-6
mnway19_cell26 ML19 gate_way19_cell26 GND GND n1 W=1e-6 L=1e-6
mpway19_cell26 ML19 gate_way19_cell26 GND ML19 p1 W=2.4e-6 L=1e-6
mnway19_cell27 ML19 gate_way19_cell27 GND GND n1 W=1e-6 L=1e-6
mpway19_cell27 ML19 gate_way19_cell27 GND ML19 p1 W=2.4e-6 L=1e-6
mnway19_cell28 ML19 gate_way19_cell28 GND GND n1 W=1e-6 L=1e-6
mpway19_cell28 ML19 gate_way19_cell28 GND ML19 p1 W=2.4e-6 L=1e-6
mnway19_cell29 ML19 gate_way19_cell29 GND GND n1 W=1e-6 L=1e-6
mpway19_cell29 ML19 gate_way19_cell29 GND ML19 p1 W=2.4e-6 L=1e-6
mnway19_cell30 ML19 gate_way19_cell30 GND GND n1 W=1e-6 L=1e-6
mpway19_cell30 ML19 gate_way19_cell30 GND ML19 p1 W=2.4e-6 L=1e-6
mnway19_cell31 ML19 gate_way19_cell31 GND GND n1 W=1e-6 L=1e-6
mpway19_cell31 ML19 gate_way19_cell31 GND ML19 p1 W=2.4e-6 L=1e-6
mnway19_cell32 ML19 gate_way19_cell32 GND GND n1 W=1e-6 L=1e-6
mpway19_cell32 ML19 gate_way19_cell32 GND ML19 p1 W=2.4e-6 L=1e-6
mnway19_cell33 ML19 gate_way19_cell33 GND GND n1 W=1e-6 L=1e-6
mpway19_cell33 ML19 gate_way19_cell33 GND ML19 p1 W=2.4e-6 L=1e-6
mnway19_cell34 ML19 gate_way19_cell34 GND GND n1 W=1e-6 L=1e-6
mpway19_cell34 ML19 gate_way19_cell34 GND ML19 p1 W=2.4e-6 L=1e-6
mnway19_cell35 ML19 gate_way19_cell35 GND GND n1 W=1e-6 L=1e-6
mpway19_cell35 ML19 gate_way19_cell35 GND ML19 p1 W=2.4e-6 L=1e-6
mnway19_cell36 ML19 gate_way19_cell36 GND GND n1 W=1e-6 L=1e-6
mpway19_cell36 ML19 gate_way19_cell36 GND ML19 p1 W=2.4e-6 L=1e-6
mnway19_cell37 ML19 gate_way19_cell37 GND GND n1 W=1e-6 L=1e-6
mpway19_cell37 ML19 gate_way19_cell37 GND ML19 p1 W=2.4e-6 L=1e-6
mnway19_cell38 ML19 gate_way19_cell38 GND GND n1 W=1e-6 L=1e-6
mpway19_cell38 ML19 gate_way19_cell38 GND ML19 p1 W=2.4e-6 L=1e-6
mnway19_cell39 ML19 gate_way19_cell39 GND GND n1 W=1e-6 L=1e-6
mpway19_cell39 ML19 gate_way19_cell39 GND ML19 p1 W=2.4e-6 L=1e-6
mnway19_cell40 ML19 gate_way19_cell40 GND GND n1 W=1e-6 L=1e-6
mpway19_cell40 ML19 gate_way19_cell40 GND ML19 p1 W=2.4e-6 L=1e-6
mnway19_cell41 ML19 gate_way19_cell41 GND GND n1 W=1e-6 L=1e-6
mpway19_cell41 ML19 gate_way19_cell41 GND ML19 p1 W=2.4e-6 L=1e-6
mnway19_cell42 ML19 gate_way19_cell42 GND GND n1 W=1e-6 L=1e-6
mpway19_cell42 ML19 gate_way19_cell42 GND ML19 p1 W=2.4e-6 L=1e-6
mnway19_cell43 ML19 gate_way19_cell43 GND GND n1 W=1e-6 L=1e-6
mpway19_cell43 ML19 gate_way19_cell43 GND ML19 p1 W=2.4e-6 L=1e-6
mnway19_cell44 ML19 gate_way19_cell44 GND GND n1 W=1e-6 L=1e-6
mpway19_cell44 ML19 gate_way19_cell44 GND ML19 p1 W=2.4e-6 L=1e-6
mnway19_cell45 ML19 gate_way19_cell45 GND GND n1 W=1e-6 L=1e-6
mpway19_cell45 ML19 gate_way19_cell45 GND ML19 p1 W=2.4e-6 L=1e-6
mnway19_cell46 ML19 gate_way19_cell46 GND GND n1 W=1e-6 L=1e-6
mpway19_cell46 ML19 gate_way19_cell46 GND ML19 p1 W=2.4e-6 L=1e-6
mnway19_cell47 ML19 gate_way19_cell47 GND GND n1 W=1e-6 L=1e-6
mpway19_cell47 ML19 gate_way19_cell47 GND ML19 p1 W=2.4e-6 L=1e-6
mnway19_cell48 ML19 gate_way19_cell48 GND GND n1 W=1e-6 L=1e-6
mpway19_cell48 ML19 gate_way19_cell48 GND ML19 p1 W=2.4e-6 L=1e-6
mnway19_cell49 ML19 gate_way19_cell49 GND GND n1 W=1e-6 L=1e-6
mpway19_cell49 ML19 gate_way19_cell49 GND ML19 p1 W=2.4e-6 L=1e-6
mnway19_cell50 ML19 gate_way19_cell50 GND GND n1 W=1e-6 L=1e-6
mpway19_cell50 ML19 gate_way19_cell50 GND ML19 p1 W=2.4e-6 L=1e-6
mnway19_cell51 ML19 gate_way19_cell51 GND GND n1 W=1e-6 L=1e-6
mpway19_cell51 ML19 gate_way19_cell51 GND ML19 p1 W=2.4e-6 L=1e-6
mnway19_cell52 ML19 gate_way19_cell52 GND GND n1 W=1e-6 L=1e-6
mpway19_cell52 ML19 gate_way19_cell52 GND ML19 p1 W=2.4e-6 L=1e-6
mnway19_cell53 ML19 gate_way19_cell53 GND GND n1 W=1e-6 L=1e-6
mpway19_cell53 ML19 gate_way19_cell53 GND ML19 p1 W=2.4e-6 L=1e-6
mnway19_cell54 ML19 gate_way19_cell54 GND GND n1 W=1e-6 L=1e-6
mpway19_cell54 ML19 gate_way19_cell54 GND ML19 p1 W=2.4e-6 L=1e-6
mnway19_cell55 ML19 gate_way19_cell55 GND GND n1 W=1e-6 L=1e-6
mpway19_cell55 ML19 gate_way19_cell55 GND ML19 p1 W=2.4e-6 L=1e-6
mnway19_cell56 ML19 gate_way19_cell56 GND GND n1 W=1e-6 L=1e-6
mpway19_cell56 ML19 gate_way19_cell56 GND ML19 p1 W=2.4e-6 L=1e-6
mnway19_cell57 ML19 gate_way19_cell57 GND GND n1 W=1e-6 L=1e-6
mpway19_cell57 ML19 gate_way19_cell57 GND ML19 p1 W=2.4e-6 L=1e-6
mnway19_cell58 ML19 gate_way19_cell58 GND GND n1 W=1e-6 L=1e-6
mpway19_cell58 ML19 gate_way19_cell58 GND ML19 p1 W=2.4e-6 L=1e-6
mnway19_cell59 ML19 gate_way19_cell59 GND GND n1 W=1e-6 L=1e-6
mpway19_cell59 ML19 gate_way19_cell59 GND ML19 p1 W=2.4e-6 L=1e-6
mnway19_cell60 ML19 gate_way19_cell60 GND GND n1 W=1e-6 L=1e-6
mpway19_cell60 ML19 gate_way19_cell60 GND ML19 p1 W=2.4e-6 L=1e-6
mnway19_cell61 ML19 gate_way19_cell61 GND GND n1 W=1e-6 L=1e-6
mpway19_cell61 ML19 gate_way19_cell61 GND ML19 p1 W=2.4e-6 L=1e-6
mnway19_cell62 ML19 gate_way19_cell62 GND GND n1 W=1e-6 L=1e-6
mpway19_cell62 ML19 gate_way19_cell62 GND ML19 p1 W=2.4e-6 L=1e-6
mnway19_cell63 ML19 gate_way19_cell63 GND GND n1 W=1e-6 L=1e-6
mpway19_cell63 ML19 gate_way19_cell63 GND ML19 p1 W=2.4e-6 L=1e-6
mnway19_cell64 ML19 gate_way19_cell64 GND GND n1 W=1e-6 L=1e-6
mpway19_cell64 ML19 gate_way19_cell64 GND ML19 p1 W=2.4e-6 L=1e-6
mnway19_cell65 ML19 gate_way19_cell65 GND GND n1 W=1e-6 L=1e-6
mpway19_cell65 ML19 gate_way19_cell65 GND ML19 p1 W=2.4e-6 L=1e-6
mnway19_cell66 ML19 gate_way19_cell66 GND GND n1 W=1e-6 L=1e-6
mpway19_cell66 ML19 gate_way19_cell66 GND ML19 p1 W=2.4e-6 L=1e-6
mnway19_cell67 ML19 gate_way19_cell67 GND GND n1 W=1e-6 L=1e-6
mpway19_cell67 ML19 gate_way19_cell67 GND ML19 p1 W=2.4e-6 L=1e-6
mnway19_cell68 ML19 gate_way19_cell68 GND GND n1 W=1e-6 L=1e-6
mpway19_cell68 ML19 gate_way19_cell68 GND ML19 p1 W=2.4e-6 L=1e-6
mnway19_cell69 ML19 gate_way19_cell69 GND GND n1 W=1e-6 L=1e-6
mpway19_cell69 ML19 gate_way19_cell69 GND ML19 p1 W=2.4e-6 L=1e-6
mnway19_cell70 ML19 gate_way19_cell70 GND GND n1 W=1e-6 L=1e-6
mpway19_cell70 ML19 gate_way19_cell70 GND ML19 p1 W=2.4e-6 L=1e-6
mnway19_cell71 ML19 gate_way19_cell71 GND GND n1 W=1e-6 L=1e-6
mpway19_cell71 ML19 gate_way19_cell71 GND ML19 p1 W=2.4e-6 L=1e-6
mnway19_cell72 ML19 gate_way19_cell72 GND GND n1 W=1e-6 L=1e-6
mpway19_cell72 ML19 gate_way19_cell72 GND ML19 p1 W=2.4e-6 L=1e-6
mnway19_cell73 ML19 gate_way19_cell73 GND GND n1 W=1e-6 L=1e-6
mpway19_cell73 ML19 gate_way19_cell73 GND ML19 p1 W=2.4e-6 L=1e-6
mnway19_cell74 ML19 gate_way19_cell74 GND GND n1 W=1e-6 L=1e-6
mpway19_cell74 ML19 gate_way19_cell74 GND ML19 p1 W=2.4e-6 L=1e-6
mnway19_cell75 ML19 gate_way19_cell75 GND GND n1 W=1e-6 L=1e-6
mpway19_cell75 ML19 gate_way19_cell75 GND ML19 p1 W=2.4e-6 L=1e-6
mnway19_cell76 ML19 gate_way19_cell76 GND GND n1 W=1e-6 L=1e-6
mpway19_cell76 ML19 gate_way19_cell76 GND ML19 p1 W=2.4e-6 L=1e-6
mnway19_cell77 ML19 gate_way19_cell77 GND GND n1 W=1e-6 L=1e-6
mpway19_cell77 ML19 gate_way19_cell77 GND ML19 p1 W=2.4e-6 L=1e-6
mnway19_cell78 ML19 gate_way19_cell78 GND GND n1 W=1e-6 L=1e-6
mpway19_cell78 ML19 gate_way19_cell78 GND ML19 p1 W=2.4e-6 L=1e-6
mnway19_cell79 ML19 gate_way19_cell79 GND GND n1 W=1e-6 L=1e-6
mpway19_cell79 ML19 gate_way19_cell79 GND ML19 p1 W=2.4e-6 L=1e-6
mnway19_cell80 ML19 gate_way19_cell80 GND GND n1 W=1e-6 L=1e-6
mpway19_cell80 ML19 gate_way19_cell80 GND ML19 p1 W=2.4e-6 L=1e-6
mnway19_cell81 ML19 gate_way19_cell81 GND GND n1 W=1e-6 L=1e-6
mpway19_cell81 ML19 gate_way19_cell81 GND ML19 p1 W=2.4e-6 L=1e-6
mnway19_cell82 ML19 gate_way19_cell82 GND GND n1 W=1e-6 L=1e-6
mpway19_cell82 ML19 gate_way19_cell82 GND ML19 p1 W=2.4e-6 L=1e-6
mnway19_cell83 ML19 gate_way19_cell83 GND GND n1 W=1e-6 L=1e-6
mpway19_cell83 ML19 gate_way19_cell83 GND ML19 p1 W=2.4e-6 L=1e-6
mnway19_cell84 ML19 gate_way19_cell84 GND GND n1 W=1e-6 L=1e-6
mpway19_cell84 ML19 gate_way19_cell84 GND ML19 p1 W=2.4e-6 L=1e-6
mnway19_cell85 ML19 gate_way19_cell85 GND GND n1 W=1e-6 L=1e-6
mpway19_cell85 ML19 gate_way19_cell85 GND ML19 p1 W=2.4e-6 L=1e-6
mnway19_cell86 ML19 gate_way19_cell86 GND GND n1 W=1e-6 L=1e-6
mpway19_cell86 ML19 gate_way19_cell86 GND ML19 p1 W=2.4e-6 L=1e-6
mnway19_cell87 ML19 gate_way19_cell87 GND GND n1 W=1e-6 L=1e-6
mpway19_cell87 ML19 gate_way19_cell87 GND ML19 p1 W=2.4e-6 L=1e-6
mnway19_cell88 ML19 gate_way19_cell88 GND GND n1 W=1e-6 L=1e-6
mpway19_cell88 ML19 gate_way19_cell88 GND ML19 p1 W=2.4e-6 L=1e-6
mnway19_cell89 ML19 gate_way19_cell89 GND GND n1 W=1e-6 L=1e-6
mpway19_cell89 ML19 gate_way19_cell89 GND ML19 p1 W=2.4e-6 L=1e-6
mnway19_cell90 ML19 gate_way19_cell90 GND GND n1 W=1e-6 L=1e-6
mpway19_cell90 ML19 gate_way19_cell90 GND ML19 p1 W=2.4e-6 L=1e-6
mnway19_cell91 ML19 gate_way19_cell91 GND GND n1 W=1e-6 L=1e-6
mpway19_cell91 ML19 gate_way19_cell91 GND ML19 p1 W=2.4e-6 L=1e-6
mnway19_cell92 ML19 gate_way19_cell92 GND GND n1 W=1e-6 L=1e-6
mpway19_cell92 ML19 gate_way19_cell92 GND ML19 p1 W=2.4e-6 L=1e-6
mnway19_cell93 ML19 gate_way19_cell93 GND GND n1 W=1e-6 L=1e-6
mpway19_cell93 ML19 gate_way19_cell93 GND ML19 p1 W=2.4e-6 L=1e-6
mnway19_cell94 ML19 gate_way19_cell94 GND GND n1 W=1e-6 L=1e-6
mpway19_cell94 ML19 gate_way19_cell94 GND ML19 p1 W=2.4e-6 L=1e-6
mnway19_cell95 ML19 gate_way19_cell95 GND GND n1 W=1e-6 L=1e-6
mpway19_cell95 ML19 gate_way19_cell95 GND ML19 p1 W=2.4e-6 L=1e-6
mnway19_cell96 ML19 gate_way19_cell96 GND GND n1 W=1e-6 L=1e-6
mpway19_cell96 ML19 gate_way19_cell96 GND ML19 p1 W=2.4e-6 L=1e-6
mnway19_cell97 ML19 gate_way19_cell97 GND GND n1 W=1e-6 L=1e-6
mpway19_cell97 ML19 gate_way19_cell97 GND ML19 p1 W=2.4e-6 L=1e-6
mnway19_cell98 ML19 gate_way19_cell98 GND GND n1 W=1e-6 L=1e-6
mpway19_cell98 ML19 gate_way19_cell98 GND ML19 p1 W=2.4e-6 L=1e-6
mnway19_cell99 ML19 gate_way19_cell99 GND GND n1 W=1e-6 L=1e-6
mpway19_cell99 ML19 gate_way19_cell99 GND ML19 p1 W=2.4e-6 L=1e-6
mnway20_cell0 ML20 gate_way20_cell0 GND GND n1 W=1e-6 L=1e-6
mpway20_cell0 ML20 gate_way20_cell0 GND ML20 p1 W=2.4e-6 L=1e-6
mnway20_cell1 ML20 gate_way20_cell1 GND GND n1 W=1e-6 L=1e-6
mpway20_cell1 ML20 gate_way20_cell1 GND ML20 p1 W=2.4e-6 L=1e-6
mnway20_cell2 ML20 gate_way20_cell2 GND GND n1 W=1e-6 L=1e-6
mpway20_cell2 ML20 gate_way20_cell2 GND ML20 p1 W=2.4e-6 L=1e-6
mnway20_cell3 ML20 gate_way20_cell3 GND GND n1 W=1e-6 L=1e-6
mpway20_cell3 ML20 gate_way20_cell3 GND ML20 p1 W=2.4e-6 L=1e-6
mnway20_cell4 ML20 gate_way20_cell4 GND GND n1 W=1e-6 L=1e-6
mpway20_cell4 ML20 gate_way20_cell4 GND ML20 p1 W=2.4e-6 L=1e-6
mnway20_cell5 ML20 gate_way20_cell5 GND GND n1 W=1e-6 L=1e-6
mpway20_cell5 ML20 gate_way20_cell5 GND ML20 p1 W=2.4e-6 L=1e-6
mnway20_cell6 ML20 gate_way20_cell6 GND GND n1 W=1e-6 L=1e-6
mpway20_cell6 ML20 gate_way20_cell6 GND ML20 p1 W=2.4e-6 L=1e-6
mnway20_cell7 ML20 gate_way20_cell7 GND GND n1 W=1e-6 L=1e-6
mpway20_cell7 ML20 gate_way20_cell7 GND ML20 p1 W=2.4e-6 L=1e-6
mnway20_cell8 ML20 gate_way20_cell8 GND GND n1 W=1e-6 L=1e-6
mpway20_cell8 ML20 gate_way20_cell8 GND ML20 p1 W=2.4e-6 L=1e-6
mnway20_cell9 ML20 gate_way20_cell9 GND GND n1 W=1e-6 L=1e-6
mpway20_cell9 ML20 gate_way20_cell9 GND ML20 p1 W=2.4e-6 L=1e-6
mnway20_cell10 ML20 gate_way20_cell10 GND GND n1 W=1e-6 L=1e-6
mpway20_cell10 ML20 gate_way20_cell10 GND ML20 p1 W=2.4e-6 L=1e-6
mnway20_cell11 ML20 gate_way20_cell11 GND GND n1 W=1e-6 L=1e-6
mpway20_cell11 ML20 gate_way20_cell11 GND ML20 p1 W=2.4e-6 L=1e-6
mnway20_cell12 ML20 gate_way20_cell12 GND GND n1 W=1e-6 L=1e-6
mpway20_cell12 ML20 gate_way20_cell12 GND ML20 p1 W=2.4e-6 L=1e-6
mnway20_cell13 ML20 gate_way20_cell13 GND GND n1 W=1e-6 L=1e-6
mpway20_cell13 ML20 gate_way20_cell13 GND ML20 p1 W=2.4e-6 L=1e-6
mnway20_cell14 ML20 gate_way20_cell14 GND GND n1 W=1e-6 L=1e-6
mpway20_cell14 ML20 gate_way20_cell14 GND ML20 p1 W=2.4e-6 L=1e-6
mnway20_cell15 ML20 gate_way20_cell15 GND GND n1 W=1e-6 L=1e-6
mpway20_cell15 ML20 gate_way20_cell15 GND ML20 p1 W=2.4e-6 L=1e-6
mnway20_cell16 ML20 gate_way20_cell16 GND GND n1 W=1e-6 L=1e-6
mpway20_cell16 ML20 gate_way20_cell16 GND ML20 p1 W=2.4e-6 L=1e-6
mnway20_cell17 ML20 gate_way20_cell17 GND GND n1 W=1e-6 L=1e-6
mpway20_cell17 ML20 gate_way20_cell17 GND ML20 p1 W=2.4e-6 L=1e-6
mnway20_cell18 ML20 gate_way20_cell18 GND GND n1 W=1e-6 L=1e-6
mpway20_cell18 ML20 gate_way20_cell18 GND ML20 p1 W=2.4e-6 L=1e-6
mnway20_cell19 ML20 gate_way20_cell19 GND GND n1 W=1e-6 L=1e-6
mpway20_cell19 ML20 gate_way20_cell19 GND ML20 p1 W=2.4e-6 L=1e-6
mnway20_cell20 ML20 gate_way20_cell20 GND GND n1 W=1e-6 L=1e-6
mpway20_cell20 ML20 gate_way20_cell20 GND ML20 p1 W=2.4e-6 L=1e-6
mnway20_cell21 ML20 gate_way20_cell21 GND GND n1 W=1e-6 L=1e-6
mpway20_cell21 ML20 gate_way20_cell21 GND ML20 p1 W=2.4e-6 L=1e-6
mnway20_cell22 ML20 gate_way20_cell22 GND GND n1 W=1e-6 L=1e-6
mpway20_cell22 ML20 gate_way20_cell22 GND ML20 p1 W=2.4e-6 L=1e-6
mnway20_cell23 ML20 gate_way20_cell23 GND GND n1 W=1e-6 L=1e-6
mpway20_cell23 ML20 gate_way20_cell23 GND ML20 p1 W=2.4e-6 L=1e-6
mnway20_cell24 ML20 gate_way20_cell24 GND GND n1 W=1e-6 L=1e-6
mpway20_cell24 ML20 gate_way20_cell24 GND ML20 p1 W=2.4e-6 L=1e-6
mnway20_cell25 ML20 gate_way20_cell25 GND GND n1 W=1e-6 L=1e-6
mpway20_cell25 ML20 gate_way20_cell25 GND ML20 p1 W=2.4e-6 L=1e-6
mnway20_cell26 ML20 gate_way20_cell26 GND GND n1 W=1e-6 L=1e-6
mpway20_cell26 ML20 gate_way20_cell26 GND ML20 p1 W=2.4e-6 L=1e-6
mnway20_cell27 ML20 gate_way20_cell27 GND GND n1 W=1e-6 L=1e-6
mpway20_cell27 ML20 gate_way20_cell27 GND ML20 p1 W=2.4e-6 L=1e-6
mnway20_cell28 ML20 gate_way20_cell28 GND GND n1 W=1e-6 L=1e-6
mpway20_cell28 ML20 gate_way20_cell28 GND ML20 p1 W=2.4e-6 L=1e-6
mnway20_cell29 ML20 gate_way20_cell29 GND GND n1 W=1e-6 L=1e-6
mpway20_cell29 ML20 gate_way20_cell29 GND ML20 p1 W=2.4e-6 L=1e-6
mnway20_cell30 ML20 gate_way20_cell30 GND GND n1 W=1e-6 L=1e-6
mpway20_cell30 ML20 gate_way20_cell30 GND ML20 p1 W=2.4e-6 L=1e-6
mnway20_cell31 ML20 gate_way20_cell31 GND GND n1 W=1e-6 L=1e-6
mpway20_cell31 ML20 gate_way20_cell31 GND ML20 p1 W=2.4e-6 L=1e-6
mnway20_cell32 ML20 gate_way20_cell32 GND GND n1 W=1e-6 L=1e-6
mpway20_cell32 ML20 gate_way20_cell32 GND ML20 p1 W=2.4e-6 L=1e-6
mnway20_cell33 ML20 gate_way20_cell33 GND GND n1 W=1e-6 L=1e-6
mpway20_cell33 ML20 gate_way20_cell33 GND ML20 p1 W=2.4e-6 L=1e-6
mnway20_cell34 ML20 gate_way20_cell34 GND GND n1 W=1e-6 L=1e-6
mpway20_cell34 ML20 gate_way20_cell34 GND ML20 p1 W=2.4e-6 L=1e-6
mnway20_cell35 ML20 gate_way20_cell35 GND GND n1 W=1e-6 L=1e-6
mpway20_cell35 ML20 gate_way20_cell35 GND ML20 p1 W=2.4e-6 L=1e-6
mnway20_cell36 ML20 gate_way20_cell36 GND GND n1 W=1e-6 L=1e-6
mpway20_cell36 ML20 gate_way20_cell36 GND ML20 p1 W=2.4e-6 L=1e-6
mnway20_cell37 ML20 gate_way20_cell37 GND GND n1 W=1e-6 L=1e-6
mpway20_cell37 ML20 gate_way20_cell37 GND ML20 p1 W=2.4e-6 L=1e-6
mnway20_cell38 ML20 gate_way20_cell38 GND GND n1 W=1e-6 L=1e-6
mpway20_cell38 ML20 gate_way20_cell38 GND ML20 p1 W=2.4e-6 L=1e-6
mnway20_cell39 ML20 gate_way20_cell39 GND GND n1 W=1e-6 L=1e-6
mpway20_cell39 ML20 gate_way20_cell39 GND ML20 p1 W=2.4e-6 L=1e-6
mnway20_cell40 ML20 gate_way20_cell40 GND GND n1 W=1e-6 L=1e-6
mpway20_cell40 ML20 gate_way20_cell40 GND ML20 p1 W=2.4e-6 L=1e-6
mnway20_cell41 ML20 gate_way20_cell41 GND GND n1 W=1e-6 L=1e-6
mpway20_cell41 ML20 gate_way20_cell41 GND ML20 p1 W=2.4e-6 L=1e-6
mnway20_cell42 ML20 gate_way20_cell42 GND GND n1 W=1e-6 L=1e-6
mpway20_cell42 ML20 gate_way20_cell42 GND ML20 p1 W=2.4e-6 L=1e-6
mnway20_cell43 ML20 gate_way20_cell43 GND GND n1 W=1e-6 L=1e-6
mpway20_cell43 ML20 gate_way20_cell43 GND ML20 p1 W=2.4e-6 L=1e-6
mnway20_cell44 ML20 gate_way20_cell44 GND GND n1 W=1e-6 L=1e-6
mpway20_cell44 ML20 gate_way20_cell44 GND ML20 p1 W=2.4e-6 L=1e-6
mnway20_cell45 ML20 gate_way20_cell45 GND GND n1 W=1e-6 L=1e-6
mpway20_cell45 ML20 gate_way20_cell45 GND ML20 p1 W=2.4e-6 L=1e-6
mnway20_cell46 ML20 gate_way20_cell46 GND GND n1 W=1e-6 L=1e-6
mpway20_cell46 ML20 gate_way20_cell46 GND ML20 p1 W=2.4e-6 L=1e-6
mnway20_cell47 ML20 gate_way20_cell47 GND GND n1 W=1e-6 L=1e-6
mpway20_cell47 ML20 gate_way20_cell47 GND ML20 p1 W=2.4e-6 L=1e-6
mnway20_cell48 ML20 gate_way20_cell48 GND GND n1 W=1e-6 L=1e-6
mpway20_cell48 ML20 gate_way20_cell48 GND ML20 p1 W=2.4e-6 L=1e-6
mnway20_cell49 ML20 gate_way20_cell49 GND GND n1 W=1e-6 L=1e-6
mpway20_cell49 ML20 gate_way20_cell49 GND ML20 p1 W=2.4e-6 L=1e-6
mnway20_cell50 ML20 gate_way20_cell50 GND GND n1 W=1e-6 L=1e-6
mpway20_cell50 ML20 gate_way20_cell50 GND ML20 p1 W=2.4e-6 L=1e-6
mnway20_cell51 ML20 gate_way20_cell51 GND GND n1 W=1e-6 L=1e-6
mpway20_cell51 ML20 gate_way20_cell51 GND ML20 p1 W=2.4e-6 L=1e-6
mnway20_cell52 ML20 gate_way20_cell52 GND GND n1 W=1e-6 L=1e-6
mpway20_cell52 ML20 gate_way20_cell52 GND ML20 p1 W=2.4e-6 L=1e-6
mnway20_cell53 ML20 gate_way20_cell53 GND GND n1 W=1e-6 L=1e-6
mpway20_cell53 ML20 gate_way20_cell53 GND ML20 p1 W=2.4e-6 L=1e-6
mnway20_cell54 ML20 gate_way20_cell54 GND GND n1 W=1e-6 L=1e-6
mpway20_cell54 ML20 gate_way20_cell54 GND ML20 p1 W=2.4e-6 L=1e-6
mnway20_cell55 ML20 gate_way20_cell55 GND GND n1 W=1e-6 L=1e-6
mpway20_cell55 ML20 gate_way20_cell55 GND ML20 p1 W=2.4e-6 L=1e-6
mnway20_cell56 ML20 gate_way20_cell56 GND GND n1 W=1e-6 L=1e-6
mpway20_cell56 ML20 gate_way20_cell56 GND ML20 p1 W=2.4e-6 L=1e-6
mnway20_cell57 ML20 gate_way20_cell57 GND GND n1 W=1e-6 L=1e-6
mpway20_cell57 ML20 gate_way20_cell57 GND ML20 p1 W=2.4e-6 L=1e-6
mnway20_cell58 ML20 gate_way20_cell58 GND GND n1 W=1e-6 L=1e-6
mpway20_cell58 ML20 gate_way20_cell58 GND ML20 p1 W=2.4e-6 L=1e-6
mnway20_cell59 ML20 gate_way20_cell59 GND GND n1 W=1e-6 L=1e-6
mpway20_cell59 ML20 gate_way20_cell59 GND ML20 p1 W=2.4e-6 L=1e-6
mnway20_cell60 ML20 gate_way20_cell60 GND GND n1 W=1e-6 L=1e-6
mpway20_cell60 ML20 gate_way20_cell60 GND ML20 p1 W=2.4e-6 L=1e-6
mnway20_cell61 ML20 gate_way20_cell61 GND GND n1 W=1e-6 L=1e-6
mpway20_cell61 ML20 gate_way20_cell61 GND ML20 p1 W=2.4e-6 L=1e-6
mnway20_cell62 ML20 gate_way20_cell62 GND GND n1 W=1e-6 L=1e-6
mpway20_cell62 ML20 gate_way20_cell62 GND ML20 p1 W=2.4e-6 L=1e-6
mnway20_cell63 ML20 gate_way20_cell63 GND GND n1 W=1e-6 L=1e-6
mpway20_cell63 ML20 gate_way20_cell63 GND ML20 p1 W=2.4e-6 L=1e-6
mnway20_cell64 ML20 gate_way20_cell64 GND GND n1 W=1e-6 L=1e-6
mpway20_cell64 ML20 gate_way20_cell64 GND ML20 p1 W=2.4e-6 L=1e-6
mnway20_cell65 ML20 gate_way20_cell65 GND GND n1 W=1e-6 L=1e-6
mpway20_cell65 ML20 gate_way20_cell65 GND ML20 p1 W=2.4e-6 L=1e-6
mnway20_cell66 ML20 gate_way20_cell66 GND GND n1 W=1e-6 L=1e-6
mpway20_cell66 ML20 gate_way20_cell66 GND ML20 p1 W=2.4e-6 L=1e-6
mnway20_cell67 ML20 gate_way20_cell67 GND GND n1 W=1e-6 L=1e-6
mpway20_cell67 ML20 gate_way20_cell67 GND ML20 p1 W=2.4e-6 L=1e-6
mnway20_cell68 ML20 gate_way20_cell68 GND GND n1 W=1e-6 L=1e-6
mpway20_cell68 ML20 gate_way20_cell68 GND ML20 p1 W=2.4e-6 L=1e-6
mnway20_cell69 ML20 gate_way20_cell69 GND GND n1 W=1e-6 L=1e-6
mpway20_cell69 ML20 gate_way20_cell69 GND ML20 p1 W=2.4e-6 L=1e-6
mnway20_cell70 ML20 gate_way20_cell70 GND GND n1 W=1e-6 L=1e-6
mpway20_cell70 ML20 gate_way20_cell70 GND ML20 p1 W=2.4e-6 L=1e-6
mnway20_cell71 ML20 gate_way20_cell71 GND GND n1 W=1e-6 L=1e-6
mpway20_cell71 ML20 gate_way20_cell71 GND ML20 p1 W=2.4e-6 L=1e-6
mnway20_cell72 ML20 gate_way20_cell72 GND GND n1 W=1e-6 L=1e-6
mpway20_cell72 ML20 gate_way20_cell72 GND ML20 p1 W=2.4e-6 L=1e-6
mnway20_cell73 ML20 gate_way20_cell73 GND GND n1 W=1e-6 L=1e-6
mpway20_cell73 ML20 gate_way20_cell73 GND ML20 p1 W=2.4e-6 L=1e-6
mnway20_cell74 ML20 gate_way20_cell74 GND GND n1 W=1e-6 L=1e-6
mpway20_cell74 ML20 gate_way20_cell74 GND ML20 p1 W=2.4e-6 L=1e-6
mnway20_cell75 ML20 gate_way20_cell75 GND GND n1 W=1e-6 L=1e-6
mpway20_cell75 ML20 gate_way20_cell75 GND ML20 p1 W=2.4e-6 L=1e-6
mnway20_cell76 ML20 gate_way20_cell76 GND GND n1 W=1e-6 L=1e-6
mpway20_cell76 ML20 gate_way20_cell76 GND ML20 p1 W=2.4e-6 L=1e-6
mnway20_cell77 ML20 gate_way20_cell77 GND GND n1 W=1e-6 L=1e-6
mpway20_cell77 ML20 gate_way20_cell77 GND ML20 p1 W=2.4e-6 L=1e-6
mnway20_cell78 ML20 gate_way20_cell78 GND GND n1 W=1e-6 L=1e-6
mpway20_cell78 ML20 gate_way20_cell78 GND ML20 p1 W=2.4e-6 L=1e-6
mnway20_cell79 ML20 gate_way20_cell79 GND GND n1 W=1e-6 L=1e-6
mpway20_cell79 ML20 gate_way20_cell79 GND ML20 p1 W=2.4e-6 L=1e-6
mnway20_cell80 ML20 gate_way20_cell80 GND GND n1 W=1e-6 L=1e-6
mpway20_cell80 ML20 gate_way20_cell80 GND ML20 p1 W=2.4e-6 L=1e-6
mnway20_cell81 ML20 gate_way20_cell81 GND GND n1 W=1e-6 L=1e-6
mpway20_cell81 ML20 gate_way20_cell81 GND ML20 p1 W=2.4e-6 L=1e-6
mnway20_cell82 ML20 gate_way20_cell82 GND GND n1 W=1e-6 L=1e-6
mpway20_cell82 ML20 gate_way20_cell82 GND ML20 p1 W=2.4e-6 L=1e-6
mnway20_cell83 ML20 gate_way20_cell83 GND GND n1 W=1e-6 L=1e-6
mpway20_cell83 ML20 gate_way20_cell83 GND ML20 p1 W=2.4e-6 L=1e-6
mnway20_cell84 ML20 gate_way20_cell84 GND GND n1 W=1e-6 L=1e-6
mpway20_cell84 ML20 gate_way20_cell84 GND ML20 p1 W=2.4e-6 L=1e-6
mnway20_cell85 ML20 gate_way20_cell85 GND GND n1 W=1e-6 L=1e-6
mpway20_cell85 ML20 gate_way20_cell85 GND ML20 p1 W=2.4e-6 L=1e-6
mnway20_cell86 ML20 gate_way20_cell86 GND GND n1 W=1e-6 L=1e-6
mpway20_cell86 ML20 gate_way20_cell86 GND ML20 p1 W=2.4e-6 L=1e-6
mnway20_cell87 ML20 gate_way20_cell87 GND GND n1 W=1e-6 L=1e-6
mpway20_cell87 ML20 gate_way20_cell87 GND ML20 p1 W=2.4e-6 L=1e-6
mnway20_cell88 ML20 gate_way20_cell88 GND GND n1 W=1e-6 L=1e-6
mpway20_cell88 ML20 gate_way20_cell88 GND ML20 p1 W=2.4e-6 L=1e-6
mnway20_cell89 ML20 gate_way20_cell89 GND GND n1 W=1e-6 L=1e-6
mpway20_cell89 ML20 gate_way20_cell89 GND ML20 p1 W=2.4e-6 L=1e-6
mnway20_cell90 ML20 gate_way20_cell90 GND GND n1 W=1e-6 L=1e-6
mpway20_cell90 ML20 gate_way20_cell90 GND ML20 p1 W=2.4e-6 L=1e-6
mnway20_cell91 ML20 gate_way20_cell91 GND GND n1 W=1e-6 L=1e-6
mpway20_cell91 ML20 gate_way20_cell91 GND ML20 p1 W=2.4e-6 L=1e-6
mnway20_cell92 ML20 gate_way20_cell92 GND GND n1 W=1e-6 L=1e-6
mpway20_cell92 ML20 gate_way20_cell92 GND ML20 p1 W=2.4e-6 L=1e-6
mnway20_cell93 ML20 gate_way20_cell93 GND GND n1 W=1e-6 L=1e-6
mpway20_cell93 ML20 gate_way20_cell93 GND ML20 p1 W=2.4e-6 L=1e-6
mnway20_cell94 ML20 gate_way20_cell94 GND GND n1 W=1e-6 L=1e-6
mpway20_cell94 ML20 gate_way20_cell94 GND ML20 p1 W=2.4e-6 L=1e-6
mnway20_cell95 ML20 gate_way20_cell95 GND GND n1 W=1e-6 L=1e-6
mpway20_cell95 ML20 gate_way20_cell95 GND ML20 p1 W=2.4e-6 L=1e-6
mnway20_cell96 ML20 gate_way20_cell96 GND GND n1 W=1e-6 L=1e-6
mpway20_cell96 ML20 gate_way20_cell96 GND ML20 p1 W=2.4e-6 L=1e-6
mnway20_cell97 ML20 gate_way20_cell97 GND GND n1 W=1e-6 L=1e-6
mpway20_cell97 ML20 gate_way20_cell97 GND ML20 p1 W=2.4e-6 L=1e-6
mnway20_cell98 ML20 gate_way20_cell98 GND GND n1 W=1e-6 L=1e-6
mpway20_cell98 ML20 gate_way20_cell98 GND ML20 p1 W=2.4e-6 L=1e-6
mnway20_cell99 ML20 gate_way20_cell99 GND GND n1 W=1e-6 L=1e-6
mpway20_cell99 ML20 gate_way20_cell99 GND ML20 p1 W=2.4e-6 L=1e-6
mnway21_cell0 ML21 gate_way21_cell0 GND GND n1 W=1e-6 L=1e-6
mpway21_cell0 ML21 gate_way21_cell0 GND ML21 p1 W=2.4e-6 L=1e-6
mnway21_cell1 ML21 gate_way21_cell1 GND GND n1 W=1e-6 L=1e-6
mpway21_cell1 ML21 gate_way21_cell1 GND ML21 p1 W=2.4e-6 L=1e-6
mnway21_cell2 ML21 gate_way21_cell2 GND GND n1 W=1e-6 L=1e-6
mpway21_cell2 ML21 gate_way21_cell2 GND ML21 p1 W=2.4e-6 L=1e-6
mnway21_cell3 ML21 gate_way21_cell3 GND GND n1 W=1e-6 L=1e-6
mpway21_cell3 ML21 gate_way21_cell3 GND ML21 p1 W=2.4e-6 L=1e-6
mnway21_cell4 ML21 gate_way21_cell4 GND GND n1 W=1e-6 L=1e-6
mpway21_cell4 ML21 gate_way21_cell4 GND ML21 p1 W=2.4e-6 L=1e-6
mnway21_cell5 ML21 gate_way21_cell5 GND GND n1 W=1e-6 L=1e-6
mpway21_cell5 ML21 gate_way21_cell5 GND ML21 p1 W=2.4e-6 L=1e-6
mnway21_cell6 ML21 gate_way21_cell6 GND GND n1 W=1e-6 L=1e-6
mpway21_cell6 ML21 gate_way21_cell6 GND ML21 p1 W=2.4e-6 L=1e-6
mnway21_cell7 ML21 gate_way21_cell7 GND GND n1 W=1e-6 L=1e-6
mpway21_cell7 ML21 gate_way21_cell7 GND ML21 p1 W=2.4e-6 L=1e-6
mnway21_cell8 ML21 gate_way21_cell8 GND GND n1 W=1e-6 L=1e-6
mpway21_cell8 ML21 gate_way21_cell8 GND ML21 p1 W=2.4e-6 L=1e-6
mnway21_cell9 ML21 gate_way21_cell9 GND GND n1 W=1e-6 L=1e-6
mpway21_cell9 ML21 gate_way21_cell9 GND ML21 p1 W=2.4e-6 L=1e-6
mnway21_cell10 ML21 gate_way21_cell10 GND GND n1 W=1e-6 L=1e-6
mpway21_cell10 ML21 gate_way21_cell10 GND ML21 p1 W=2.4e-6 L=1e-6
mnway21_cell11 ML21 gate_way21_cell11 GND GND n1 W=1e-6 L=1e-6
mpway21_cell11 ML21 gate_way21_cell11 GND ML21 p1 W=2.4e-6 L=1e-6
mnway21_cell12 ML21 gate_way21_cell12 GND GND n1 W=1e-6 L=1e-6
mpway21_cell12 ML21 gate_way21_cell12 GND ML21 p1 W=2.4e-6 L=1e-6
mnway21_cell13 ML21 gate_way21_cell13 GND GND n1 W=1e-6 L=1e-6
mpway21_cell13 ML21 gate_way21_cell13 GND ML21 p1 W=2.4e-6 L=1e-6
mnway21_cell14 ML21 gate_way21_cell14 GND GND n1 W=1e-6 L=1e-6
mpway21_cell14 ML21 gate_way21_cell14 GND ML21 p1 W=2.4e-6 L=1e-6
mnway21_cell15 ML21 gate_way21_cell15 GND GND n1 W=1e-6 L=1e-6
mpway21_cell15 ML21 gate_way21_cell15 GND ML21 p1 W=2.4e-6 L=1e-6
mnway21_cell16 ML21 gate_way21_cell16 GND GND n1 W=1e-6 L=1e-6
mpway21_cell16 ML21 gate_way21_cell16 GND ML21 p1 W=2.4e-6 L=1e-6
mnway21_cell17 ML21 gate_way21_cell17 GND GND n1 W=1e-6 L=1e-6
mpway21_cell17 ML21 gate_way21_cell17 GND ML21 p1 W=2.4e-6 L=1e-6
mnway21_cell18 ML21 gate_way21_cell18 GND GND n1 W=1e-6 L=1e-6
mpway21_cell18 ML21 gate_way21_cell18 GND ML21 p1 W=2.4e-6 L=1e-6
mnway21_cell19 ML21 gate_way21_cell19 GND GND n1 W=1e-6 L=1e-6
mpway21_cell19 ML21 gate_way21_cell19 GND ML21 p1 W=2.4e-6 L=1e-6
mnway21_cell20 ML21 gate_way21_cell20 GND GND n1 W=1e-6 L=1e-6
mpway21_cell20 ML21 gate_way21_cell20 GND ML21 p1 W=2.4e-6 L=1e-6
mnway21_cell21 ML21 gate_way21_cell21 GND GND n1 W=1e-6 L=1e-6
mpway21_cell21 ML21 gate_way21_cell21 GND ML21 p1 W=2.4e-6 L=1e-6
mnway21_cell22 ML21 gate_way21_cell22 GND GND n1 W=1e-6 L=1e-6
mpway21_cell22 ML21 gate_way21_cell22 GND ML21 p1 W=2.4e-6 L=1e-6
mnway21_cell23 ML21 gate_way21_cell23 GND GND n1 W=1e-6 L=1e-6
mpway21_cell23 ML21 gate_way21_cell23 GND ML21 p1 W=2.4e-6 L=1e-6
mnway21_cell24 ML21 gate_way21_cell24 GND GND n1 W=1e-6 L=1e-6
mpway21_cell24 ML21 gate_way21_cell24 GND ML21 p1 W=2.4e-6 L=1e-6
mnway21_cell25 ML21 gate_way21_cell25 GND GND n1 W=1e-6 L=1e-6
mpway21_cell25 ML21 gate_way21_cell25 GND ML21 p1 W=2.4e-6 L=1e-6
mnway21_cell26 ML21 gate_way21_cell26 GND GND n1 W=1e-6 L=1e-6
mpway21_cell26 ML21 gate_way21_cell26 GND ML21 p1 W=2.4e-6 L=1e-6
mnway21_cell27 ML21 gate_way21_cell27 GND GND n1 W=1e-6 L=1e-6
mpway21_cell27 ML21 gate_way21_cell27 GND ML21 p1 W=2.4e-6 L=1e-6
mnway21_cell28 ML21 gate_way21_cell28 GND GND n1 W=1e-6 L=1e-6
mpway21_cell28 ML21 gate_way21_cell28 GND ML21 p1 W=2.4e-6 L=1e-6
mnway21_cell29 ML21 gate_way21_cell29 GND GND n1 W=1e-6 L=1e-6
mpway21_cell29 ML21 gate_way21_cell29 GND ML21 p1 W=2.4e-6 L=1e-6
mnway21_cell30 ML21 gate_way21_cell30 GND GND n1 W=1e-6 L=1e-6
mpway21_cell30 ML21 gate_way21_cell30 GND ML21 p1 W=2.4e-6 L=1e-6
mnway21_cell31 ML21 gate_way21_cell31 GND GND n1 W=1e-6 L=1e-6
mpway21_cell31 ML21 gate_way21_cell31 GND ML21 p1 W=2.4e-6 L=1e-6
mnway21_cell32 ML21 gate_way21_cell32 GND GND n1 W=1e-6 L=1e-6
mpway21_cell32 ML21 gate_way21_cell32 GND ML21 p1 W=2.4e-6 L=1e-6
mnway21_cell33 ML21 gate_way21_cell33 GND GND n1 W=1e-6 L=1e-6
mpway21_cell33 ML21 gate_way21_cell33 GND ML21 p1 W=2.4e-6 L=1e-6
mnway21_cell34 ML21 gate_way21_cell34 GND GND n1 W=1e-6 L=1e-6
mpway21_cell34 ML21 gate_way21_cell34 GND ML21 p1 W=2.4e-6 L=1e-6
mnway21_cell35 ML21 gate_way21_cell35 GND GND n1 W=1e-6 L=1e-6
mpway21_cell35 ML21 gate_way21_cell35 GND ML21 p1 W=2.4e-6 L=1e-6
mnway21_cell36 ML21 gate_way21_cell36 GND GND n1 W=1e-6 L=1e-6
mpway21_cell36 ML21 gate_way21_cell36 GND ML21 p1 W=2.4e-6 L=1e-6
mnway21_cell37 ML21 gate_way21_cell37 GND GND n1 W=1e-6 L=1e-6
mpway21_cell37 ML21 gate_way21_cell37 GND ML21 p1 W=2.4e-6 L=1e-6
mnway21_cell38 ML21 gate_way21_cell38 GND GND n1 W=1e-6 L=1e-6
mpway21_cell38 ML21 gate_way21_cell38 GND ML21 p1 W=2.4e-6 L=1e-6
mnway21_cell39 ML21 gate_way21_cell39 GND GND n1 W=1e-6 L=1e-6
mpway21_cell39 ML21 gate_way21_cell39 GND ML21 p1 W=2.4e-6 L=1e-6
mnway21_cell40 ML21 gate_way21_cell40 GND GND n1 W=1e-6 L=1e-6
mpway21_cell40 ML21 gate_way21_cell40 GND ML21 p1 W=2.4e-6 L=1e-6
mnway21_cell41 ML21 gate_way21_cell41 GND GND n1 W=1e-6 L=1e-6
mpway21_cell41 ML21 gate_way21_cell41 GND ML21 p1 W=2.4e-6 L=1e-6
mnway21_cell42 ML21 gate_way21_cell42 GND GND n1 W=1e-6 L=1e-6
mpway21_cell42 ML21 gate_way21_cell42 GND ML21 p1 W=2.4e-6 L=1e-6
mnway21_cell43 ML21 gate_way21_cell43 GND GND n1 W=1e-6 L=1e-6
mpway21_cell43 ML21 gate_way21_cell43 GND ML21 p1 W=2.4e-6 L=1e-6
mnway21_cell44 ML21 gate_way21_cell44 GND GND n1 W=1e-6 L=1e-6
mpway21_cell44 ML21 gate_way21_cell44 GND ML21 p1 W=2.4e-6 L=1e-6
mnway21_cell45 ML21 gate_way21_cell45 GND GND n1 W=1e-6 L=1e-6
mpway21_cell45 ML21 gate_way21_cell45 GND ML21 p1 W=2.4e-6 L=1e-6
mnway21_cell46 ML21 gate_way21_cell46 GND GND n1 W=1e-6 L=1e-6
mpway21_cell46 ML21 gate_way21_cell46 GND ML21 p1 W=2.4e-6 L=1e-6
mnway21_cell47 ML21 gate_way21_cell47 GND GND n1 W=1e-6 L=1e-6
mpway21_cell47 ML21 gate_way21_cell47 GND ML21 p1 W=2.4e-6 L=1e-6
mnway21_cell48 ML21 gate_way21_cell48 GND GND n1 W=1e-6 L=1e-6
mpway21_cell48 ML21 gate_way21_cell48 GND ML21 p1 W=2.4e-6 L=1e-6
mnway21_cell49 ML21 gate_way21_cell49 GND GND n1 W=1e-6 L=1e-6
mpway21_cell49 ML21 gate_way21_cell49 GND ML21 p1 W=2.4e-6 L=1e-6
mnway21_cell50 ML21 gate_way21_cell50 GND GND n1 W=1e-6 L=1e-6
mpway21_cell50 ML21 gate_way21_cell50 GND ML21 p1 W=2.4e-6 L=1e-6
mnway21_cell51 ML21 gate_way21_cell51 GND GND n1 W=1e-6 L=1e-6
mpway21_cell51 ML21 gate_way21_cell51 GND ML21 p1 W=2.4e-6 L=1e-6
mnway21_cell52 ML21 gate_way21_cell52 GND GND n1 W=1e-6 L=1e-6
mpway21_cell52 ML21 gate_way21_cell52 GND ML21 p1 W=2.4e-6 L=1e-6
mnway21_cell53 ML21 gate_way21_cell53 GND GND n1 W=1e-6 L=1e-6
mpway21_cell53 ML21 gate_way21_cell53 GND ML21 p1 W=2.4e-6 L=1e-6
mnway21_cell54 ML21 gate_way21_cell54 GND GND n1 W=1e-6 L=1e-6
mpway21_cell54 ML21 gate_way21_cell54 GND ML21 p1 W=2.4e-6 L=1e-6
mnway21_cell55 ML21 gate_way21_cell55 GND GND n1 W=1e-6 L=1e-6
mpway21_cell55 ML21 gate_way21_cell55 GND ML21 p1 W=2.4e-6 L=1e-6
mnway21_cell56 ML21 gate_way21_cell56 GND GND n1 W=1e-6 L=1e-6
mpway21_cell56 ML21 gate_way21_cell56 GND ML21 p1 W=2.4e-6 L=1e-6
mnway21_cell57 ML21 gate_way21_cell57 GND GND n1 W=1e-6 L=1e-6
mpway21_cell57 ML21 gate_way21_cell57 GND ML21 p1 W=2.4e-6 L=1e-6
mnway21_cell58 ML21 gate_way21_cell58 GND GND n1 W=1e-6 L=1e-6
mpway21_cell58 ML21 gate_way21_cell58 GND ML21 p1 W=2.4e-6 L=1e-6
mnway21_cell59 ML21 gate_way21_cell59 GND GND n1 W=1e-6 L=1e-6
mpway21_cell59 ML21 gate_way21_cell59 GND ML21 p1 W=2.4e-6 L=1e-6
mnway21_cell60 ML21 gate_way21_cell60 GND GND n1 W=1e-6 L=1e-6
mpway21_cell60 ML21 gate_way21_cell60 GND ML21 p1 W=2.4e-6 L=1e-6
mnway21_cell61 ML21 gate_way21_cell61 GND GND n1 W=1e-6 L=1e-6
mpway21_cell61 ML21 gate_way21_cell61 GND ML21 p1 W=2.4e-6 L=1e-6
mnway21_cell62 ML21 gate_way21_cell62 GND GND n1 W=1e-6 L=1e-6
mpway21_cell62 ML21 gate_way21_cell62 GND ML21 p1 W=2.4e-6 L=1e-6
mnway21_cell63 ML21 gate_way21_cell63 GND GND n1 W=1e-6 L=1e-6
mpway21_cell63 ML21 gate_way21_cell63 GND ML21 p1 W=2.4e-6 L=1e-6
mnway21_cell64 ML21 gate_way21_cell64 GND GND n1 W=1e-6 L=1e-6
mpway21_cell64 ML21 gate_way21_cell64 GND ML21 p1 W=2.4e-6 L=1e-6
mnway21_cell65 ML21 gate_way21_cell65 GND GND n1 W=1e-6 L=1e-6
mpway21_cell65 ML21 gate_way21_cell65 GND ML21 p1 W=2.4e-6 L=1e-6
mnway21_cell66 ML21 gate_way21_cell66 GND GND n1 W=1e-6 L=1e-6
mpway21_cell66 ML21 gate_way21_cell66 GND ML21 p1 W=2.4e-6 L=1e-6
mnway21_cell67 ML21 gate_way21_cell67 GND GND n1 W=1e-6 L=1e-6
mpway21_cell67 ML21 gate_way21_cell67 GND ML21 p1 W=2.4e-6 L=1e-6
mnway21_cell68 ML21 gate_way21_cell68 GND GND n1 W=1e-6 L=1e-6
mpway21_cell68 ML21 gate_way21_cell68 GND ML21 p1 W=2.4e-6 L=1e-6
mnway21_cell69 ML21 gate_way21_cell69 GND GND n1 W=1e-6 L=1e-6
mpway21_cell69 ML21 gate_way21_cell69 GND ML21 p1 W=2.4e-6 L=1e-6
mnway21_cell70 ML21 gate_way21_cell70 GND GND n1 W=1e-6 L=1e-6
mpway21_cell70 ML21 gate_way21_cell70 GND ML21 p1 W=2.4e-6 L=1e-6
mnway21_cell71 ML21 gate_way21_cell71 GND GND n1 W=1e-6 L=1e-6
mpway21_cell71 ML21 gate_way21_cell71 GND ML21 p1 W=2.4e-6 L=1e-6
mnway21_cell72 ML21 gate_way21_cell72 GND GND n1 W=1e-6 L=1e-6
mpway21_cell72 ML21 gate_way21_cell72 GND ML21 p1 W=2.4e-6 L=1e-6
mnway21_cell73 ML21 gate_way21_cell73 GND GND n1 W=1e-6 L=1e-6
mpway21_cell73 ML21 gate_way21_cell73 GND ML21 p1 W=2.4e-6 L=1e-6
mnway21_cell74 ML21 gate_way21_cell74 GND GND n1 W=1e-6 L=1e-6
mpway21_cell74 ML21 gate_way21_cell74 GND ML21 p1 W=2.4e-6 L=1e-6
mnway21_cell75 ML21 gate_way21_cell75 GND GND n1 W=1e-6 L=1e-6
mpway21_cell75 ML21 gate_way21_cell75 GND ML21 p1 W=2.4e-6 L=1e-6
mnway21_cell76 ML21 gate_way21_cell76 GND GND n1 W=1e-6 L=1e-6
mpway21_cell76 ML21 gate_way21_cell76 GND ML21 p1 W=2.4e-6 L=1e-6
mnway21_cell77 ML21 gate_way21_cell77 GND GND n1 W=1e-6 L=1e-6
mpway21_cell77 ML21 gate_way21_cell77 GND ML21 p1 W=2.4e-6 L=1e-6
mnway21_cell78 ML21 gate_way21_cell78 GND GND n1 W=1e-6 L=1e-6
mpway21_cell78 ML21 gate_way21_cell78 GND ML21 p1 W=2.4e-6 L=1e-6
mnway21_cell79 ML21 gate_way21_cell79 GND GND n1 W=1e-6 L=1e-6
mpway21_cell79 ML21 gate_way21_cell79 GND ML21 p1 W=2.4e-6 L=1e-6
mnway21_cell80 ML21 gate_way21_cell80 GND GND n1 W=1e-6 L=1e-6
mpway21_cell80 ML21 gate_way21_cell80 GND ML21 p1 W=2.4e-6 L=1e-6
mnway21_cell81 ML21 gate_way21_cell81 GND GND n1 W=1e-6 L=1e-6
mpway21_cell81 ML21 gate_way21_cell81 GND ML21 p1 W=2.4e-6 L=1e-6
mnway21_cell82 ML21 gate_way21_cell82 GND GND n1 W=1e-6 L=1e-6
mpway21_cell82 ML21 gate_way21_cell82 GND ML21 p1 W=2.4e-6 L=1e-6
mnway21_cell83 ML21 gate_way21_cell83 GND GND n1 W=1e-6 L=1e-6
mpway21_cell83 ML21 gate_way21_cell83 GND ML21 p1 W=2.4e-6 L=1e-6
mnway21_cell84 ML21 gate_way21_cell84 GND GND n1 W=1e-6 L=1e-6
mpway21_cell84 ML21 gate_way21_cell84 GND ML21 p1 W=2.4e-6 L=1e-6
mnway21_cell85 ML21 gate_way21_cell85 GND GND n1 W=1e-6 L=1e-6
mpway21_cell85 ML21 gate_way21_cell85 GND ML21 p1 W=2.4e-6 L=1e-6
mnway21_cell86 ML21 gate_way21_cell86 GND GND n1 W=1e-6 L=1e-6
mpway21_cell86 ML21 gate_way21_cell86 GND ML21 p1 W=2.4e-6 L=1e-6
mnway21_cell87 ML21 gate_way21_cell87 GND GND n1 W=1e-6 L=1e-6
mpway21_cell87 ML21 gate_way21_cell87 GND ML21 p1 W=2.4e-6 L=1e-6
mnway21_cell88 ML21 gate_way21_cell88 GND GND n1 W=1e-6 L=1e-6
mpway21_cell88 ML21 gate_way21_cell88 GND ML21 p1 W=2.4e-6 L=1e-6
mnway21_cell89 ML21 gate_way21_cell89 GND GND n1 W=1e-6 L=1e-6
mpway21_cell89 ML21 gate_way21_cell89 GND ML21 p1 W=2.4e-6 L=1e-6
mnway21_cell90 ML21 gate_way21_cell90 GND GND n1 W=1e-6 L=1e-6
mpway21_cell90 ML21 gate_way21_cell90 GND ML21 p1 W=2.4e-6 L=1e-6
mnway21_cell91 ML21 gate_way21_cell91 GND GND n1 W=1e-6 L=1e-6
mpway21_cell91 ML21 gate_way21_cell91 GND ML21 p1 W=2.4e-6 L=1e-6
mnway21_cell92 ML21 gate_way21_cell92 GND GND n1 W=1e-6 L=1e-6
mpway21_cell92 ML21 gate_way21_cell92 GND ML21 p1 W=2.4e-6 L=1e-6
mnway21_cell93 ML21 gate_way21_cell93 GND GND n1 W=1e-6 L=1e-6
mpway21_cell93 ML21 gate_way21_cell93 GND ML21 p1 W=2.4e-6 L=1e-6
mnway21_cell94 ML21 gate_way21_cell94 GND GND n1 W=1e-6 L=1e-6
mpway21_cell94 ML21 gate_way21_cell94 GND ML21 p1 W=2.4e-6 L=1e-6
mnway21_cell95 ML21 gate_way21_cell95 GND GND n1 W=1e-6 L=1e-6
mpway21_cell95 ML21 gate_way21_cell95 GND ML21 p1 W=2.4e-6 L=1e-6
mnway21_cell96 ML21 gate_way21_cell96 GND GND n1 W=1e-6 L=1e-6
mpway21_cell96 ML21 gate_way21_cell96 GND ML21 p1 W=2.4e-6 L=1e-6
mnway21_cell97 ML21 gate_way21_cell97 GND GND n1 W=1e-6 L=1e-6
mpway21_cell97 ML21 gate_way21_cell97 GND ML21 p1 W=2.4e-6 L=1e-6
mnway21_cell98 ML21 gate_way21_cell98 GND GND n1 W=1e-6 L=1e-6
mpway21_cell98 ML21 gate_way21_cell98 GND ML21 p1 W=2.4e-6 L=1e-6
mnway21_cell99 ML21 gate_way21_cell99 GND GND n1 W=1e-6 L=1e-6
mpway21_cell99 ML21 gate_way21_cell99 GND ML21 p1 W=2.4e-6 L=1e-6
mnway22_cell0 ML22 gate_way22_cell0 GND GND n1 W=1e-6 L=1e-6
mpway22_cell0 ML22 gate_way22_cell0 GND ML22 p1 W=2.4e-6 L=1e-6
mnway22_cell1 ML22 gate_way22_cell1 GND GND n1 W=1e-6 L=1e-6
mpway22_cell1 ML22 gate_way22_cell1 GND ML22 p1 W=2.4e-6 L=1e-6
mnway22_cell2 ML22 gate_way22_cell2 GND GND n1 W=1e-6 L=1e-6
mpway22_cell2 ML22 gate_way22_cell2 GND ML22 p1 W=2.4e-6 L=1e-6
mnway22_cell3 ML22 gate_way22_cell3 GND GND n1 W=1e-6 L=1e-6
mpway22_cell3 ML22 gate_way22_cell3 GND ML22 p1 W=2.4e-6 L=1e-6
mnway22_cell4 ML22 gate_way22_cell4 GND GND n1 W=1e-6 L=1e-6
mpway22_cell4 ML22 gate_way22_cell4 GND ML22 p1 W=2.4e-6 L=1e-6
mnway22_cell5 ML22 gate_way22_cell5 GND GND n1 W=1e-6 L=1e-6
mpway22_cell5 ML22 gate_way22_cell5 GND ML22 p1 W=2.4e-6 L=1e-6
mnway22_cell6 ML22 gate_way22_cell6 GND GND n1 W=1e-6 L=1e-6
mpway22_cell6 ML22 gate_way22_cell6 GND ML22 p1 W=2.4e-6 L=1e-6
mnway22_cell7 ML22 gate_way22_cell7 GND GND n1 W=1e-6 L=1e-6
mpway22_cell7 ML22 gate_way22_cell7 GND ML22 p1 W=2.4e-6 L=1e-6
mnway22_cell8 ML22 gate_way22_cell8 GND GND n1 W=1e-6 L=1e-6
mpway22_cell8 ML22 gate_way22_cell8 GND ML22 p1 W=2.4e-6 L=1e-6
mnway22_cell9 ML22 gate_way22_cell9 GND GND n1 W=1e-6 L=1e-6
mpway22_cell9 ML22 gate_way22_cell9 GND ML22 p1 W=2.4e-6 L=1e-6
mnway22_cell10 ML22 gate_way22_cell10 GND GND n1 W=1e-6 L=1e-6
mpway22_cell10 ML22 gate_way22_cell10 GND ML22 p1 W=2.4e-6 L=1e-6
mnway22_cell11 ML22 gate_way22_cell11 GND GND n1 W=1e-6 L=1e-6
mpway22_cell11 ML22 gate_way22_cell11 GND ML22 p1 W=2.4e-6 L=1e-6
mnway22_cell12 ML22 gate_way22_cell12 GND GND n1 W=1e-6 L=1e-6
mpway22_cell12 ML22 gate_way22_cell12 GND ML22 p1 W=2.4e-6 L=1e-6
mnway22_cell13 ML22 gate_way22_cell13 GND GND n1 W=1e-6 L=1e-6
mpway22_cell13 ML22 gate_way22_cell13 GND ML22 p1 W=2.4e-6 L=1e-6
mnway22_cell14 ML22 gate_way22_cell14 GND GND n1 W=1e-6 L=1e-6
mpway22_cell14 ML22 gate_way22_cell14 GND ML22 p1 W=2.4e-6 L=1e-6
mnway22_cell15 ML22 gate_way22_cell15 GND GND n1 W=1e-6 L=1e-6
mpway22_cell15 ML22 gate_way22_cell15 GND ML22 p1 W=2.4e-6 L=1e-6
mnway22_cell16 ML22 gate_way22_cell16 GND GND n1 W=1e-6 L=1e-6
mpway22_cell16 ML22 gate_way22_cell16 GND ML22 p1 W=2.4e-6 L=1e-6
mnway22_cell17 ML22 gate_way22_cell17 GND GND n1 W=1e-6 L=1e-6
mpway22_cell17 ML22 gate_way22_cell17 GND ML22 p1 W=2.4e-6 L=1e-6
mnway22_cell18 ML22 gate_way22_cell18 GND GND n1 W=1e-6 L=1e-6
mpway22_cell18 ML22 gate_way22_cell18 GND ML22 p1 W=2.4e-6 L=1e-6
mnway22_cell19 ML22 gate_way22_cell19 GND GND n1 W=1e-6 L=1e-6
mpway22_cell19 ML22 gate_way22_cell19 GND ML22 p1 W=2.4e-6 L=1e-6
mnway22_cell20 ML22 gate_way22_cell20 GND GND n1 W=1e-6 L=1e-6
mpway22_cell20 ML22 gate_way22_cell20 GND ML22 p1 W=2.4e-6 L=1e-6
mnway22_cell21 ML22 gate_way22_cell21 GND GND n1 W=1e-6 L=1e-6
mpway22_cell21 ML22 gate_way22_cell21 GND ML22 p1 W=2.4e-6 L=1e-6
mnway22_cell22 ML22 gate_way22_cell22 GND GND n1 W=1e-6 L=1e-6
mpway22_cell22 ML22 gate_way22_cell22 GND ML22 p1 W=2.4e-6 L=1e-6
mnway22_cell23 ML22 gate_way22_cell23 GND GND n1 W=1e-6 L=1e-6
mpway22_cell23 ML22 gate_way22_cell23 GND ML22 p1 W=2.4e-6 L=1e-6
mnway22_cell24 ML22 gate_way22_cell24 GND GND n1 W=1e-6 L=1e-6
mpway22_cell24 ML22 gate_way22_cell24 GND ML22 p1 W=2.4e-6 L=1e-6
mnway22_cell25 ML22 gate_way22_cell25 GND GND n1 W=1e-6 L=1e-6
mpway22_cell25 ML22 gate_way22_cell25 GND ML22 p1 W=2.4e-6 L=1e-6
mnway22_cell26 ML22 gate_way22_cell26 GND GND n1 W=1e-6 L=1e-6
mpway22_cell26 ML22 gate_way22_cell26 GND ML22 p1 W=2.4e-6 L=1e-6
mnway22_cell27 ML22 gate_way22_cell27 GND GND n1 W=1e-6 L=1e-6
mpway22_cell27 ML22 gate_way22_cell27 GND ML22 p1 W=2.4e-6 L=1e-6
mnway22_cell28 ML22 gate_way22_cell28 GND GND n1 W=1e-6 L=1e-6
mpway22_cell28 ML22 gate_way22_cell28 GND ML22 p1 W=2.4e-6 L=1e-6
mnway22_cell29 ML22 gate_way22_cell29 GND GND n1 W=1e-6 L=1e-6
mpway22_cell29 ML22 gate_way22_cell29 GND ML22 p1 W=2.4e-6 L=1e-6
mnway22_cell30 ML22 gate_way22_cell30 GND GND n1 W=1e-6 L=1e-6
mpway22_cell30 ML22 gate_way22_cell30 GND ML22 p1 W=2.4e-6 L=1e-6
mnway22_cell31 ML22 gate_way22_cell31 GND GND n1 W=1e-6 L=1e-6
mpway22_cell31 ML22 gate_way22_cell31 GND ML22 p1 W=2.4e-6 L=1e-6
mnway22_cell32 ML22 gate_way22_cell32 GND GND n1 W=1e-6 L=1e-6
mpway22_cell32 ML22 gate_way22_cell32 GND ML22 p1 W=2.4e-6 L=1e-6
mnway22_cell33 ML22 gate_way22_cell33 GND GND n1 W=1e-6 L=1e-6
mpway22_cell33 ML22 gate_way22_cell33 GND ML22 p1 W=2.4e-6 L=1e-6
mnway22_cell34 ML22 gate_way22_cell34 GND GND n1 W=1e-6 L=1e-6
mpway22_cell34 ML22 gate_way22_cell34 GND ML22 p1 W=2.4e-6 L=1e-6
mnway22_cell35 ML22 gate_way22_cell35 GND GND n1 W=1e-6 L=1e-6
mpway22_cell35 ML22 gate_way22_cell35 GND ML22 p1 W=2.4e-6 L=1e-6
mnway22_cell36 ML22 gate_way22_cell36 GND GND n1 W=1e-6 L=1e-6
mpway22_cell36 ML22 gate_way22_cell36 GND ML22 p1 W=2.4e-6 L=1e-6
mnway22_cell37 ML22 gate_way22_cell37 GND GND n1 W=1e-6 L=1e-6
mpway22_cell37 ML22 gate_way22_cell37 GND ML22 p1 W=2.4e-6 L=1e-6
mnway22_cell38 ML22 gate_way22_cell38 GND GND n1 W=1e-6 L=1e-6
mpway22_cell38 ML22 gate_way22_cell38 GND ML22 p1 W=2.4e-6 L=1e-6
mnway22_cell39 ML22 gate_way22_cell39 GND GND n1 W=1e-6 L=1e-6
mpway22_cell39 ML22 gate_way22_cell39 GND ML22 p1 W=2.4e-6 L=1e-6
mnway22_cell40 ML22 gate_way22_cell40 GND GND n1 W=1e-6 L=1e-6
mpway22_cell40 ML22 gate_way22_cell40 GND ML22 p1 W=2.4e-6 L=1e-6
mnway22_cell41 ML22 gate_way22_cell41 GND GND n1 W=1e-6 L=1e-6
mpway22_cell41 ML22 gate_way22_cell41 GND ML22 p1 W=2.4e-6 L=1e-6
mnway22_cell42 ML22 gate_way22_cell42 GND GND n1 W=1e-6 L=1e-6
mpway22_cell42 ML22 gate_way22_cell42 GND ML22 p1 W=2.4e-6 L=1e-6
mnway22_cell43 ML22 gate_way22_cell43 GND GND n1 W=1e-6 L=1e-6
mpway22_cell43 ML22 gate_way22_cell43 GND ML22 p1 W=2.4e-6 L=1e-6
mnway22_cell44 ML22 gate_way22_cell44 GND GND n1 W=1e-6 L=1e-6
mpway22_cell44 ML22 gate_way22_cell44 GND ML22 p1 W=2.4e-6 L=1e-6
mnway22_cell45 ML22 gate_way22_cell45 GND GND n1 W=1e-6 L=1e-6
mpway22_cell45 ML22 gate_way22_cell45 GND ML22 p1 W=2.4e-6 L=1e-6
mnway22_cell46 ML22 gate_way22_cell46 GND GND n1 W=1e-6 L=1e-6
mpway22_cell46 ML22 gate_way22_cell46 GND ML22 p1 W=2.4e-6 L=1e-6
mnway22_cell47 ML22 gate_way22_cell47 GND GND n1 W=1e-6 L=1e-6
mpway22_cell47 ML22 gate_way22_cell47 GND ML22 p1 W=2.4e-6 L=1e-6
mnway22_cell48 ML22 gate_way22_cell48 GND GND n1 W=1e-6 L=1e-6
mpway22_cell48 ML22 gate_way22_cell48 GND ML22 p1 W=2.4e-6 L=1e-6
mnway22_cell49 ML22 gate_way22_cell49 GND GND n1 W=1e-6 L=1e-6
mpway22_cell49 ML22 gate_way22_cell49 GND ML22 p1 W=2.4e-6 L=1e-6
mnway22_cell50 ML22 gate_way22_cell50 GND GND n1 W=1e-6 L=1e-6
mpway22_cell50 ML22 gate_way22_cell50 GND ML22 p1 W=2.4e-6 L=1e-6
mnway22_cell51 ML22 gate_way22_cell51 GND GND n1 W=1e-6 L=1e-6
mpway22_cell51 ML22 gate_way22_cell51 GND ML22 p1 W=2.4e-6 L=1e-6
mnway22_cell52 ML22 gate_way22_cell52 GND GND n1 W=1e-6 L=1e-6
mpway22_cell52 ML22 gate_way22_cell52 GND ML22 p1 W=2.4e-6 L=1e-6
mnway22_cell53 ML22 gate_way22_cell53 GND GND n1 W=1e-6 L=1e-6
mpway22_cell53 ML22 gate_way22_cell53 GND ML22 p1 W=2.4e-6 L=1e-6
mnway22_cell54 ML22 gate_way22_cell54 GND GND n1 W=1e-6 L=1e-6
mpway22_cell54 ML22 gate_way22_cell54 GND ML22 p1 W=2.4e-6 L=1e-6
mnway22_cell55 ML22 gate_way22_cell55 GND GND n1 W=1e-6 L=1e-6
mpway22_cell55 ML22 gate_way22_cell55 GND ML22 p1 W=2.4e-6 L=1e-6
mnway22_cell56 ML22 gate_way22_cell56 GND GND n1 W=1e-6 L=1e-6
mpway22_cell56 ML22 gate_way22_cell56 GND ML22 p1 W=2.4e-6 L=1e-6
mnway22_cell57 ML22 gate_way22_cell57 GND GND n1 W=1e-6 L=1e-6
mpway22_cell57 ML22 gate_way22_cell57 GND ML22 p1 W=2.4e-6 L=1e-6
mnway22_cell58 ML22 gate_way22_cell58 GND GND n1 W=1e-6 L=1e-6
mpway22_cell58 ML22 gate_way22_cell58 GND ML22 p1 W=2.4e-6 L=1e-6
mnway22_cell59 ML22 gate_way22_cell59 GND GND n1 W=1e-6 L=1e-6
mpway22_cell59 ML22 gate_way22_cell59 GND ML22 p1 W=2.4e-6 L=1e-6
mnway22_cell60 ML22 gate_way22_cell60 GND GND n1 W=1e-6 L=1e-6
mpway22_cell60 ML22 gate_way22_cell60 GND ML22 p1 W=2.4e-6 L=1e-6
mnway22_cell61 ML22 gate_way22_cell61 GND GND n1 W=1e-6 L=1e-6
mpway22_cell61 ML22 gate_way22_cell61 GND ML22 p1 W=2.4e-6 L=1e-6
mnway22_cell62 ML22 gate_way22_cell62 GND GND n1 W=1e-6 L=1e-6
mpway22_cell62 ML22 gate_way22_cell62 GND ML22 p1 W=2.4e-6 L=1e-6
mnway22_cell63 ML22 gate_way22_cell63 GND GND n1 W=1e-6 L=1e-6
mpway22_cell63 ML22 gate_way22_cell63 GND ML22 p1 W=2.4e-6 L=1e-6
mnway22_cell64 ML22 gate_way22_cell64 GND GND n1 W=1e-6 L=1e-6
mpway22_cell64 ML22 gate_way22_cell64 GND ML22 p1 W=2.4e-6 L=1e-6
mnway22_cell65 ML22 gate_way22_cell65 GND GND n1 W=1e-6 L=1e-6
mpway22_cell65 ML22 gate_way22_cell65 GND ML22 p1 W=2.4e-6 L=1e-6
mnway22_cell66 ML22 gate_way22_cell66 GND GND n1 W=1e-6 L=1e-6
mpway22_cell66 ML22 gate_way22_cell66 GND ML22 p1 W=2.4e-6 L=1e-6
mnway22_cell67 ML22 gate_way22_cell67 GND GND n1 W=1e-6 L=1e-6
mpway22_cell67 ML22 gate_way22_cell67 GND ML22 p1 W=2.4e-6 L=1e-6
mnway22_cell68 ML22 gate_way22_cell68 GND GND n1 W=1e-6 L=1e-6
mpway22_cell68 ML22 gate_way22_cell68 GND ML22 p1 W=2.4e-6 L=1e-6
mnway22_cell69 ML22 gate_way22_cell69 GND GND n1 W=1e-6 L=1e-6
mpway22_cell69 ML22 gate_way22_cell69 GND ML22 p1 W=2.4e-6 L=1e-6
mnway22_cell70 ML22 gate_way22_cell70 GND GND n1 W=1e-6 L=1e-6
mpway22_cell70 ML22 gate_way22_cell70 GND ML22 p1 W=2.4e-6 L=1e-6
mnway22_cell71 ML22 gate_way22_cell71 GND GND n1 W=1e-6 L=1e-6
mpway22_cell71 ML22 gate_way22_cell71 GND ML22 p1 W=2.4e-6 L=1e-6
mnway22_cell72 ML22 gate_way22_cell72 GND GND n1 W=1e-6 L=1e-6
mpway22_cell72 ML22 gate_way22_cell72 GND ML22 p1 W=2.4e-6 L=1e-6
mnway22_cell73 ML22 gate_way22_cell73 GND GND n1 W=1e-6 L=1e-6
mpway22_cell73 ML22 gate_way22_cell73 GND ML22 p1 W=2.4e-6 L=1e-6
mnway22_cell74 ML22 gate_way22_cell74 GND GND n1 W=1e-6 L=1e-6
mpway22_cell74 ML22 gate_way22_cell74 GND ML22 p1 W=2.4e-6 L=1e-6
mnway22_cell75 ML22 gate_way22_cell75 GND GND n1 W=1e-6 L=1e-6
mpway22_cell75 ML22 gate_way22_cell75 GND ML22 p1 W=2.4e-6 L=1e-6
mnway22_cell76 ML22 gate_way22_cell76 GND GND n1 W=1e-6 L=1e-6
mpway22_cell76 ML22 gate_way22_cell76 GND ML22 p1 W=2.4e-6 L=1e-6
mnway22_cell77 ML22 gate_way22_cell77 GND GND n1 W=1e-6 L=1e-6
mpway22_cell77 ML22 gate_way22_cell77 GND ML22 p1 W=2.4e-6 L=1e-6
mnway22_cell78 ML22 gate_way22_cell78 GND GND n1 W=1e-6 L=1e-6
mpway22_cell78 ML22 gate_way22_cell78 GND ML22 p1 W=2.4e-6 L=1e-6
mnway22_cell79 ML22 gate_way22_cell79 GND GND n1 W=1e-6 L=1e-6
mpway22_cell79 ML22 gate_way22_cell79 GND ML22 p1 W=2.4e-6 L=1e-6
mnway22_cell80 ML22 gate_way22_cell80 GND GND n1 W=1e-6 L=1e-6
mpway22_cell80 ML22 gate_way22_cell80 GND ML22 p1 W=2.4e-6 L=1e-6
mnway22_cell81 ML22 gate_way22_cell81 GND GND n1 W=1e-6 L=1e-6
mpway22_cell81 ML22 gate_way22_cell81 GND ML22 p1 W=2.4e-6 L=1e-6
mnway22_cell82 ML22 gate_way22_cell82 GND GND n1 W=1e-6 L=1e-6
mpway22_cell82 ML22 gate_way22_cell82 GND ML22 p1 W=2.4e-6 L=1e-6
mnway22_cell83 ML22 gate_way22_cell83 GND GND n1 W=1e-6 L=1e-6
mpway22_cell83 ML22 gate_way22_cell83 GND ML22 p1 W=2.4e-6 L=1e-6
mnway22_cell84 ML22 gate_way22_cell84 GND GND n1 W=1e-6 L=1e-6
mpway22_cell84 ML22 gate_way22_cell84 GND ML22 p1 W=2.4e-6 L=1e-6
mnway22_cell85 ML22 gate_way22_cell85 GND GND n1 W=1e-6 L=1e-6
mpway22_cell85 ML22 gate_way22_cell85 GND ML22 p1 W=2.4e-6 L=1e-6
mnway22_cell86 ML22 gate_way22_cell86 GND GND n1 W=1e-6 L=1e-6
mpway22_cell86 ML22 gate_way22_cell86 GND ML22 p1 W=2.4e-6 L=1e-6
mnway22_cell87 ML22 gate_way22_cell87 GND GND n1 W=1e-6 L=1e-6
mpway22_cell87 ML22 gate_way22_cell87 GND ML22 p1 W=2.4e-6 L=1e-6
mnway22_cell88 ML22 gate_way22_cell88 GND GND n1 W=1e-6 L=1e-6
mpway22_cell88 ML22 gate_way22_cell88 GND ML22 p1 W=2.4e-6 L=1e-6
mnway22_cell89 ML22 gate_way22_cell89 GND GND n1 W=1e-6 L=1e-6
mpway22_cell89 ML22 gate_way22_cell89 GND ML22 p1 W=2.4e-6 L=1e-6
mnway22_cell90 ML22 gate_way22_cell90 GND GND n1 W=1e-6 L=1e-6
mpway22_cell90 ML22 gate_way22_cell90 GND ML22 p1 W=2.4e-6 L=1e-6
mnway22_cell91 ML22 gate_way22_cell91 GND GND n1 W=1e-6 L=1e-6
mpway22_cell91 ML22 gate_way22_cell91 GND ML22 p1 W=2.4e-6 L=1e-6
mnway22_cell92 ML22 gate_way22_cell92 GND GND n1 W=1e-6 L=1e-6
mpway22_cell92 ML22 gate_way22_cell92 GND ML22 p1 W=2.4e-6 L=1e-6
mnway22_cell93 ML22 gate_way22_cell93 GND GND n1 W=1e-6 L=1e-6
mpway22_cell93 ML22 gate_way22_cell93 GND ML22 p1 W=2.4e-6 L=1e-6
mnway22_cell94 ML22 gate_way22_cell94 GND GND n1 W=1e-6 L=1e-6
mpway22_cell94 ML22 gate_way22_cell94 GND ML22 p1 W=2.4e-6 L=1e-6
mnway22_cell95 ML22 gate_way22_cell95 GND GND n1 W=1e-6 L=1e-6
mpway22_cell95 ML22 gate_way22_cell95 GND ML22 p1 W=2.4e-6 L=1e-6
mnway22_cell96 ML22 gate_way22_cell96 GND GND n1 W=1e-6 L=1e-6
mpway22_cell96 ML22 gate_way22_cell96 GND ML22 p1 W=2.4e-6 L=1e-6
mnway22_cell97 ML22 gate_way22_cell97 GND GND n1 W=1e-6 L=1e-6
mpway22_cell97 ML22 gate_way22_cell97 GND ML22 p1 W=2.4e-6 L=1e-6
mnway22_cell98 ML22 gate_way22_cell98 GND GND n1 W=1e-6 L=1e-6
mpway22_cell98 ML22 gate_way22_cell98 GND ML22 p1 W=2.4e-6 L=1e-6
mnway22_cell99 ML22 gate_way22_cell99 GND GND n1 W=1e-6 L=1e-6
mpway22_cell99 ML22 gate_way22_cell99 GND ML22 p1 W=2.4e-6 L=1e-6
mnway23_cell0 ML23 gate_way23_cell0 GND GND n1 W=1e-6 L=1e-6
mpway23_cell0 ML23 gate_way23_cell0 GND ML23 p1 W=2.4e-6 L=1e-6
mnway23_cell1 ML23 gate_way23_cell1 GND GND n1 W=1e-6 L=1e-6
mpway23_cell1 ML23 gate_way23_cell1 GND ML23 p1 W=2.4e-6 L=1e-6
mnway23_cell2 ML23 gate_way23_cell2 GND GND n1 W=1e-6 L=1e-6
mpway23_cell2 ML23 gate_way23_cell2 GND ML23 p1 W=2.4e-6 L=1e-6
mnway23_cell3 ML23 gate_way23_cell3 GND GND n1 W=1e-6 L=1e-6
mpway23_cell3 ML23 gate_way23_cell3 GND ML23 p1 W=2.4e-6 L=1e-6
mnway23_cell4 ML23 gate_way23_cell4 GND GND n1 W=1e-6 L=1e-6
mpway23_cell4 ML23 gate_way23_cell4 GND ML23 p1 W=2.4e-6 L=1e-6
mnway23_cell5 ML23 gate_way23_cell5 GND GND n1 W=1e-6 L=1e-6
mpway23_cell5 ML23 gate_way23_cell5 GND ML23 p1 W=2.4e-6 L=1e-6
mnway23_cell6 ML23 gate_way23_cell6 GND GND n1 W=1e-6 L=1e-6
mpway23_cell6 ML23 gate_way23_cell6 GND ML23 p1 W=2.4e-6 L=1e-6
mnway23_cell7 ML23 gate_way23_cell7 GND GND n1 W=1e-6 L=1e-6
mpway23_cell7 ML23 gate_way23_cell7 GND ML23 p1 W=2.4e-6 L=1e-6
mnway23_cell8 ML23 gate_way23_cell8 GND GND n1 W=1e-6 L=1e-6
mpway23_cell8 ML23 gate_way23_cell8 GND ML23 p1 W=2.4e-6 L=1e-6
mnway23_cell9 ML23 gate_way23_cell9 GND GND n1 W=1e-6 L=1e-6
mpway23_cell9 ML23 gate_way23_cell9 GND ML23 p1 W=2.4e-6 L=1e-6
mnway23_cell10 ML23 gate_way23_cell10 GND GND n1 W=1e-6 L=1e-6
mpway23_cell10 ML23 gate_way23_cell10 GND ML23 p1 W=2.4e-6 L=1e-6
mnway23_cell11 ML23 gate_way23_cell11 GND GND n1 W=1e-6 L=1e-6
mpway23_cell11 ML23 gate_way23_cell11 GND ML23 p1 W=2.4e-6 L=1e-6
mnway23_cell12 ML23 gate_way23_cell12 GND GND n1 W=1e-6 L=1e-6
mpway23_cell12 ML23 gate_way23_cell12 GND ML23 p1 W=2.4e-6 L=1e-6
mnway23_cell13 ML23 gate_way23_cell13 GND GND n1 W=1e-6 L=1e-6
mpway23_cell13 ML23 gate_way23_cell13 GND ML23 p1 W=2.4e-6 L=1e-6
mnway23_cell14 ML23 gate_way23_cell14 GND GND n1 W=1e-6 L=1e-6
mpway23_cell14 ML23 gate_way23_cell14 GND ML23 p1 W=2.4e-6 L=1e-6
mnway23_cell15 ML23 gate_way23_cell15 GND GND n1 W=1e-6 L=1e-6
mpway23_cell15 ML23 gate_way23_cell15 GND ML23 p1 W=2.4e-6 L=1e-6
mnway23_cell16 ML23 gate_way23_cell16 GND GND n1 W=1e-6 L=1e-6
mpway23_cell16 ML23 gate_way23_cell16 GND ML23 p1 W=2.4e-6 L=1e-6
mnway23_cell17 ML23 gate_way23_cell17 GND GND n1 W=1e-6 L=1e-6
mpway23_cell17 ML23 gate_way23_cell17 GND ML23 p1 W=2.4e-6 L=1e-6
mnway23_cell18 ML23 gate_way23_cell18 GND GND n1 W=1e-6 L=1e-6
mpway23_cell18 ML23 gate_way23_cell18 GND ML23 p1 W=2.4e-6 L=1e-6
mnway23_cell19 ML23 gate_way23_cell19 GND GND n1 W=1e-6 L=1e-6
mpway23_cell19 ML23 gate_way23_cell19 GND ML23 p1 W=2.4e-6 L=1e-6
mnway23_cell20 ML23 gate_way23_cell20 GND GND n1 W=1e-6 L=1e-6
mpway23_cell20 ML23 gate_way23_cell20 GND ML23 p1 W=2.4e-6 L=1e-6
mnway23_cell21 ML23 gate_way23_cell21 GND GND n1 W=1e-6 L=1e-6
mpway23_cell21 ML23 gate_way23_cell21 GND ML23 p1 W=2.4e-6 L=1e-6
mnway23_cell22 ML23 gate_way23_cell22 GND GND n1 W=1e-6 L=1e-6
mpway23_cell22 ML23 gate_way23_cell22 GND ML23 p1 W=2.4e-6 L=1e-6
mnway23_cell23 ML23 gate_way23_cell23 GND GND n1 W=1e-6 L=1e-6
mpway23_cell23 ML23 gate_way23_cell23 GND ML23 p1 W=2.4e-6 L=1e-6
mnway23_cell24 ML23 gate_way23_cell24 GND GND n1 W=1e-6 L=1e-6
mpway23_cell24 ML23 gate_way23_cell24 GND ML23 p1 W=2.4e-6 L=1e-6
mnway23_cell25 ML23 gate_way23_cell25 GND GND n1 W=1e-6 L=1e-6
mpway23_cell25 ML23 gate_way23_cell25 GND ML23 p1 W=2.4e-6 L=1e-6
mnway23_cell26 ML23 gate_way23_cell26 GND GND n1 W=1e-6 L=1e-6
mpway23_cell26 ML23 gate_way23_cell26 GND ML23 p1 W=2.4e-6 L=1e-6
mnway23_cell27 ML23 gate_way23_cell27 GND GND n1 W=1e-6 L=1e-6
mpway23_cell27 ML23 gate_way23_cell27 GND ML23 p1 W=2.4e-6 L=1e-6
mnway23_cell28 ML23 gate_way23_cell28 GND GND n1 W=1e-6 L=1e-6
mpway23_cell28 ML23 gate_way23_cell28 GND ML23 p1 W=2.4e-6 L=1e-6
mnway23_cell29 ML23 gate_way23_cell29 GND GND n1 W=1e-6 L=1e-6
mpway23_cell29 ML23 gate_way23_cell29 GND ML23 p1 W=2.4e-6 L=1e-6
mnway23_cell30 ML23 gate_way23_cell30 GND GND n1 W=1e-6 L=1e-6
mpway23_cell30 ML23 gate_way23_cell30 GND ML23 p1 W=2.4e-6 L=1e-6
mnway23_cell31 ML23 gate_way23_cell31 GND GND n1 W=1e-6 L=1e-6
mpway23_cell31 ML23 gate_way23_cell31 GND ML23 p1 W=2.4e-6 L=1e-6
mnway23_cell32 ML23 gate_way23_cell32 GND GND n1 W=1e-6 L=1e-6
mpway23_cell32 ML23 gate_way23_cell32 GND ML23 p1 W=2.4e-6 L=1e-6
mnway23_cell33 ML23 gate_way23_cell33 GND GND n1 W=1e-6 L=1e-6
mpway23_cell33 ML23 gate_way23_cell33 GND ML23 p1 W=2.4e-6 L=1e-6
mnway23_cell34 ML23 gate_way23_cell34 GND GND n1 W=1e-6 L=1e-6
mpway23_cell34 ML23 gate_way23_cell34 GND ML23 p1 W=2.4e-6 L=1e-6
mnway23_cell35 ML23 gate_way23_cell35 GND GND n1 W=1e-6 L=1e-6
mpway23_cell35 ML23 gate_way23_cell35 GND ML23 p1 W=2.4e-6 L=1e-6
mnway23_cell36 ML23 gate_way23_cell36 GND GND n1 W=1e-6 L=1e-6
mpway23_cell36 ML23 gate_way23_cell36 GND ML23 p1 W=2.4e-6 L=1e-6
mnway23_cell37 ML23 gate_way23_cell37 GND GND n1 W=1e-6 L=1e-6
mpway23_cell37 ML23 gate_way23_cell37 GND ML23 p1 W=2.4e-6 L=1e-6
mnway23_cell38 ML23 gate_way23_cell38 GND GND n1 W=1e-6 L=1e-6
mpway23_cell38 ML23 gate_way23_cell38 GND ML23 p1 W=2.4e-6 L=1e-6
mnway23_cell39 ML23 gate_way23_cell39 GND GND n1 W=1e-6 L=1e-6
mpway23_cell39 ML23 gate_way23_cell39 GND ML23 p1 W=2.4e-6 L=1e-6
mnway23_cell40 ML23 gate_way23_cell40 GND GND n1 W=1e-6 L=1e-6
mpway23_cell40 ML23 gate_way23_cell40 GND ML23 p1 W=2.4e-6 L=1e-6
mnway23_cell41 ML23 gate_way23_cell41 GND GND n1 W=1e-6 L=1e-6
mpway23_cell41 ML23 gate_way23_cell41 GND ML23 p1 W=2.4e-6 L=1e-6
mnway23_cell42 ML23 gate_way23_cell42 GND GND n1 W=1e-6 L=1e-6
mpway23_cell42 ML23 gate_way23_cell42 GND ML23 p1 W=2.4e-6 L=1e-6
mnway23_cell43 ML23 gate_way23_cell43 GND GND n1 W=1e-6 L=1e-6
mpway23_cell43 ML23 gate_way23_cell43 GND ML23 p1 W=2.4e-6 L=1e-6
mnway23_cell44 ML23 gate_way23_cell44 GND GND n1 W=1e-6 L=1e-6
mpway23_cell44 ML23 gate_way23_cell44 GND ML23 p1 W=2.4e-6 L=1e-6
mnway23_cell45 ML23 gate_way23_cell45 GND GND n1 W=1e-6 L=1e-6
mpway23_cell45 ML23 gate_way23_cell45 GND ML23 p1 W=2.4e-6 L=1e-6
mnway23_cell46 ML23 gate_way23_cell46 GND GND n1 W=1e-6 L=1e-6
mpway23_cell46 ML23 gate_way23_cell46 GND ML23 p1 W=2.4e-6 L=1e-6
mnway23_cell47 ML23 gate_way23_cell47 GND GND n1 W=1e-6 L=1e-6
mpway23_cell47 ML23 gate_way23_cell47 GND ML23 p1 W=2.4e-6 L=1e-6
mnway23_cell48 ML23 gate_way23_cell48 GND GND n1 W=1e-6 L=1e-6
mpway23_cell48 ML23 gate_way23_cell48 GND ML23 p1 W=2.4e-6 L=1e-6
mnway23_cell49 ML23 gate_way23_cell49 GND GND n1 W=1e-6 L=1e-6
mpway23_cell49 ML23 gate_way23_cell49 GND ML23 p1 W=2.4e-6 L=1e-6
mnway23_cell50 ML23 gate_way23_cell50 GND GND n1 W=1e-6 L=1e-6
mpway23_cell50 ML23 gate_way23_cell50 GND ML23 p1 W=2.4e-6 L=1e-6
mnway23_cell51 ML23 gate_way23_cell51 GND GND n1 W=1e-6 L=1e-6
mpway23_cell51 ML23 gate_way23_cell51 GND ML23 p1 W=2.4e-6 L=1e-6
mnway23_cell52 ML23 gate_way23_cell52 GND GND n1 W=1e-6 L=1e-6
mpway23_cell52 ML23 gate_way23_cell52 GND ML23 p1 W=2.4e-6 L=1e-6
mnway23_cell53 ML23 gate_way23_cell53 GND GND n1 W=1e-6 L=1e-6
mpway23_cell53 ML23 gate_way23_cell53 GND ML23 p1 W=2.4e-6 L=1e-6
mnway23_cell54 ML23 gate_way23_cell54 GND GND n1 W=1e-6 L=1e-6
mpway23_cell54 ML23 gate_way23_cell54 GND ML23 p1 W=2.4e-6 L=1e-6
mnway23_cell55 ML23 gate_way23_cell55 GND GND n1 W=1e-6 L=1e-6
mpway23_cell55 ML23 gate_way23_cell55 GND ML23 p1 W=2.4e-6 L=1e-6
mnway23_cell56 ML23 gate_way23_cell56 GND GND n1 W=1e-6 L=1e-6
mpway23_cell56 ML23 gate_way23_cell56 GND ML23 p1 W=2.4e-6 L=1e-6
mnway23_cell57 ML23 gate_way23_cell57 GND GND n1 W=1e-6 L=1e-6
mpway23_cell57 ML23 gate_way23_cell57 GND ML23 p1 W=2.4e-6 L=1e-6
mnway23_cell58 ML23 gate_way23_cell58 GND GND n1 W=1e-6 L=1e-6
mpway23_cell58 ML23 gate_way23_cell58 GND ML23 p1 W=2.4e-6 L=1e-6
mnway23_cell59 ML23 gate_way23_cell59 GND GND n1 W=1e-6 L=1e-6
mpway23_cell59 ML23 gate_way23_cell59 GND ML23 p1 W=2.4e-6 L=1e-6
mnway23_cell60 ML23 gate_way23_cell60 GND GND n1 W=1e-6 L=1e-6
mpway23_cell60 ML23 gate_way23_cell60 GND ML23 p1 W=2.4e-6 L=1e-6
mnway23_cell61 ML23 gate_way23_cell61 GND GND n1 W=1e-6 L=1e-6
mpway23_cell61 ML23 gate_way23_cell61 GND ML23 p1 W=2.4e-6 L=1e-6
mnway23_cell62 ML23 gate_way23_cell62 GND GND n1 W=1e-6 L=1e-6
mpway23_cell62 ML23 gate_way23_cell62 GND ML23 p1 W=2.4e-6 L=1e-6
mnway23_cell63 ML23 gate_way23_cell63 GND GND n1 W=1e-6 L=1e-6
mpway23_cell63 ML23 gate_way23_cell63 GND ML23 p1 W=2.4e-6 L=1e-6
mnway23_cell64 ML23 gate_way23_cell64 GND GND n1 W=1e-6 L=1e-6
mpway23_cell64 ML23 gate_way23_cell64 GND ML23 p1 W=2.4e-6 L=1e-6
mnway23_cell65 ML23 gate_way23_cell65 GND GND n1 W=1e-6 L=1e-6
mpway23_cell65 ML23 gate_way23_cell65 GND ML23 p1 W=2.4e-6 L=1e-6
mnway23_cell66 ML23 gate_way23_cell66 GND GND n1 W=1e-6 L=1e-6
mpway23_cell66 ML23 gate_way23_cell66 GND ML23 p1 W=2.4e-6 L=1e-6
mnway23_cell67 ML23 gate_way23_cell67 GND GND n1 W=1e-6 L=1e-6
mpway23_cell67 ML23 gate_way23_cell67 GND ML23 p1 W=2.4e-6 L=1e-6
mnway23_cell68 ML23 gate_way23_cell68 GND GND n1 W=1e-6 L=1e-6
mpway23_cell68 ML23 gate_way23_cell68 GND ML23 p1 W=2.4e-6 L=1e-6
mnway23_cell69 ML23 gate_way23_cell69 GND GND n1 W=1e-6 L=1e-6
mpway23_cell69 ML23 gate_way23_cell69 GND ML23 p1 W=2.4e-6 L=1e-6
mnway23_cell70 ML23 gate_way23_cell70 GND GND n1 W=1e-6 L=1e-6
mpway23_cell70 ML23 gate_way23_cell70 GND ML23 p1 W=2.4e-6 L=1e-6
mnway23_cell71 ML23 gate_way23_cell71 GND GND n1 W=1e-6 L=1e-6
mpway23_cell71 ML23 gate_way23_cell71 GND ML23 p1 W=2.4e-6 L=1e-6
mnway23_cell72 ML23 gate_way23_cell72 GND GND n1 W=1e-6 L=1e-6
mpway23_cell72 ML23 gate_way23_cell72 GND ML23 p1 W=2.4e-6 L=1e-6
mnway23_cell73 ML23 gate_way23_cell73 GND GND n1 W=1e-6 L=1e-6
mpway23_cell73 ML23 gate_way23_cell73 GND ML23 p1 W=2.4e-6 L=1e-6
mnway23_cell74 ML23 gate_way23_cell74 GND GND n1 W=1e-6 L=1e-6
mpway23_cell74 ML23 gate_way23_cell74 GND ML23 p1 W=2.4e-6 L=1e-6
mnway23_cell75 ML23 gate_way23_cell75 GND GND n1 W=1e-6 L=1e-6
mpway23_cell75 ML23 gate_way23_cell75 GND ML23 p1 W=2.4e-6 L=1e-6
mnway23_cell76 ML23 gate_way23_cell76 GND GND n1 W=1e-6 L=1e-6
mpway23_cell76 ML23 gate_way23_cell76 GND ML23 p1 W=2.4e-6 L=1e-6
mnway23_cell77 ML23 gate_way23_cell77 GND GND n1 W=1e-6 L=1e-6
mpway23_cell77 ML23 gate_way23_cell77 GND ML23 p1 W=2.4e-6 L=1e-6
mnway23_cell78 ML23 gate_way23_cell78 GND GND n1 W=1e-6 L=1e-6
mpway23_cell78 ML23 gate_way23_cell78 GND ML23 p1 W=2.4e-6 L=1e-6
mnway23_cell79 ML23 gate_way23_cell79 GND GND n1 W=1e-6 L=1e-6
mpway23_cell79 ML23 gate_way23_cell79 GND ML23 p1 W=2.4e-6 L=1e-6
mnway23_cell80 ML23 gate_way23_cell80 GND GND n1 W=1e-6 L=1e-6
mpway23_cell80 ML23 gate_way23_cell80 GND ML23 p1 W=2.4e-6 L=1e-6
mnway23_cell81 ML23 gate_way23_cell81 GND GND n1 W=1e-6 L=1e-6
mpway23_cell81 ML23 gate_way23_cell81 GND ML23 p1 W=2.4e-6 L=1e-6
mnway23_cell82 ML23 gate_way23_cell82 GND GND n1 W=1e-6 L=1e-6
mpway23_cell82 ML23 gate_way23_cell82 GND ML23 p1 W=2.4e-6 L=1e-6
mnway23_cell83 ML23 gate_way23_cell83 GND GND n1 W=1e-6 L=1e-6
mpway23_cell83 ML23 gate_way23_cell83 GND ML23 p1 W=2.4e-6 L=1e-6
mnway23_cell84 ML23 gate_way23_cell84 GND GND n1 W=1e-6 L=1e-6
mpway23_cell84 ML23 gate_way23_cell84 GND ML23 p1 W=2.4e-6 L=1e-6
mnway23_cell85 ML23 gate_way23_cell85 GND GND n1 W=1e-6 L=1e-6
mpway23_cell85 ML23 gate_way23_cell85 GND ML23 p1 W=2.4e-6 L=1e-6
mnway23_cell86 ML23 gate_way23_cell86 GND GND n1 W=1e-6 L=1e-6
mpway23_cell86 ML23 gate_way23_cell86 GND ML23 p1 W=2.4e-6 L=1e-6
mnway23_cell87 ML23 gate_way23_cell87 GND GND n1 W=1e-6 L=1e-6
mpway23_cell87 ML23 gate_way23_cell87 GND ML23 p1 W=2.4e-6 L=1e-6
mnway23_cell88 ML23 gate_way23_cell88 GND GND n1 W=1e-6 L=1e-6
mpway23_cell88 ML23 gate_way23_cell88 GND ML23 p1 W=2.4e-6 L=1e-6
mnway23_cell89 ML23 gate_way23_cell89 GND GND n1 W=1e-6 L=1e-6
mpway23_cell89 ML23 gate_way23_cell89 GND ML23 p1 W=2.4e-6 L=1e-6
mnway23_cell90 ML23 gate_way23_cell90 GND GND n1 W=1e-6 L=1e-6
mpway23_cell90 ML23 gate_way23_cell90 GND ML23 p1 W=2.4e-6 L=1e-6
mnway23_cell91 ML23 gate_way23_cell91 GND GND n1 W=1e-6 L=1e-6
mpway23_cell91 ML23 gate_way23_cell91 GND ML23 p1 W=2.4e-6 L=1e-6
mnway23_cell92 ML23 gate_way23_cell92 GND GND n1 W=1e-6 L=1e-6
mpway23_cell92 ML23 gate_way23_cell92 GND ML23 p1 W=2.4e-6 L=1e-6
mnway23_cell93 ML23 gate_way23_cell93 GND GND n1 W=1e-6 L=1e-6
mpway23_cell93 ML23 gate_way23_cell93 GND ML23 p1 W=2.4e-6 L=1e-6
mnway23_cell94 ML23 gate_way23_cell94 GND GND n1 W=1e-6 L=1e-6
mpway23_cell94 ML23 gate_way23_cell94 GND ML23 p1 W=2.4e-6 L=1e-6
mnway23_cell95 ML23 gate_way23_cell95 GND GND n1 W=1e-6 L=1e-6
mpway23_cell95 ML23 gate_way23_cell95 GND ML23 p1 W=2.4e-6 L=1e-6
mnway23_cell96 ML23 gate_way23_cell96 GND GND n1 W=1e-6 L=1e-6
mpway23_cell96 ML23 gate_way23_cell96 GND ML23 p1 W=2.4e-6 L=1e-6
mnway23_cell97 ML23 gate_way23_cell97 GND GND n1 W=1e-6 L=1e-6
mpway23_cell97 ML23 gate_way23_cell97 GND ML23 p1 W=2.4e-6 L=1e-6
mnway23_cell98 ML23 gate_way23_cell98 GND GND n1 W=1e-6 L=1e-6
mpway23_cell98 ML23 gate_way23_cell98 GND ML23 p1 W=2.4e-6 L=1e-6
mnway23_cell99 ML23 gate_way23_cell99 GND GND n1 W=1e-6 L=1e-6
mpway23_cell99 ML23 gate_way23_cell99 GND ML23 p1 W=2.4e-6 L=1e-6
mnway24_cell0 ML24 gate_way24_cell0 GND GND n1 W=1e-6 L=1e-6
mpway24_cell0 ML24 gate_way24_cell0 GND ML24 p1 W=2.4e-6 L=1e-6
mnway24_cell1 ML24 gate_way24_cell1 GND GND n1 W=1e-6 L=1e-6
mpway24_cell1 ML24 gate_way24_cell1 GND ML24 p1 W=2.4e-6 L=1e-6
mnway24_cell2 ML24 gate_way24_cell2 GND GND n1 W=1e-6 L=1e-6
mpway24_cell2 ML24 gate_way24_cell2 GND ML24 p1 W=2.4e-6 L=1e-6
mnway24_cell3 ML24 gate_way24_cell3 GND GND n1 W=1e-6 L=1e-6
mpway24_cell3 ML24 gate_way24_cell3 GND ML24 p1 W=2.4e-6 L=1e-6
mnway24_cell4 ML24 gate_way24_cell4 GND GND n1 W=1e-6 L=1e-6
mpway24_cell4 ML24 gate_way24_cell4 GND ML24 p1 W=2.4e-6 L=1e-6
mnway24_cell5 ML24 gate_way24_cell5 GND GND n1 W=1e-6 L=1e-6
mpway24_cell5 ML24 gate_way24_cell5 GND ML24 p1 W=2.4e-6 L=1e-6
mnway24_cell6 ML24 gate_way24_cell6 GND GND n1 W=1e-6 L=1e-6
mpway24_cell6 ML24 gate_way24_cell6 GND ML24 p1 W=2.4e-6 L=1e-6
mnway24_cell7 ML24 gate_way24_cell7 GND GND n1 W=1e-6 L=1e-6
mpway24_cell7 ML24 gate_way24_cell7 GND ML24 p1 W=2.4e-6 L=1e-6
mnway24_cell8 ML24 gate_way24_cell8 GND GND n1 W=1e-6 L=1e-6
mpway24_cell8 ML24 gate_way24_cell8 GND ML24 p1 W=2.4e-6 L=1e-6
mnway24_cell9 ML24 gate_way24_cell9 GND GND n1 W=1e-6 L=1e-6
mpway24_cell9 ML24 gate_way24_cell9 GND ML24 p1 W=2.4e-6 L=1e-6
mnway24_cell10 ML24 gate_way24_cell10 GND GND n1 W=1e-6 L=1e-6
mpway24_cell10 ML24 gate_way24_cell10 GND ML24 p1 W=2.4e-6 L=1e-6
mnway24_cell11 ML24 gate_way24_cell11 GND GND n1 W=1e-6 L=1e-6
mpway24_cell11 ML24 gate_way24_cell11 GND ML24 p1 W=2.4e-6 L=1e-6
mnway24_cell12 ML24 gate_way24_cell12 GND GND n1 W=1e-6 L=1e-6
mpway24_cell12 ML24 gate_way24_cell12 GND ML24 p1 W=2.4e-6 L=1e-6
mnway24_cell13 ML24 gate_way24_cell13 GND GND n1 W=1e-6 L=1e-6
mpway24_cell13 ML24 gate_way24_cell13 GND ML24 p1 W=2.4e-6 L=1e-6
mnway24_cell14 ML24 gate_way24_cell14 GND GND n1 W=1e-6 L=1e-6
mpway24_cell14 ML24 gate_way24_cell14 GND ML24 p1 W=2.4e-6 L=1e-6
mnway24_cell15 ML24 gate_way24_cell15 GND GND n1 W=1e-6 L=1e-6
mpway24_cell15 ML24 gate_way24_cell15 GND ML24 p1 W=2.4e-6 L=1e-6
mnway24_cell16 ML24 gate_way24_cell16 GND GND n1 W=1e-6 L=1e-6
mpway24_cell16 ML24 gate_way24_cell16 GND ML24 p1 W=2.4e-6 L=1e-6
mnway24_cell17 ML24 gate_way24_cell17 GND GND n1 W=1e-6 L=1e-6
mpway24_cell17 ML24 gate_way24_cell17 GND ML24 p1 W=2.4e-6 L=1e-6
mnway24_cell18 ML24 gate_way24_cell18 GND GND n1 W=1e-6 L=1e-6
mpway24_cell18 ML24 gate_way24_cell18 GND ML24 p1 W=2.4e-6 L=1e-6
mnway24_cell19 ML24 gate_way24_cell19 GND GND n1 W=1e-6 L=1e-6
mpway24_cell19 ML24 gate_way24_cell19 GND ML24 p1 W=2.4e-6 L=1e-6
mnway24_cell20 ML24 gate_way24_cell20 GND GND n1 W=1e-6 L=1e-6
mpway24_cell20 ML24 gate_way24_cell20 GND ML24 p1 W=2.4e-6 L=1e-6
mnway24_cell21 ML24 gate_way24_cell21 GND GND n1 W=1e-6 L=1e-6
mpway24_cell21 ML24 gate_way24_cell21 GND ML24 p1 W=2.4e-6 L=1e-6
mnway24_cell22 ML24 gate_way24_cell22 GND GND n1 W=1e-6 L=1e-6
mpway24_cell22 ML24 gate_way24_cell22 GND ML24 p1 W=2.4e-6 L=1e-6
mnway24_cell23 ML24 gate_way24_cell23 GND GND n1 W=1e-6 L=1e-6
mpway24_cell23 ML24 gate_way24_cell23 GND ML24 p1 W=2.4e-6 L=1e-6
mnway24_cell24 ML24 gate_way24_cell24 GND GND n1 W=1e-6 L=1e-6
mpway24_cell24 ML24 gate_way24_cell24 GND ML24 p1 W=2.4e-6 L=1e-6
mnway24_cell25 ML24 gate_way24_cell25 GND GND n1 W=1e-6 L=1e-6
mpway24_cell25 ML24 gate_way24_cell25 GND ML24 p1 W=2.4e-6 L=1e-6
mnway24_cell26 ML24 gate_way24_cell26 GND GND n1 W=1e-6 L=1e-6
mpway24_cell26 ML24 gate_way24_cell26 GND ML24 p1 W=2.4e-6 L=1e-6
mnway24_cell27 ML24 gate_way24_cell27 GND GND n1 W=1e-6 L=1e-6
mpway24_cell27 ML24 gate_way24_cell27 GND ML24 p1 W=2.4e-6 L=1e-6
mnway24_cell28 ML24 gate_way24_cell28 GND GND n1 W=1e-6 L=1e-6
mpway24_cell28 ML24 gate_way24_cell28 GND ML24 p1 W=2.4e-6 L=1e-6
mnway24_cell29 ML24 gate_way24_cell29 GND GND n1 W=1e-6 L=1e-6
mpway24_cell29 ML24 gate_way24_cell29 GND ML24 p1 W=2.4e-6 L=1e-6
mnway24_cell30 ML24 gate_way24_cell30 GND GND n1 W=1e-6 L=1e-6
mpway24_cell30 ML24 gate_way24_cell30 GND ML24 p1 W=2.4e-6 L=1e-6
mnway24_cell31 ML24 gate_way24_cell31 GND GND n1 W=1e-6 L=1e-6
mpway24_cell31 ML24 gate_way24_cell31 GND ML24 p1 W=2.4e-6 L=1e-6
mnway24_cell32 ML24 gate_way24_cell32 GND GND n1 W=1e-6 L=1e-6
mpway24_cell32 ML24 gate_way24_cell32 GND ML24 p1 W=2.4e-6 L=1e-6
mnway24_cell33 ML24 gate_way24_cell33 GND GND n1 W=1e-6 L=1e-6
mpway24_cell33 ML24 gate_way24_cell33 GND ML24 p1 W=2.4e-6 L=1e-6
mnway24_cell34 ML24 gate_way24_cell34 GND GND n1 W=1e-6 L=1e-6
mpway24_cell34 ML24 gate_way24_cell34 GND ML24 p1 W=2.4e-6 L=1e-6
mnway24_cell35 ML24 gate_way24_cell35 GND GND n1 W=1e-6 L=1e-6
mpway24_cell35 ML24 gate_way24_cell35 GND ML24 p1 W=2.4e-6 L=1e-6
mnway24_cell36 ML24 gate_way24_cell36 GND GND n1 W=1e-6 L=1e-6
mpway24_cell36 ML24 gate_way24_cell36 GND ML24 p1 W=2.4e-6 L=1e-6
mnway24_cell37 ML24 gate_way24_cell37 GND GND n1 W=1e-6 L=1e-6
mpway24_cell37 ML24 gate_way24_cell37 GND ML24 p1 W=2.4e-6 L=1e-6
mnway24_cell38 ML24 gate_way24_cell38 GND GND n1 W=1e-6 L=1e-6
mpway24_cell38 ML24 gate_way24_cell38 GND ML24 p1 W=2.4e-6 L=1e-6
mnway24_cell39 ML24 gate_way24_cell39 GND GND n1 W=1e-6 L=1e-6
mpway24_cell39 ML24 gate_way24_cell39 GND ML24 p1 W=2.4e-6 L=1e-6
mnway24_cell40 ML24 gate_way24_cell40 GND GND n1 W=1e-6 L=1e-6
mpway24_cell40 ML24 gate_way24_cell40 GND ML24 p1 W=2.4e-6 L=1e-6
mnway24_cell41 ML24 gate_way24_cell41 GND GND n1 W=1e-6 L=1e-6
mpway24_cell41 ML24 gate_way24_cell41 GND ML24 p1 W=2.4e-6 L=1e-6
mnway24_cell42 ML24 gate_way24_cell42 GND GND n1 W=1e-6 L=1e-6
mpway24_cell42 ML24 gate_way24_cell42 GND ML24 p1 W=2.4e-6 L=1e-6
mnway24_cell43 ML24 gate_way24_cell43 GND GND n1 W=1e-6 L=1e-6
mpway24_cell43 ML24 gate_way24_cell43 GND ML24 p1 W=2.4e-6 L=1e-6
mnway24_cell44 ML24 gate_way24_cell44 GND GND n1 W=1e-6 L=1e-6
mpway24_cell44 ML24 gate_way24_cell44 GND ML24 p1 W=2.4e-6 L=1e-6
mnway24_cell45 ML24 gate_way24_cell45 GND GND n1 W=1e-6 L=1e-6
mpway24_cell45 ML24 gate_way24_cell45 GND ML24 p1 W=2.4e-6 L=1e-6
mnway24_cell46 ML24 gate_way24_cell46 GND GND n1 W=1e-6 L=1e-6
mpway24_cell46 ML24 gate_way24_cell46 GND ML24 p1 W=2.4e-6 L=1e-6
mnway24_cell47 ML24 gate_way24_cell47 GND GND n1 W=1e-6 L=1e-6
mpway24_cell47 ML24 gate_way24_cell47 GND ML24 p1 W=2.4e-6 L=1e-6
mnway24_cell48 ML24 gate_way24_cell48 GND GND n1 W=1e-6 L=1e-6
mpway24_cell48 ML24 gate_way24_cell48 GND ML24 p1 W=2.4e-6 L=1e-6
mnway24_cell49 ML24 gate_way24_cell49 GND GND n1 W=1e-6 L=1e-6
mpway24_cell49 ML24 gate_way24_cell49 GND ML24 p1 W=2.4e-6 L=1e-6
mnway24_cell50 ML24 gate_way24_cell50 GND GND n1 W=1e-6 L=1e-6
mpway24_cell50 ML24 gate_way24_cell50 GND ML24 p1 W=2.4e-6 L=1e-6
mnway24_cell51 ML24 gate_way24_cell51 GND GND n1 W=1e-6 L=1e-6
mpway24_cell51 ML24 gate_way24_cell51 GND ML24 p1 W=2.4e-6 L=1e-6
mnway24_cell52 ML24 gate_way24_cell52 GND GND n1 W=1e-6 L=1e-6
mpway24_cell52 ML24 gate_way24_cell52 GND ML24 p1 W=2.4e-6 L=1e-6
mnway24_cell53 ML24 gate_way24_cell53 GND GND n1 W=1e-6 L=1e-6
mpway24_cell53 ML24 gate_way24_cell53 GND ML24 p1 W=2.4e-6 L=1e-6
mnway24_cell54 ML24 gate_way24_cell54 GND GND n1 W=1e-6 L=1e-6
mpway24_cell54 ML24 gate_way24_cell54 GND ML24 p1 W=2.4e-6 L=1e-6
mnway24_cell55 ML24 gate_way24_cell55 GND GND n1 W=1e-6 L=1e-6
mpway24_cell55 ML24 gate_way24_cell55 GND ML24 p1 W=2.4e-6 L=1e-6
mnway24_cell56 ML24 gate_way24_cell56 GND GND n1 W=1e-6 L=1e-6
mpway24_cell56 ML24 gate_way24_cell56 GND ML24 p1 W=2.4e-6 L=1e-6
mnway24_cell57 ML24 gate_way24_cell57 GND GND n1 W=1e-6 L=1e-6
mpway24_cell57 ML24 gate_way24_cell57 GND ML24 p1 W=2.4e-6 L=1e-6
mnway24_cell58 ML24 gate_way24_cell58 GND GND n1 W=1e-6 L=1e-6
mpway24_cell58 ML24 gate_way24_cell58 GND ML24 p1 W=2.4e-6 L=1e-6
mnway24_cell59 ML24 gate_way24_cell59 GND GND n1 W=1e-6 L=1e-6
mpway24_cell59 ML24 gate_way24_cell59 GND ML24 p1 W=2.4e-6 L=1e-6
mnway24_cell60 ML24 gate_way24_cell60 GND GND n1 W=1e-6 L=1e-6
mpway24_cell60 ML24 gate_way24_cell60 GND ML24 p1 W=2.4e-6 L=1e-6
mnway24_cell61 ML24 gate_way24_cell61 GND GND n1 W=1e-6 L=1e-6
mpway24_cell61 ML24 gate_way24_cell61 GND ML24 p1 W=2.4e-6 L=1e-6
mnway24_cell62 ML24 gate_way24_cell62 GND GND n1 W=1e-6 L=1e-6
mpway24_cell62 ML24 gate_way24_cell62 GND ML24 p1 W=2.4e-6 L=1e-6
mnway24_cell63 ML24 gate_way24_cell63 GND GND n1 W=1e-6 L=1e-6
mpway24_cell63 ML24 gate_way24_cell63 GND ML24 p1 W=2.4e-6 L=1e-6
mnway24_cell64 ML24 gate_way24_cell64 GND GND n1 W=1e-6 L=1e-6
mpway24_cell64 ML24 gate_way24_cell64 GND ML24 p1 W=2.4e-6 L=1e-6
mnway24_cell65 ML24 gate_way24_cell65 GND GND n1 W=1e-6 L=1e-6
mpway24_cell65 ML24 gate_way24_cell65 GND ML24 p1 W=2.4e-6 L=1e-6
mnway24_cell66 ML24 gate_way24_cell66 GND GND n1 W=1e-6 L=1e-6
mpway24_cell66 ML24 gate_way24_cell66 GND ML24 p1 W=2.4e-6 L=1e-6
mnway24_cell67 ML24 gate_way24_cell67 GND GND n1 W=1e-6 L=1e-6
mpway24_cell67 ML24 gate_way24_cell67 GND ML24 p1 W=2.4e-6 L=1e-6
mnway24_cell68 ML24 gate_way24_cell68 GND GND n1 W=1e-6 L=1e-6
mpway24_cell68 ML24 gate_way24_cell68 GND ML24 p1 W=2.4e-6 L=1e-6
mnway24_cell69 ML24 gate_way24_cell69 GND GND n1 W=1e-6 L=1e-6
mpway24_cell69 ML24 gate_way24_cell69 GND ML24 p1 W=2.4e-6 L=1e-6
mnway24_cell70 ML24 gate_way24_cell70 GND GND n1 W=1e-6 L=1e-6
mpway24_cell70 ML24 gate_way24_cell70 GND ML24 p1 W=2.4e-6 L=1e-6
mnway24_cell71 ML24 gate_way24_cell71 GND GND n1 W=1e-6 L=1e-6
mpway24_cell71 ML24 gate_way24_cell71 GND ML24 p1 W=2.4e-6 L=1e-6
mnway24_cell72 ML24 gate_way24_cell72 GND GND n1 W=1e-6 L=1e-6
mpway24_cell72 ML24 gate_way24_cell72 GND ML24 p1 W=2.4e-6 L=1e-6
mnway24_cell73 ML24 gate_way24_cell73 GND GND n1 W=1e-6 L=1e-6
mpway24_cell73 ML24 gate_way24_cell73 GND ML24 p1 W=2.4e-6 L=1e-6
mnway24_cell74 ML24 gate_way24_cell74 GND GND n1 W=1e-6 L=1e-6
mpway24_cell74 ML24 gate_way24_cell74 GND ML24 p1 W=2.4e-6 L=1e-6
mnway24_cell75 ML24 gate_way24_cell75 GND GND n1 W=1e-6 L=1e-6
mpway24_cell75 ML24 gate_way24_cell75 GND ML24 p1 W=2.4e-6 L=1e-6
mnway24_cell76 ML24 gate_way24_cell76 GND GND n1 W=1e-6 L=1e-6
mpway24_cell76 ML24 gate_way24_cell76 GND ML24 p1 W=2.4e-6 L=1e-6
mnway24_cell77 ML24 gate_way24_cell77 GND GND n1 W=1e-6 L=1e-6
mpway24_cell77 ML24 gate_way24_cell77 GND ML24 p1 W=2.4e-6 L=1e-6
mnway24_cell78 ML24 gate_way24_cell78 GND GND n1 W=1e-6 L=1e-6
mpway24_cell78 ML24 gate_way24_cell78 GND ML24 p1 W=2.4e-6 L=1e-6
mnway24_cell79 ML24 gate_way24_cell79 GND GND n1 W=1e-6 L=1e-6
mpway24_cell79 ML24 gate_way24_cell79 GND ML24 p1 W=2.4e-6 L=1e-6
mnway24_cell80 ML24 gate_way24_cell80 GND GND n1 W=1e-6 L=1e-6
mpway24_cell80 ML24 gate_way24_cell80 GND ML24 p1 W=2.4e-6 L=1e-6
mnway24_cell81 ML24 gate_way24_cell81 GND GND n1 W=1e-6 L=1e-6
mpway24_cell81 ML24 gate_way24_cell81 GND ML24 p1 W=2.4e-6 L=1e-6
mnway24_cell82 ML24 gate_way24_cell82 GND GND n1 W=1e-6 L=1e-6
mpway24_cell82 ML24 gate_way24_cell82 GND ML24 p1 W=2.4e-6 L=1e-6
mnway24_cell83 ML24 gate_way24_cell83 GND GND n1 W=1e-6 L=1e-6
mpway24_cell83 ML24 gate_way24_cell83 GND ML24 p1 W=2.4e-6 L=1e-6
mnway24_cell84 ML24 gate_way24_cell84 GND GND n1 W=1e-6 L=1e-6
mpway24_cell84 ML24 gate_way24_cell84 GND ML24 p1 W=2.4e-6 L=1e-6
mnway24_cell85 ML24 gate_way24_cell85 GND GND n1 W=1e-6 L=1e-6
mpway24_cell85 ML24 gate_way24_cell85 GND ML24 p1 W=2.4e-6 L=1e-6
mnway24_cell86 ML24 gate_way24_cell86 GND GND n1 W=1e-6 L=1e-6
mpway24_cell86 ML24 gate_way24_cell86 GND ML24 p1 W=2.4e-6 L=1e-6
mnway24_cell87 ML24 gate_way24_cell87 GND GND n1 W=1e-6 L=1e-6
mpway24_cell87 ML24 gate_way24_cell87 GND ML24 p1 W=2.4e-6 L=1e-6
mnway24_cell88 ML24 gate_way24_cell88 GND GND n1 W=1e-6 L=1e-6
mpway24_cell88 ML24 gate_way24_cell88 GND ML24 p1 W=2.4e-6 L=1e-6
mnway24_cell89 ML24 gate_way24_cell89 GND GND n1 W=1e-6 L=1e-6
mpway24_cell89 ML24 gate_way24_cell89 GND ML24 p1 W=2.4e-6 L=1e-6
mnway24_cell90 ML24 gate_way24_cell90 GND GND n1 W=1e-6 L=1e-6
mpway24_cell90 ML24 gate_way24_cell90 GND ML24 p1 W=2.4e-6 L=1e-6
mnway24_cell91 ML24 gate_way24_cell91 GND GND n1 W=1e-6 L=1e-6
mpway24_cell91 ML24 gate_way24_cell91 GND ML24 p1 W=2.4e-6 L=1e-6
mnway24_cell92 ML24 gate_way24_cell92 GND GND n1 W=1e-6 L=1e-6
mpway24_cell92 ML24 gate_way24_cell92 GND ML24 p1 W=2.4e-6 L=1e-6
mnway24_cell93 ML24 gate_way24_cell93 GND GND n1 W=1e-6 L=1e-6
mpway24_cell93 ML24 gate_way24_cell93 GND ML24 p1 W=2.4e-6 L=1e-6
mnway24_cell94 ML24 gate_way24_cell94 GND GND n1 W=1e-6 L=1e-6
mpway24_cell94 ML24 gate_way24_cell94 GND ML24 p1 W=2.4e-6 L=1e-6
mnway24_cell95 ML24 gate_way24_cell95 GND GND n1 W=1e-6 L=1e-6
mpway24_cell95 ML24 gate_way24_cell95 GND ML24 p1 W=2.4e-6 L=1e-6
mnway24_cell96 ML24 gate_way24_cell96 GND GND n1 W=1e-6 L=1e-6
mpway24_cell96 ML24 gate_way24_cell96 GND ML24 p1 W=2.4e-6 L=1e-6
mnway24_cell97 ML24 gate_way24_cell97 GND GND n1 W=1e-6 L=1e-6
mpway24_cell97 ML24 gate_way24_cell97 GND ML24 p1 W=2.4e-6 L=1e-6
mnway24_cell98 ML24 gate_way24_cell98 GND GND n1 W=1e-6 L=1e-6
mpway24_cell98 ML24 gate_way24_cell98 GND ML24 p1 W=2.4e-6 L=1e-6
mnway24_cell99 ML24 gate_way24_cell99 GND GND n1 W=1e-6 L=1e-6
mpway24_cell99 ML24 gate_way24_cell99 GND ML24 p1 W=2.4e-6 L=1e-6
mnway25_cell0 ML25 gate_way25_cell0 GND GND n1 W=1e-6 L=1e-6
mpway25_cell0 ML25 gate_way25_cell0 GND ML25 p1 W=2.4e-6 L=1e-6
mnway25_cell1 ML25 gate_way25_cell1 GND GND n1 W=1e-6 L=1e-6
mpway25_cell1 ML25 gate_way25_cell1 GND ML25 p1 W=2.4e-6 L=1e-6
mnway25_cell2 ML25 gate_way25_cell2 GND GND n1 W=1e-6 L=1e-6
mpway25_cell2 ML25 gate_way25_cell2 GND ML25 p1 W=2.4e-6 L=1e-6
mnway25_cell3 ML25 gate_way25_cell3 GND GND n1 W=1e-6 L=1e-6
mpway25_cell3 ML25 gate_way25_cell3 GND ML25 p1 W=2.4e-6 L=1e-6
mnway25_cell4 ML25 gate_way25_cell4 GND GND n1 W=1e-6 L=1e-6
mpway25_cell4 ML25 gate_way25_cell4 GND ML25 p1 W=2.4e-6 L=1e-6
mnway25_cell5 ML25 gate_way25_cell5 GND GND n1 W=1e-6 L=1e-6
mpway25_cell5 ML25 gate_way25_cell5 GND ML25 p1 W=2.4e-6 L=1e-6
mnway25_cell6 ML25 gate_way25_cell6 GND GND n1 W=1e-6 L=1e-6
mpway25_cell6 ML25 gate_way25_cell6 GND ML25 p1 W=2.4e-6 L=1e-6
mnway25_cell7 ML25 gate_way25_cell7 GND GND n1 W=1e-6 L=1e-6
mpway25_cell7 ML25 gate_way25_cell7 GND ML25 p1 W=2.4e-6 L=1e-6
mnway25_cell8 ML25 gate_way25_cell8 GND GND n1 W=1e-6 L=1e-6
mpway25_cell8 ML25 gate_way25_cell8 GND ML25 p1 W=2.4e-6 L=1e-6
mnway25_cell9 ML25 gate_way25_cell9 GND GND n1 W=1e-6 L=1e-6
mpway25_cell9 ML25 gate_way25_cell9 GND ML25 p1 W=2.4e-6 L=1e-6
mnway25_cell10 ML25 gate_way25_cell10 GND GND n1 W=1e-6 L=1e-6
mpway25_cell10 ML25 gate_way25_cell10 GND ML25 p1 W=2.4e-6 L=1e-6
mnway25_cell11 ML25 gate_way25_cell11 GND GND n1 W=1e-6 L=1e-6
mpway25_cell11 ML25 gate_way25_cell11 GND ML25 p1 W=2.4e-6 L=1e-6
mnway25_cell12 ML25 gate_way25_cell12 GND GND n1 W=1e-6 L=1e-6
mpway25_cell12 ML25 gate_way25_cell12 GND ML25 p1 W=2.4e-6 L=1e-6
mnway25_cell13 ML25 gate_way25_cell13 GND GND n1 W=1e-6 L=1e-6
mpway25_cell13 ML25 gate_way25_cell13 GND ML25 p1 W=2.4e-6 L=1e-6
mnway25_cell14 ML25 gate_way25_cell14 GND GND n1 W=1e-6 L=1e-6
mpway25_cell14 ML25 gate_way25_cell14 GND ML25 p1 W=2.4e-6 L=1e-6
mnway25_cell15 ML25 gate_way25_cell15 GND GND n1 W=1e-6 L=1e-6
mpway25_cell15 ML25 gate_way25_cell15 GND ML25 p1 W=2.4e-6 L=1e-6
mnway25_cell16 ML25 gate_way25_cell16 GND GND n1 W=1e-6 L=1e-6
mpway25_cell16 ML25 gate_way25_cell16 GND ML25 p1 W=2.4e-6 L=1e-6
mnway25_cell17 ML25 gate_way25_cell17 GND GND n1 W=1e-6 L=1e-6
mpway25_cell17 ML25 gate_way25_cell17 GND ML25 p1 W=2.4e-6 L=1e-6
mnway25_cell18 ML25 gate_way25_cell18 GND GND n1 W=1e-6 L=1e-6
mpway25_cell18 ML25 gate_way25_cell18 GND ML25 p1 W=2.4e-6 L=1e-6
mnway25_cell19 ML25 gate_way25_cell19 GND GND n1 W=1e-6 L=1e-6
mpway25_cell19 ML25 gate_way25_cell19 GND ML25 p1 W=2.4e-6 L=1e-6
mnway25_cell20 ML25 gate_way25_cell20 GND GND n1 W=1e-6 L=1e-6
mpway25_cell20 ML25 gate_way25_cell20 GND ML25 p1 W=2.4e-6 L=1e-6
mnway25_cell21 ML25 gate_way25_cell21 GND GND n1 W=1e-6 L=1e-6
mpway25_cell21 ML25 gate_way25_cell21 GND ML25 p1 W=2.4e-6 L=1e-6
mnway25_cell22 ML25 gate_way25_cell22 GND GND n1 W=1e-6 L=1e-6
mpway25_cell22 ML25 gate_way25_cell22 GND ML25 p1 W=2.4e-6 L=1e-6
mnway25_cell23 ML25 gate_way25_cell23 GND GND n1 W=1e-6 L=1e-6
mpway25_cell23 ML25 gate_way25_cell23 GND ML25 p1 W=2.4e-6 L=1e-6
mnway25_cell24 ML25 gate_way25_cell24 GND GND n1 W=1e-6 L=1e-6
mpway25_cell24 ML25 gate_way25_cell24 GND ML25 p1 W=2.4e-6 L=1e-6
mnway25_cell25 ML25 gate_way25_cell25 GND GND n1 W=1e-6 L=1e-6
mpway25_cell25 ML25 gate_way25_cell25 GND ML25 p1 W=2.4e-6 L=1e-6
mnway25_cell26 ML25 gate_way25_cell26 GND GND n1 W=1e-6 L=1e-6
mpway25_cell26 ML25 gate_way25_cell26 GND ML25 p1 W=2.4e-6 L=1e-6
mnway25_cell27 ML25 gate_way25_cell27 GND GND n1 W=1e-6 L=1e-6
mpway25_cell27 ML25 gate_way25_cell27 GND ML25 p1 W=2.4e-6 L=1e-6
mnway25_cell28 ML25 gate_way25_cell28 GND GND n1 W=1e-6 L=1e-6
mpway25_cell28 ML25 gate_way25_cell28 GND ML25 p1 W=2.4e-6 L=1e-6
mnway25_cell29 ML25 gate_way25_cell29 GND GND n1 W=1e-6 L=1e-6
mpway25_cell29 ML25 gate_way25_cell29 GND ML25 p1 W=2.4e-6 L=1e-6
mnway25_cell30 ML25 gate_way25_cell30 GND GND n1 W=1e-6 L=1e-6
mpway25_cell30 ML25 gate_way25_cell30 GND ML25 p1 W=2.4e-6 L=1e-6
mnway25_cell31 ML25 gate_way25_cell31 GND GND n1 W=1e-6 L=1e-6
mpway25_cell31 ML25 gate_way25_cell31 GND ML25 p1 W=2.4e-6 L=1e-6
mnway25_cell32 ML25 gate_way25_cell32 GND GND n1 W=1e-6 L=1e-6
mpway25_cell32 ML25 gate_way25_cell32 GND ML25 p1 W=2.4e-6 L=1e-6
mnway25_cell33 ML25 gate_way25_cell33 GND GND n1 W=1e-6 L=1e-6
mpway25_cell33 ML25 gate_way25_cell33 GND ML25 p1 W=2.4e-6 L=1e-6
mnway25_cell34 ML25 gate_way25_cell34 GND GND n1 W=1e-6 L=1e-6
mpway25_cell34 ML25 gate_way25_cell34 GND ML25 p1 W=2.4e-6 L=1e-6
mnway25_cell35 ML25 gate_way25_cell35 GND GND n1 W=1e-6 L=1e-6
mpway25_cell35 ML25 gate_way25_cell35 GND ML25 p1 W=2.4e-6 L=1e-6
mnway25_cell36 ML25 gate_way25_cell36 GND GND n1 W=1e-6 L=1e-6
mpway25_cell36 ML25 gate_way25_cell36 GND ML25 p1 W=2.4e-6 L=1e-6
mnway25_cell37 ML25 gate_way25_cell37 GND GND n1 W=1e-6 L=1e-6
mpway25_cell37 ML25 gate_way25_cell37 GND ML25 p1 W=2.4e-6 L=1e-6
mnway25_cell38 ML25 gate_way25_cell38 GND GND n1 W=1e-6 L=1e-6
mpway25_cell38 ML25 gate_way25_cell38 GND ML25 p1 W=2.4e-6 L=1e-6
mnway25_cell39 ML25 gate_way25_cell39 GND GND n1 W=1e-6 L=1e-6
mpway25_cell39 ML25 gate_way25_cell39 GND ML25 p1 W=2.4e-6 L=1e-6
mnway25_cell40 ML25 gate_way25_cell40 GND GND n1 W=1e-6 L=1e-6
mpway25_cell40 ML25 gate_way25_cell40 GND ML25 p1 W=2.4e-6 L=1e-6
mnway25_cell41 ML25 gate_way25_cell41 GND GND n1 W=1e-6 L=1e-6
mpway25_cell41 ML25 gate_way25_cell41 GND ML25 p1 W=2.4e-6 L=1e-6
mnway25_cell42 ML25 gate_way25_cell42 GND GND n1 W=1e-6 L=1e-6
mpway25_cell42 ML25 gate_way25_cell42 GND ML25 p1 W=2.4e-6 L=1e-6
mnway25_cell43 ML25 gate_way25_cell43 GND GND n1 W=1e-6 L=1e-6
mpway25_cell43 ML25 gate_way25_cell43 GND ML25 p1 W=2.4e-6 L=1e-6
mnway25_cell44 ML25 gate_way25_cell44 GND GND n1 W=1e-6 L=1e-6
mpway25_cell44 ML25 gate_way25_cell44 GND ML25 p1 W=2.4e-6 L=1e-6
mnway25_cell45 ML25 gate_way25_cell45 GND GND n1 W=1e-6 L=1e-6
mpway25_cell45 ML25 gate_way25_cell45 GND ML25 p1 W=2.4e-6 L=1e-6
mnway25_cell46 ML25 gate_way25_cell46 GND GND n1 W=1e-6 L=1e-6
mpway25_cell46 ML25 gate_way25_cell46 GND ML25 p1 W=2.4e-6 L=1e-6
mnway25_cell47 ML25 gate_way25_cell47 GND GND n1 W=1e-6 L=1e-6
mpway25_cell47 ML25 gate_way25_cell47 GND ML25 p1 W=2.4e-6 L=1e-6
mnway25_cell48 ML25 gate_way25_cell48 GND GND n1 W=1e-6 L=1e-6
mpway25_cell48 ML25 gate_way25_cell48 GND ML25 p1 W=2.4e-6 L=1e-6
mnway25_cell49 ML25 gate_way25_cell49 GND GND n1 W=1e-6 L=1e-6
mpway25_cell49 ML25 gate_way25_cell49 GND ML25 p1 W=2.4e-6 L=1e-6
mnway25_cell50 ML25 gate_way25_cell50 GND GND n1 W=1e-6 L=1e-6
mpway25_cell50 ML25 gate_way25_cell50 GND ML25 p1 W=2.4e-6 L=1e-6
mnway25_cell51 ML25 gate_way25_cell51 GND GND n1 W=1e-6 L=1e-6
mpway25_cell51 ML25 gate_way25_cell51 GND ML25 p1 W=2.4e-6 L=1e-6
mnway25_cell52 ML25 gate_way25_cell52 GND GND n1 W=1e-6 L=1e-6
mpway25_cell52 ML25 gate_way25_cell52 GND ML25 p1 W=2.4e-6 L=1e-6
mnway25_cell53 ML25 gate_way25_cell53 GND GND n1 W=1e-6 L=1e-6
mpway25_cell53 ML25 gate_way25_cell53 GND ML25 p1 W=2.4e-6 L=1e-6
mnway25_cell54 ML25 gate_way25_cell54 GND GND n1 W=1e-6 L=1e-6
mpway25_cell54 ML25 gate_way25_cell54 GND ML25 p1 W=2.4e-6 L=1e-6
mnway25_cell55 ML25 gate_way25_cell55 GND GND n1 W=1e-6 L=1e-6
mpway25_cell55 ML25 gate_way25_cell55 GND ML25 p1 W=2.4e-6 L=1e-6
mnway25_cell56 ML25 gate_way25_cell56 GND GND n1 W=1e-6 L=1e-6
mpway25_cell56 ML25 gate_way25_cell56 GND ML25 p1 W=2.4e-6 L=1e-6
mnway25_cell57 ML25 gate_way25_cell57 GND GND n1 W=1e-6 L=1e-6
mpway25_cell57 ML25 gate_way25_cell57 GND ML25 p1 W=2.4e-6 L=1e-6
mnway25_cell58 ML25 gate_way25_cell58 GND GND n1 W=1e-6 L=1e-6
mpway25_cell58 ML25 gate_way25_cell58 GND ML25 p1 W=2.4e-6 L=1e-6
mnway25_cell59 ML25 gate_way25_cell59 GND GND n1 W=1e-6 L=1e-6
mpway25_cell59 ML25 gate_way25_cell59 GND ML25 p1 W=2.4e-6 L=1e-6
mnway25_cell60 ML25 gate_way25_cell60 GND GND n1 W=1e-6 L=1e-6
mpway25_cell60 ML25 gate_way25_cell60 GND ML25 p1 W=2.4e-6 L=1e-6
mnway25_cell61 ML25 gate_way25_cell61 GND GND n1 W=1e-6 L=1e-6
mpway25_cell61 ML25 gate_way25_cell61 GND ML25 p1 W=2.4e-6 L=1e-6
mnway25_cell62 ML25 gate_way25_cell62 GND GND n1 W=1e-6 L=1e-6
mpway25_cell62 ML25 gate_way25_cell62 GND ML25 p1 W=2.4e-6 L=1e-6
mnway25_cell63 ML25 gate_way25_cell63 GND GND n1 W=1e-6 L=1e-6
mpway25_cell63 ML25 gate_way25_cell63 GND ML25 p1 W=2.4e-6 L=1e-6
mnway25_cell64 ML25 gate_way25_cell64 GND GND n1 W=1e-6 L=1e-6
mpway25_cell64 ML25 gate_way25_cell64 GND ML25 p1 W=2.4e-6 L=1e-6
mnway25_cell65 ML25 gate_way25_cell65 GND GND n1 W=1e-6 L=1e-6
mpway25_cell65 ML25 gate_way25_cell65 GND ML25 p1 W=2.4e-6 L=1e-6
mnway25_cell66 ML25 gate_way25_cell66 GND GND n1 W=1e-6 L=1e-6
mpway25_cell66 ML25 gate_way25_cell66 GND ML25 p1 W=2.4e-6 L=1e-6
mnway25_cell67 ML25 gate_way25_cell67 GND GND n1 W=1e-6 L=1e-6
mpway25_cell67 ML25 gate_way25_cell67 GND ML25 p1 W=2.4e-6 L=1e-6
mnway25_cell68 ML25 gate_way25_cell68 GND GND n1 W=1e-6 L=1e-6
mpway25_cell68 ML25 gate_way25_cell68 GND ML25 p1 W=2.4e-6 L=1e-6
mnway25_cell69 ML25 gate_way25_cell69 GND GND n1 W=1e-6 L=1e-6
mpway25_cell69 ML25 gate_way25_cell69 GND ML25 p1 W=2.4e-6 L=1e-6
mnway25_cell70 ML25 gate_way25_cell70 GND GND n1 W=1e-6 L=1e-6
mpway25_cell70 ML25 gate_way25_cell70 GND ML25 p1 W=2.4e-6 L=1e-6
mnway25_cell71 ML25 gate_way25_cell71 GND GND n1 W=1e-6 L=1e-6
mpway25_cell71 ML25 gate_way25_cell71 GND ML25 p1 W=2.4e-6 L=1e-6
mnway25_cell72 ML25 gate_way25_cell72 GND GND n1 W=1e-6 L=1e-6
mpway25_cell72 ML25 gate_way25_cell72 GND ML25 p1 W=2.4e-6 L=1e-6
mnway25_cell73 ML25 gate_way25_cell73 GND GND n1 W=1e-6 L=1e-6
mpway25_cell73 ML25 gate_way25_cell73 GND ML25 p1 W=2.4e-6 L=1e-6
mnway25_cell74 ML25 gate_way25_cell74 GND GND n1 W=1e-6 L=1e-6
mpway25_cell74 ML25 gate_way25_cell74 GND ML25 p1 W=2.4e-6 L=1e-6
mnway25_cell75 ML25 gate_way25_cell75 GND GND n1 W=1e-6 L=1e-6
mpway25_cell75 ML25 gate_way25_cell75 GND ML25 p1 W=2.4e-6 L=1e-6
mnway25_cell76 ML25 gate_way25_cell76 GND GND n1 W=1e-6 L=1e-6
mpway25_cell76 ML25 gate_way25_cell76 GND ML25 p1 W=2.4e-6 L=1e-6
mnway25_cell77 ML25 gate_way25_cell77 GND GND n1 W=1e-6 L=1e-6
mpway25_cell77 ML25 gate_way25_cell77 GND ML25 p1 W=2.4e-6 L=1e-6
mnway25_cell78 ML25 gate_way25_cell78 GND GND n1 W=1e-6 L=1e-6
mpway25_cell78 ML25 gate_way25_cell78 GND ML25 p1 W=2.4e-6 L=1e-6
mnway25_cell79 ML25 gate_way25_cell79 GND GND n1 W=1e-6 L=1e-6
mpway25_cell79 ML25 gate_way25_cell79 GND ML25 p1 W=2.4e-6 L=1e-6
mnway25_cell80 ML25 gate_way25_cell80 GND GND n1 W=1e-6 L=1e-6
mpway25_cell80 ML25 gate_way25_cell80 GND ML25 p1 W=2.4e-6 L=1e-6
mnway25_cell81 ML25 gate_way25_cell81 GND GND n1 W=1e-6 L=1e-6
mpway25_cell81 ML25 gate_way25_cell81 GND ML25 p1 W=2.4e-6 L=1e-6
mnway25_cell82 ML25 gate_way25_cell82 GND GND n1 W=1e-6 L=1e-6
mpway25_cell82 ML25 gate_way25_cell82 GND ML25 p1 W=2.4e-6 L=1e-6
mnway25_cell83 ML25 gate_way25_cell83 GND GND n1 W=1e-6 L=1e-6
mpway25_cell83 ML25 gate_way25_cell83 GND ML25 p1 W=2.4e-6 L=1e-6
mnway25_cell84 ML25 gate_way25_cell84 GND GND n1 W=1e-6 L=1e-6
mpway25_cell84 ML25 gate_way25_cell84 GND ML25 p1 W=2.4e-6 L=1e-6
mnway25_cell85 ML25 gate_way25_cell85 GND GND n1 W=1e-6 L=1e-6
mpway25_cell85 ML25 gate_way25_cell85 GND ML25 p1 W=2.4e-6 L=1e-6
mnway25_cell86 ML25 gate_way25_cell86 GND GND n1 W=1e-6 L=1e-6
mpway25_cell86 ML25 gate_way25_cell86 GND ML25 p1 W=2.4e-6 L=1e-6
mnway25_cell87 ML25 gate_way25_cell87 GND GND n1 W=1e-6 L=1e-6
mpway25_cell87 ML25 gate_way25_cell87 GND ML25 p1 W=2.4e-6 L=1e-6
mnway25_cell88 ML25 gate_way25_cell88 GND GND n1 W=1e-6 L=1e-6
mpway25_cell88 ML25 gate_way25_cell88 GND ML25 p1 W=2.4e-6 L=1e-6
mnway25_cell89 ML25 gate_way25_cell89 GND GND n1 W=1e-6 L=1e-6
mpway25_cell89 ML25 gate_way25_cell89 GND ML25 p1 W=2.4e-6 L=1e-6
mnway25_cell90 ML25 gate_way25_cell90 GND GND n1 W=1e-6 L=1e-6
mpway25_cell90 ML25 gate_way25_cell90 GND ML25 p1 W=2.4e-6 L=1e-6
mnway25_cell91 ML25 gate_way25_cell91 GND GND n1 W=1e-6 L=1e-6
mpway25_cell91 ML25 gate_way25_cell91 GND ML25 p1 W=2.4e-6 L=1e-6
mnway25_cell92 ML25 gate_way25_cell92 GND GND n1 W=1e-6 L=1e-6
mpway25_cell92 ML25 gate_way25_cell92 GND ML25 p1 W=2.4e-6 L=1e-6
mnway25_cell93 ML25 gate_way25_cell93 GND GND n1 W=1e-6 L=1e-6
mpway25_cell93 ML25 gate_way25_cell93 GND ML25 p1 W=2.4e-6 L=1e-6
mnway25_cell94 ML25 gate_way25_cell94 GND GND n1 W=1e-6 L=1e-6
mpway25_cell94 ML25 gate_way25_cell94 GND ML25 p1 W=2.4e-6 L=1e-6
mnway25_cell95 ML25 gate_way25_cell95 GND GND n1 W=1e-6 L=1e-6
mpway25_cell95 ML25 gate_way25_cell95 GND ML25 p1 W=2.4e-6 L=1e-6
mnway25_cell96 ML25 gate_way25_cell96 GND GND n1 W=1e-6 L=1e-6
mpway25_cell96 ML25 gate_way25_cell96 GND ML25 p1 W=2.4e-6 L=1e-6
mnway25_cell97 ML25 gate_way25_cell97 GND GND n1 W=1e-6 L=1e-6
mpway25_cell97 ML25 gate_way25_cell97 GND ML25 p1 W=2.4e-6 L=1e-6
mnway25_cell98 ML25 gate_way25_cell98 GND GND n1 W=1e-6 L=1e-6
mpway25_cell98 ML25 gate_way25_cell98 GND ML25 p1 W=2.4e-6 L=1e-6
mnway25_cell99 ML25 gate_way25_cell99 GND GND n1 W=1e-6 L=1e-6
mpway25_cell99 ML25 gate_way25_cell99 GND ML25 p1 W=2.4e-6 L=1e-6
mnway26_cell0 ML26 gate_way26_cell0 GND GND n1 W=1e-6 L=1e-6
mpway26_cell0 ML26 gate_way26_cell0 GND ML26 p1 W=2.4e-6 L=1e-6
mnway26_cell1 ML26 gate_way26_cell1 GND GND n1 W=1e-6 L=1e-6
mpway26_cell1 ML26 gate_way26_cell1 GND ML26 p1 W=2.4e-6 L=1e-6
mnway26_cell2 ML26 gate_way26_cell2 GND GND n1 W=1e-6 L=1e-6
mpway26_cell2 ML26 gate_way26_cell2 GND ML26 p1 W=2.4e-6 L=1e-6
mnway26_cell3 ML26 gate_way26_cell3 GND GND n1 W=1e-6 L=1e-6
mpway26_cell3 ML26 gate_way26_cell3 GND ML26 p1 W=2.4e-6 L=1e-6
mnway26_cell4 ML26 gate_way26_cell4 GND GND n1 W=1e-6 L=1e-6
mpway26_cell4 ML26 gate_way26_cell4 GND ML26 p1 W=2.4e-6 L=1e-6
mnway26_cell5 ML26 gate_way26_cell5 GND GND n1 W=1e-6 L=1e-6
mpway26_cell5 ML26 gate_way26_cell5 GND ML26 p1 W=2.4e-6 L=1e-6
mnway26_cell6 ML26 gate_way26_cell6 GND GND n1 W=1e-6 L=1e-6
mpway26_cell6 ML26 gate_way26_cell6 GND ML26 p1 W=2.4e-6 L=1e-6
mnway26_cell7 ML26 gate_way26_cell7 GND GND n1 W=1e-6 L=1e-6
mpway26_cell7 ML26 gate_way26_cell7 GND ML26 p1 W=2.4e-6 L=1e-6
mnway26_cell8 ML26 gate_way26_cell8 GND GND n1 W=1e-6 L=1e-6
mpway26_cell8 ML26 gate_way26_cell8 GND ML26 p1 W=2.4e-6 L=1e-6
mnway26_cell9 ML26 gate_way26_cell9 GND GND n1 W=1e-6 L=1e-6
mpway26_cell9 ML26 gate_way26_cell9 GND ML26 p1 W=2.4e-6 L=1e-6
mnway26_cell10 ML26 gate_way26_cell10 GND GND n1 W=1e-6 L=1e-6
mpway26_cell10 ML26 gate_way26_cell10 GND ML26 p1 W=2.4e-6 L=1e-6
mnway26_cell11 ML26 gate_way26_cell11 GND GND n1 W=1e-6 L=1e-6
mpway26_cell11 ML26 gate_way26_cell11 GND ML26 p1 W=2.4e-6 L=1e-6
mnway26_cell12 ML26 gate_way26_cell12 GND GND n1 W=1e-6 L=1e-6
mpway26_cell12 ML26 gate_way26_cell12 GND ML26 p1 W=2.4e-6 L=1e-6
mnway26_cell13 ML26 gate_way26_cell13 GND GND n1 W=1e-6 L=1e-6
mpway26_cell13 ML26 gate_way26_cell13 GND ML26 p1 W=2.4e-6 L=1e-6
mnway26_cell14 ML26 gate_way26_cell14 GND GND n1 W=1e-6 L=1e-6
mpway26_cell14 ML26 gate_way26_cell14 GND ML26 p1 W=2.4e-6 L=1e-6
mnway26_cell15 ML26 gate_way26_cell15 GND GND n1 W=1e-6 L=1e-6
mpway26_cell15 ML26 gate_way26_cell15 GND ML26 p1 W=2.4e-6 L=1e-6
mnway26_cell16 ML26 gate_way26_cell16 GND GND n1 W=1e-6 L=1e-6
mpway26_cell16 ML26 gate_way26_cell16 GND ML26 p1 W=2.4e-6 L=1e-6
mnway26_cell17 ML26 gate_way26_cell17 GND GND n1 W=1e-6 L=1e-6
mpway26_cell17 ML26 gate_way26_cell17 GND ML26 p1 W=2.4e-6 L=1e-6
mnway26_cell18 ML26 gate_way26_cell18 GND GND n1 W=1e-6 L=1e-6
mpway26_cell18 ML26 gate_way26_cell18 GND ML26 p1 W=2.4e-6 L=1e-6
mnway26_cell19 ML26 gate_way26_cell19 GND GND n1 W=1e-6 L=1e-6
mpway26_cell19 ML26 gate_way26_cell19 GND ML26 p1 W=2.4e-6 L=1e-6
mnway26_cell20 ML26 gate_way26_cell20 GND GND n1 W=1e-6 L=1e-6
mpway26_cell20 ML26 gate_way26_cell20 GND ML26 p1 W=2.4e-6 L=1e-6
mnway26_cell21 ML26 gate_way26_cell21 GND GND n1 W=1e-6 L=1e-6
mpway26_cell21 ML26 gate_way26_cell21 GND ML26 p1 W=2.4e-6 L=1e-6
mnway26_cell22 ML26 gate_way26_cell22 GND GND n1 W=1e-6 L=1e-6
mpway26_cell22 ML26 gate_way26_cell22 GND ML26 p1 W=2.4e-6 L=1e-6
mnway26_cell23 ML26 gate_way26_cell23 GND GND n1 W=1e-6 L=1e-6
mpway26_cell23 ML26 gate_way26_cell23 GND ML26 p1 W=2.4e-6 L=1e-6
mnway26_cell24 ML26 gate_way26_cell24 GND GND n1 W=1e-6 L=1e-6
mpway26_cell24 ML26 gate_way26_cell24 GND ML26 p1 W=2.4e-6 L=1e-6
mnway26_cell25 ML26 gate_way26_cell25 GND GND n1 W=1e-6 L=1e-6
mpway26_cell25 ML26 gate_way26_cell25 GND ML26 p1 W=2.4e-6 L=1e-6
mnway26_cell26 ML26 gate_way26_cell26 GND GND n1 W=1e-6 L=1e-6
mpway26_cell26 ML26 gate_way26_cell26 GND ML26 p1 W=2.4e-6 L=1e-6
mnway26_cell27 ML26 gate_way26_cell27 GND GND n1 W=1e-6 L=1e-6
mpway26_cell27 ML26 gate_way26_cell27 GND ML26 p1 W=2.4e-6 L=1e-6
mnway26_cell28 ML26 gate_way26_cell28 GND GND n1 W=1e-6 L=1e-6
mpway26_cell28 ML26 gate_way26_cell28 GND ML26 p1 W=2.4e-6 L=1e-6
mnway26_cell29 ML26 gate_way26_cell29 GND GND n1 W=1e-6 L=1e-6
mpway26_cell29 ML26 gate_way26_cell29 GND ML26 p1 W=2.4e-6 L=1e-6
mnway26_cell30 ML26 gate_way26_cell30 GND GND n1 W=1e-6 L=1e-6
mpway26_cell30 ML26 gate_way26_cell30 GND ML26 p1 W=2.4e-6 L=1e-6
mnway26_cell31 ML26 gate_way26_cell31 GND GND n1 W=1e-6 L=1e-6
mpway26_cell31 ML26 gate_way26_cell31 GND ML26 p1 W=2.4e-6 L=1e-6
mnway26_cell32 ML26 gate_way26_cell32 GND GND n1 W=1e-6 L=1e-6
mpway26_cell32 ML26 gate_way26_cell32 GND ML26 p1 W=2.4e-6 L=1e-6
mnway26_cell33 ML26 gate_way26_cell33 GND GND n1 W=1e-6 L=1e-6
mpway26_cell33 ML26 gate_way26_cell33 GND ML26 p1 W=2.4e-6 L=1e-6
mnway26_cell34 ML26 gate_way26_cell34 GND GND n1 W=1e-6 L=1e-6
mpway26_cell34 ML26 gate_way26_cell34 GND ML26 p1 W=2.4e-6 L=1e-6
mnway26_cell35 ML26 gate_way26_cell35 GND GND n1 W=1e-6 L=1e-6
mpway26_cell35 ML26 gate_way26_cell35 GND ML26 p1 W=2.4e-6 L=1e-6
mnway26_cell36 ML26 gate_way26_cell36 GND GND n1 W=1e-6 L=1e-6
mpway26_cell36 ML26 gate_way26_cell36 GND ML26 p1 W=2.4e-6 L=1e-6
mnway26_cell37 ML26 gate_way26_cell37 GND GND n1 W=1e-6 L=1e-6
mpway26_cell37 ML26 gate_way26_cell37 GND ML26 p1 W=2.4e-6 L=1e-6
mnway26_cell38 ML26 gate_way26_cell38 GND GND n1 W=1e-6 L=1e-6
mpway26_cell38 ML26 gate_way26_cell38 GND ML26 p1 W=2.4e-6 L=1e-6
mnway26_cell39 ML26 gate_way26_cell39 GND GND n1 W=1e-6 L=1e-6
mpway26_cell39 ML26 gate_way26_cell39 GND ML26 p1 W=2.4e-6 L=1e-6
mnway26_cell40 ML26 gate_way26_cell40 GND GND n1 W=1e-6 L=1e-6
mpway26_cell40 ML26 gate_way26_cell40 GND ML26 p1 W=2.4e-6 L=1e-6
mnway26_cell41 ML26 gate_way26_cell41 GND GND n1 W=1e-6 L=1e-6
mpway26_cell41 ML26 gate_way26_cell41 GND ML26 p1 W=2.4e-6 L=1e-6
mnway26_cell42 ML26 gate_way26_cell42 GND GND n1 W=1e-6 L=1e-6
mpway26_cell42 ML26 gate_way26_cell42 GND ML26 p1 W=2.4e-6 L=1e-6
mnway26_cell43 ML26 gate_way26_cell43 GND GND n1 W=1e-6 L=1e-6
mpway26_cell43 ML26 gate_way26_cell43 GND ML26 p1 W=2.4e-6 L=1e-6
mnway26_cell44 ML26 gate_way26_cell44 GND GND n1 W=1e-6 L=1e-6
mpway26_cell44 ML26 gate_way26_cell44 GND ML26 p1 W=2.4e-6 L=1e-6
mnway26_cell45 ML26 gate_way26_cell45 GND GND n1 W=1e-6 L=1e-6
mpway26_cell45 ML26 gate_way26_cell45 GND ML26 p1 W=2.4e-6 L=1e-6
mnway26_cell46 ML26 gate_way26_cell46 GND GND n1 W=1e-6 L=1e-6
mpway26_cell46 ML26 gate_way26_cell46 GND ML26 p1 W=2.4e-6 L=1e-6
mnway26_cell47 ML26 gate_way26_cell47 GND GND n1 W=1e-6 L=1e-6
mpway26_cell47 ML26 gate_way26_cell47 GND ML26 p1 W=2.4e-6 L=1e-6
mnway26_cell48 ML26 gate_way26_cell48 GND GND n1 W=1e-6 L=1e-6
mpway26_cell48 ML26 gate_way26_cell48 GND ML26 p1 W=2.4e-6 L=1e-6
mnway26_cell49 ML26 gate_way26_cell49 GND GND n1 W=1e-6 L=1e-6
mpway26_cell49 ML26 gate_way26_cell49 GND ML26 p1 W=2.4e-6 L=1e-6
mnway26_cell50 ML26 gate_way26_cell50 GND GND n1 W=1e-6 L=1e-6
mpway26_cell50 ML26 gate_way26_cell50 GND ML26 p1 W=2.4e-6 L=1e-6
mnway26_cell51 ML26 gate_way26_cell51 GND GND n1 W=1e-6 L=1e-6
mpway26_cell51 ML26 gate_way26_cell51 GND ML26 p1 W=2.4e-6 L=1e-6
mnway26_cell52 ML26 gate_way26_cell52 GND GND n1 W=1e-6 L=1e-6
mpway26_cell52 ML26 gate_way26_cell52 GND ML26 p1 W=2.4e-6 L=1e-6
mnway26_cell53 ML26 gate_way26_cell53 GND GND n1 W=1e-6 L=1e-6
mpway26_cell53 ML26 gate_way26_cell53 GND ML26 p1 W=2.4e-6 L=1e-6
mnway26_cell54 ML26 gate_way26_cell54 GND GND n1 W=1e-6 L=1e-6
mpway26_cell54 ML26 gate_way26_cell54 GND ML26 p1 W=2.4e-6 L=1e-6
mnway26_cell55 ML26 gate_way26_cell55 GND GND n1 W=1e-6 L=1e-6
mpway26_cell55 ML26 gate_way26_cell55 GND ML26 p1 W=2.4e-6 L=1e-6
mnway26_cell56 ML26 gate_way26_cell56 GND GND n1 W=1e-6 L=1e-6
mpway26_cell56 ML26 gate_way26_cell56 GND ML26 p1 W=2.4e-6 L=1e-6
mnway26_cell57 ML26 gate_way26_cell57 GND GND n1 W=1e-6 L=1e-6
mpway26_cell57 ML26 gate_way26_cell57 GND ML26 p1 W=2.4e-6 L=1e-6
mnway26_cell58 ML26 gate_way26_cell58 GND GND n1 W=1e-6 L=1e-6
mpway26_cell58 ML26 gate_way26_cell58 GND ML26 p1 W=2.4e-6 L=1e-6
mnway26_cell59 ML26 gate_way26_cell59 GND GND n1 W=1e-6 L=1e-6
mpway26_cell59 ML26 gate_way26_cell59 GND ML26 p1 W=2.4e-6 L=1e-6
mnway26_cell60 ML26 gate_way26_cell60 GND GND n1 W=1e-6 L=1e-6
mpway26_cell60 ML26 gate_way26_cell60 GND ML26 p1 W=2.4e-6 L=1e-6
mnway26_cell61 ML26 gate_way26_cell61 GND GND n1 W=1e-6 L=1e-6
mpway26_cell61 ML26 gate_way26_cell61 GND ML26 p1 W=2.4e-6 L=1e-6
mnway26_cell62 ML26 gate_way26_cell62 GND GND n1 W=1e-6 L=1e-6
mpway26_cell62 ML26 gate_way26_cell62 GND ML26 p1 W=2.4e-6 L=1e-6
mnway26_cell63 ML26 gate_way26_cell63 GND GND n1 W=1e-6 L=1e-6
mpway26_cell63 ML26 gate_way26_cell63 GND ML26 p1 W=2.4e-6 L=1e-6
mnway26_cell64 ML26 gate_way26_cell64 GND GND n1 W=1e-6 L=1e-6
mpway26_cell64 ML26 gate_way26_cell64 GND ML26 p1 W=2.4e-6 L=1e-6
mnway26_cell65 ML26 gate_way26_cell65 GND GND n1 W=1e-6 L=1e-6
mpway26_cell65 ML26 gate_way26_cell65 GND ML26 p1 W=2.4e-6 L=1e-6
mnway26_cell66 ML26 gate_way26_cell66 GND GND n1 W=1e-6 L=1e-6
mpway26_cell66 ML26 gate_way26_cell66 GND ML26 p1 W=2.4e-6 L=1e-6
mnway26_cell67 ML26 gate_way26_cell67 GND GND n1 W=1e-6 L=1e-6
mpway26_cell67 ML26 gate_way26_cell67 GND ML26 p1 W=2.4e-6 L=1e-6
mnway26_cell68 ML26 gate_way26_cell68 GND GND n1 W=1e-6 L=1e-6
mpway26_cell68 ML26 gate_way26_cell68 GND ML26 p1 W=2.4e-6 L=1e-6
mnway26_cell69 ML26 gate_way26_cell69 GND GND n1 W=1e-6 L=1e-6
mpway26_cell69 ML26 gate_way26_cell69 GND ML26 p1 W=2.4e-6 L=1e-6
mnway26_cell70 ML26 gate_way26_cell70 GND GND n1 W=1e-6 L=1e-6
mpway26_cell70 ML26 gate_way26_cell70 GND ML26 p1 W=2.4e-6 L=1e-6
mnway26_cell71 ML26 gate_way26_cell71 GND GND n1 W=1e-6 L=1e-6
mpway26_cell71 ML26 gate_way26_cell71 GND ML26 p1 W=2.4e-6 L=1e-6
mnway26_cell72 ML26 gate_way26_cell72 GND GND n1 W=1e-6 L=1e-6
mpway26_cell72 ML26 gate_way26_cell72 GND ML26 p1 W=2.4e-6 L=1e-6
mnway26_cell73 ML26 gate_way26_cell73 GND GND n1 W=1e-6 L=1e-6
mpway26_cell73 ML26 gate_way26_cell73 GND ML26 p1 W=2.4e-6 L=1e-6
mnway26_cell74 ML26 gate_way26_cell74 GND GND n1 W=1e-6 L=1e-6
mpway26_cell74 ML26 gate_way26_cell74 GND ML26 p1 W=2.4e-6 L=1e-6
mnway26_cell75 ML26 gate_way26_cell75 GND GND n1 W=1e-6 L=1e-6
mpway26_cell75 ML26 gate_way26_cell75 GND ML26 p1 W=2.4e-6 L=1e-6
mnway26_cell76 ML26 gate_way26_cell76 GND GND n1 W=1e-6 L=1e-6
mpway26_cell76 ML26 gate_way26_cell76 GND ML26 p1 W=2.4e-6 L=1e-6
mnway26_cell77 ML26 gate_way26_cell77 GND GND n1 W=1e-6 L=1e-6
mpway26_cell77 ML26 gate_way26_cell77 GND ML26 p1 W=2.4e-6 L=1e-6
mnway26_cell78 ML26 gate_way26_cell78 GND GND n1 W=1e-6 L=1e-6
mpway26_cell78 ML26 gate_way26_cell78 GND ML26 p1 W=2.4e-6 L=1e-6
mnway26_cell79 ML26 gate_way26_cell79 GND GND n1 W=1e-6 L=1e-6
mpway26_cell79 ML26 gate_way26_cell79 GND ML26 p1 W=2.4e-6 L=1e-6
mnway26_cell80 ML26 gate_way26_cell80 GND GND n1 W=1e-6 L=1e-6
mpway26_cell80 ML26 gate_way26_cell80 GND ML26 p1 W=2.4e-6 L=1e-6
mnway26_cell81 ML26 gate_way26_cell81 GND GND n1 W=1e-6 L=1e-6
mpway26_cell81 ML26 gate_way26_cell81 GND ML26 p1 W=2.4e-6 L=1e-6
mnway26_cell82 ML26 gate_way26_cell82 GND GND n1 W=1e-6 L=1e-6
mpway26_cell82 ML26 gate_way26_cell82 GND ML26 p1 W=2.4e-6 L=1e-6
mnway26_cell83 ML26 gate_way26_cell83 GND GND n1 W=1e-6 L=1e-6
mpway26_cell83 ML26 gate_way26_cell83 GND ML26 p1 W=2.4e-6 L=1e-6
mnway26_cell84 ML26 gate_way26_cell84 GND GND n1 W=1e-6 L=1e-6
mpway26_cell84 ML26 gate_way26_cell84 GND ML26 p1 W=2.4e-6 L=1e-6
mnway26_cell85 ML26 gate_way26_cell85 GND GND n1 W=1e-6 L=1e-6
mpway26_cell85 ML26 gate_way26_cell85 GND ML26 p1 W=2.4e-6 L=1e-6
mnway26_cell86 ML26 gate_way26_cell86 GND GND n1 W=1e-6 L=1e-6
mpway26_cell86 ML26 gate_way26_cell86 GND ML26 p1 W=2.4e-6 L=1e-6
mnway26_cell87 ML26 gate_way26_cell87 GND GND n1 W=1e-6 L=1e-6
mpway26_cell87 ML26 gate_way26_cell87 GND ML26 p1 W=2.4e-6 L=1e-6
mnway26_cell88 ML26 gate_way26_cell88 GND GND n1 W=1e-6 L=1e-6
mpway26_cell88 ML26 gate_way26_cell88 GND ML26 p1 W=2.4e-6 L=1e-6
mnway26_cell89 ML26 gate_way26_cell89 GND GND n1 W=1e-6 L=1e-6
mpway26_cell89 ML26 gate_way26_cell89 GND ML26 p1 W=2.4e-6 L=1e-6
mnway26_cell90 ML26 gate_way26_cell90 GND GND n1 W=1e-6 L=1e-6
mpway26_cell90 ML26 gate_way26_cell90 GND ML26 p1 W=2.4e-6 L=1e-6
mnway26_cell91 ML26 gate_way26_cell91 GND GND n1 W=1e-6 L=1e-6
mpway26_cell91 ML26 gate_way26_cell91 GND ML26 p1 W=2.4e-6 L=1e-6
mnway26_cell92 ML26 gate_way26_cell92 GND GND n1 W=1e-6 L=1e-6
mpway26_cell92 ML26 gate_way26_cell92 GND ML26 p1 W=2.4e-6 L=1e-6
mnway26_cell93 ML26 gate_way26_cell93 GND GND n1 W=1e-6 L=1e-6
mpway26_cell93 ML26 gate_way26_cell93 GND ML26 p1 W=2.4e-6 L=1e-6
mnway26_cell94 ML26 gate_way26_cell94 GND GND n1 W=1e-6 L=1e-6
mpway26_cell94 ML26 gate_way26_cell94 GND ML26 p1 W=2.4e-6 L=1e-6
mnway26_cell95 ML26 gate_way26_cell95 GND GND n1 W=1e-6 L=1e-6
mpway26_cell95 ML26 gate_way26_cell95 GND ML26 p1 W=2.4e-6 L=1e-6
mnway26_cell96 ML26 gate_way26_cell96 GND GND n1 W=1e-6 L=1e-6
mpway26_cell96 ML26 gate_way26_cell96 GND ML26 p1 W=2.4e-6 L=1e-6
mnway26_cell97 ML26 gate_way26_cell97 GND GND n1 W=1e-6 L=1e-6
mpway26_cell97 ML26 gate_way26_cell97 GND ML26 p1 W=2.4e-6 L=1e-6
mnway26_cell98 ML26 gate_way26_cell98 GND GND n1 W=1e-6 L=1e-6
mpway26_cell98 ML26 gate_way26_cell98 GND ML26 p1 W=2.4e-6 L=1e-6
mnway26_cell99 ML26 gate_way26_cell99 GND GND n1 W=1e-6 L=1e-6
mpway26_cell99 ML26 gate_way26_cell99 GND ML26 p1 W=2.4e-6 L=1e-6
mnway27_cell0 ML27 gate_way27_cell0 GND GND n1 W=1e-6 L=1e-6
mpway27_cell0 ML27 gate_way27_cell0 GND ML27 p1 W=2.4e-6 L=1e-6
mnway27_cell1 ML27 gate_way27_cell1 GND GND n1 W=1e-6 L=1e-6
mpway27_cell1 ML27 gate_way27_cell1 GND ML27 p1 W=2.4e-6 L=1e-6
mnway27_cell2 ML27 gate_way27_cell2 GND GND n1 W=1e-6 L=1e-6
mpway27_cell2 ML27 gate_way27_cell2 GND ML27 p1 W=2.4e-6 L=1e-6
mnway27_cell3 ML27 gate_way27_cell3 GND GND n1 W=1e-6 L=1e-6
mpway27_cell3 ML27 gate_way27_cell3 GND ML27 p1 W=2.4e-6 L=1e-6
mnway27_cell4 ML27 gate_way27_cell4 GND GND n1 W=1e-6 L=1e-6
mpway27_cell4 ML27 gate_way27_cell4 GND ML27 p1 W=2.4e-6 L=1e-6
mnway27_cell5 ML27 gate_way27_cell5 GND GND n1 W=1e-6 L=1e-6
mpway27_cell5 ML27 gate_way27_cell5 GND ML27 p1 W=2.4e-6 L=1e-6
mnway27_cell6 ML27 gate_way27_cell6 GND GND n1 W=1e-6 L=1e-6
mpway27_cell6 ML27 gate_way27_cell6 GND ML27 p1 W=2.4e-6 L=1e-6
mnway27_cell7 ML27 gate_way27_cell7 GND GND n1 W=1e-6 L=1e-6
mpway27_cell7 ML27 gate_way27_cell7 GND ML27 p1 W=2.4e-6 L=1e-6
mnway27_cell8 ML27 gate_way27_cell8 GND GND n1 W=1e-6 L=1e-6
mpway27_cell8 ML27 gate_way27_cell8 GND ML27 p1 W=2.4e-6 L=1e-6
mnway27_cell9 ML27 gate_way27_cell9 GND GND n1 W=1e-6 L=1e-6
mpway27_cell9 ML27 gate_way27_cell9 GND ML27 p1 W=2.4e-6 L=1e-6
mnway27_cell10 ML27 gate_way27_cell10 GND GND n1 W=1e-6 L=1e-6
mpway27_cell10 ML27 gate_way27_cell10 GND ML27 p1 W=2.4e-6 L=1e-6
mnway27_cell11 ML27 gate_way27_cell11 GND GND n1 W=1e-6 L=1e-6
mpway27_cell11 ML27 gate_way27_cell11 GND ML27 p1 W=2.4e-6 L=1e-6
mnway27_cell12 ML27 gate_way27_cell12 GND GND n1 W=1e-6 L=1e-6
mpway27_cell12 ML27 gate_way27_cell12 GND ML27 p1 W=2.4e-6 L=1e-6
mnway27_cell13 ML27 gate_way27_cell13 GND GND n1 W=1e-6 L=1e-6
mpway27_cell13 ML27 gate_way27_cell13 GND ML27 p1 W=2.4e-6 L=1e-6
mnway27_cell14 ML27 gate_way27_cell14 GND GND n1 W=1e-6 L=1e-6
mpway27_cell14 ML27 gate_way27_cell14 GND ML27 p1 W=2.4e-6 L=1e-6
mnway27_cell15 ML27 gate_way27_cell15 GND GND n1 W=1e-6 L=1e-6
mpway27_cell15 ML27 gate_way27_cell15 GND ML27 p1 W=2.4e-6 L=1e-6
mnway27_cell16 ML27 gate_way27_cell16 GND GND n1 W=1e-6 L=1e-6
mpway27_cell16 ML27 gate_way27_cell16 GND ML27 p1 W=2.4e-6 L=1e-6
mnway27_cell17 ML27 gate_way27_cell17 GND GND n1 W=1e-6 L=1e-6
mpway27_cell17 ML27 gate_way27_cell17 GND ML27 p1 W=2.4e-6 L=1e-6
mnway27_cell18 ML27 gate_way27_cell18 GND GND n1 W=1e-6 L=1e-6
mpway27_cell18 ML27 gate_way27_cell18 GND ML27 p1 W=2.4e-6 L=1e-6
mnway27_cell19 ML27 gate_way27_cell19 GND GND n1 W=1e-6 L=1e-6
mpway27_cell19 ML27 gate_way27_cell19 GND ML27 p1 W=2.4e-6 L=1e-6
mnway27_cell20 ML27 gate_way27_cell20 GND GND n1 W=1e-6 L=1e-6
mpway27_cell20 ML27 gate_way27_cell20 GND ML27 p1 W=2.4e-6 L=1e-6
mnway27_cell21 ML27 gate_way27_cell21 GND GND n1 W=1e-6 L=1e-6
mpway27_cell21 ML27 gate_way27_cell21 GND ML27 p1 W=2.4e-6 L=1e-6
mnway27_cell22 ML27 gate_way27_cell22 GND GND n1 W=1e-6 L=1e-6
mpway27_cell22 ML27 gate_way27_cell22 GND ML27 p1 W=2.4e-6 L=1e-6
mnway27_cell23 ML27 gate_way27_cell23 GND GND n1 W=1e-6 L=1e-6
mpway27_cell23 ML27 gate_way27_cell23 GND ML27 p1 W=2.4e-6 L=1e-6
mnway27_cell24 ML27 gate_way27_cell24 GND GND n1 W=1e-6 L=1e-6
mpway27_cell24 ML27 gate_way27_cell24 GND ML27 p1 W=2.4e-6 L=1e-6
mnway27_cell25 ML27 gate_way27_cell25 GND GND n1 W=1e-6 L=1e-6
mpway27_cell25 ML27 gate_way27_cell25 GND ML27 p1 W=2.4e-6 L=1e-6
mnway27_cell26 ML27 gate_way27_cell26 GND GND n1 W=1e-6 L=1e-6
mpway27_cell26 ML27 gate_way27_cell26 GND ML27 p1 W=2.4e-6 L=1e-6
mnway27_cell27 ML27 gate_way27_cell27 GND GND n1 W=1e-6 L=1e-6
mpway27_cell27 ML27 gate_way27_cell27 GND ML27 p1 W=2.4e-6 L=1e-6
mnway27_cell28 ML27 gate_way27_cell28 GND GND n1 W=1e-6 L=1e-6
mpway27_cell28 ML27 gate_way27_cell28 GND ML27 p1 W=2.4e-6 L=1e-6
mnway27_cell29 ML27 gate_way27_cell29 GND GND n1 W=1e-6 L=1e-6
mpway27_cell29 ML27 gate_way27_cell29 GND ML27 p1 W=2.4e-6 L=1e-6
mnway27_cell30 ML27 gate_way27_cell30 GND GND n1 W=1e-6 L=1e-6
mpway27_cell30 ML27 gate_way27_cell30 GND ML27 p1 W=2.4e-6 L=1e-6
mnway27_cell31 ML27 gate_way27_cell31 GND GND n1 W=1e-6 L=1e-6
mpway27_cell31 ML27 gate_way27_cell31 GND ML27 p1 W=2.4e-6 L=1e-6
mnway27_cell32 ML27 gate_way27_cell32 GND GND n1 W=1e-6 L=1e-6
mpway27_cell32 ML27 gate_way27_cell32 GND ML27 p1 W=2.4e-6 L=1e-6
mnway27_cell33 ML27 gate_way27_cell33 GND GND n1 W=1e-6 L=1e-6
mpway27_cell33 ML27 gate_way27_cell33 GND ML27 p1 W=2.4e-6 L=1e-6
mnway27_cell34 ML27 gate_way27_cell34 GND GND n1 W=1e-6 L=1e-6
mpway27_cell34 ML27 gate_way27_cell34 GND ML27 p1 W=2.4e-6 L=1e-6
mnway27_cell35 ML27 gate_way27_cell35 GND GND n1 W=1e-6 L=1e-6
mpway27_cell35 ML27 gate_way27_cell35 GND ML27 p1 W=2.4e-6 L=1e-6
mnway27_cell36 ML27 gate_way27_cell36 GND GND n1 W=1e-6 L=1e-6
mpway27_cell36 ML27 gate_way27_cell36 GND ML27 p1 W=2.4e-6 L=1e-6
mnway27_cell37 ML27 gate_way27_cell37 GND GND n1 W=1e-6 L=1e-6
mpway27_cell37 ML27 gate_way27_cell37 GND ML27 p1 W=2.4e-6 L=1e-6
mnway27_cell38 ML27 gate_way27_cell38 GND GND n1 W=1e-6 L=1e-6
mpway27_cell38 ML27 gate_way27_cell38 GND ML27 p1 W=2.4e-6 L=1e-6
mnway27_cell39 ML27 gate_way27_cell39 GND GND n1 W=1e-6 L=1e-6
mpway27_cell39 ML27 gate_way27_cell39 GND ML27 p1 W=2.4e-6 L=1e-6
mnway27_cell40 ML27 gate_way27_cell40 GND GND n1 W=1e-6 L=1e-6
mpway27_cell40 ML27 gate_way27_cell40 GND ML27 p1 W=2.4e-6 L=1e-6
mnway27_cell41 ML27 gate_way27_cell41 GND GND n1 W=1e-6 L=1e-6
mpway27_cell41 ML27 gate_way27_cell41 GND ML27 p1 W=2.4e-6 L=1e-6
mnway27_cell42 ML27 gate_way27_cell42 GND GND n1 W=1e-6 L=1e-6
mpway27_cell42 ML27 gate_way27_cell42 GND ML27 p1 W=2.4e-6 L=1e-6
mnway27_cell43 ML27 gate_way27_cell43 GND GND n1 W=1e-6 L=1e-6
mpway27_cell43 ML27 gate_way27_cell43 GND ML27 p1 W=2.4e-6 L=1e-6
mnway27_cell44 ML27 gate_way27_cell44 GND GND n1 W=1e-6 L=1e-6
mpway27_cell44 ML27 gate_way27_cell44 GND ML27 p1 W=2.4e-6 L=1e-6
mnway27_cell45 ML27 gate_way27_cell45 GND GND n1 W=1e-6 L=1e-6
mpway27_cell45 ML27 gate_way27_cell45 GND ML27 p1 W=2.4e-6 L=1e-6
mnway27_cell46 ML27 gate_way27_cell46 GND GND n1 W=1e-6 L=1e-6
mpway27_cell46 ML27 gate_way27_cell46 GND ML27 p1 W=2.4e-6 L=1e-6
mnway27_cell47 ML27 gate_way27_cell47 GND GND n1 W=1e-6 L=1e-6
mpway27_cell47 ML27 gate_way27_cell47 GND ML27 p1 W=2.4e-6 L=1e-6
mnway27_cell48 ML27 gate_way27_cell48 GND GND n1 W=1e-6 L=1e-6
mpway27_cell48 ML27 gate_way27_cell48 GND ML27 p1 W=2.4e-6 L=1e-6
mnway27_cell49 ML27 gate_way27_cell49 GND GND n1 W=1e-6 L=1e-6
mpway27_cell49 ML27 gate_way27_cell49 GND ML27 p1 W=2.4e-6 L=1e-6
mnway27_cell50 ML27 gate_way27_cell50 GND GND n1 W=1e-6 L=1e-6
mpway27_cell50 ML27 gate_way27_cell50 GND ML27 p1 W=2.4e-6 L=1e-6
mnway27_cell51 ML27 gate_way27_cell51 GND GND n1 W=1e-6 L=1e-6
mpway27_cell51 ML27 gate_way27_cell51 GND ML27 p1 W=2.4e-6 L=1e-6
mnway27_cell52 ML27 gate_way27_cell52 GND GND n1 W=1e-6 L=1e-6
mpway27_cell52 ML27 gate_way27_cell52 GND ML27 p1 W=2.4e-6 L=1e-6
mnway27_cell53 ML27 gate_way27_cell53 GND GND n1 W=1e-6 L=1e-6
mpway27_cell53 ML27 gate_way27_cell53 GND ML27 p1 W=2.4e-6 L=1e-6
mnway27_cell54 ML27 gate_way27_cell54 GND GND n1 W=1e-6 L=1e-6
mpway27_cell54 ML27 gate_way27_cell54 GND ML27 p1 W=2.4e-6 L=1e-6
mnway27_cell55 ML27 gate_way27_cell55 GND GND n1 W=1e-6 L=1e-6
mpway27_cell55 ML27 gate_way27_cell55 GND ML27 p1 W=2.4e-6 L=1e-6
mnway27_cell56 ML27 gate_way27_cell56 GND GND n1 W=1e-6 L=1e-6
mpway27_cell56 ML27 gate_way27_cell56 GND ML27 p1 W=2.4e-6 L=1e-6
mnway27_cell57 ML27 gate_way27_cell57 GND GND n1 W=1e-6 L=1e-6
mpway27_cell57 ML27 gate_way27_cell57 GND ML27 p1 W=2.4e-6 L=1e-6
mnway27_cell58 ML27 gate_way27_cell58 GND GND n1 W=1e-6 L=1e-6
mpway27_cell58 ML27 gate_way27_cell58 GND ML27 p1 W=2.4e-6 L=1e-6
mnway27_cell59 ML27 gate_way27_cell59 GND GND n1 W=1e-6 L=1e-6
mpway27_cell59 ML27 gate_way27_cell59 GND ML27 p1 W=2.4e-6 L=1e-6
mnway27_cell60 ML27 gate_way27_cell60 GND GND n1 W=1e-6 L=1e-6
mpway27_cell60 ML27 gate_way27_cell60 GND ML27 p1 W=2.4e-6 L=1e-6
mnway27_cell61 ML27 gate_way27_cell61 GND GND n1 W=1e-6 L=1e-6
mpway27_cell61 ML27 gate_way27_cell61 GND ML27 p1 W=2.4e-6 L=1e-6
mnway27_cell62 ML27 gate_way27_cell62 GND GND n1 W=1e-6 L=1e-6
mpway27_cell62 ML27 gate_way27_cell62 GND ML27 p1 W=2.4e-6 L=1e-6
mnway27_cell63 ML27 gate_way27_cell63 GND GND n1 W=1e-6 L=1e-6
mpway27_cell63 ML27 gate_way27_cell63 GND ML27 p1 W=2.4e-6 L=1e-6
mnway27_cell64 ML27 gate_way27_cell64 GND GND n1 W=1e-6 L=1e-6
mpway27_cell64 ML27 gate_way27_cell64 GND ML27 p1 W=2.4e-6 L=1e-6
mnway27_cell65 ML27 gate_way27_cell65 GND GND n1 W=1e-6 L=1e-6
mpway27_cell65 ML27 gate_way27_cell65 GND ML27 p1 W=2.4e-6 L=1e-6
mnway27_cell66 ML27 gate_way27_cell66 GND GND n1 W=1e-6 L=1e-6
mpway27_cell66 ML27 gate_way27_cell66 GND ML27 p1 W=2.4e-6 L=1e-6
mnway27_cell67 ML27 gate_way27_cell67 GND GND n1 W=1e-6 L=1e-6
mpway27_cell67 ML27 gate_way27_cell67 GND ML27 p1 W=2.4e-6 L=1e-6
mnway27_cell68 ML27 gate_way27_cell68 GND GND n1 W=1e-6 L=1e-6
mpway27_cell68 ML27 gate_way27_cell68 GND ML27 p1 W=2.4e-6 L=1e-6
mnway27_cell69 ML27 gate_way27_cell69 GND GND n1 W=1e-6 L=1e-6
mpway27_cell69 ML27 gate_way27_cell69 GND ML27 p1 W=2.4e-6 L=1e-6
mnway27_cell70 ML27 gate_way27_cell70 GND GND n1 W=1e-6 L=1e-6
mpway27_cell70 ML27 gate_way27_cell70 GND ML27 p1 W=2.4e-6 L=1e-6
mnway27_cell71 ML27 gate_way27_cell71 GND GND n1 W=1e-6 L=1e-6
mpway27_cell71 ML27 gate_way27_cell71 GND ML27 p1 W=2.4e-6 L=1e-6
mnway27_cell72 ML27 gate_way27_cell72 GND GND n1 W=1e-6 L=1e-6
mpway27_cell72 ML27 gate_way27_cell72 GND ML27 p1 W=2.4e-6 L=1e-6
mnway27_cell73 ML27 gate_way27_cell73 GND GND n1 W=1e-6 L=1e-6
mpway27_cell73 ML27 gate_way27_cell73 GND ML27 p1 W=2.4e-6 L=1e-6
mnway27_cell74 ML27 gate_way27_cell74 GND GND n1 W=1e-6 L=1e-6
mpway27_cell74 ML27 gate_way27_cell74 GND ML27 p1 W=2.4e-6 L=1e-6
mnway27_cell75 ML27 gate_way27_cell75 GND GND n1 W=1e-6 L=1e-6
mpway27_cell75 ML27 gate_way27_cell75 GND ML27 p1 W=2.4e-6 L=1e-6
mnway27_cell76 ML27 gate_way27_cell76 GND GND n1 W=1e-6 L=1e-6
mpway27_cell76 ML27 gate_way27_cell76 GND ML27 p1 W=2.4e-6 L=1e-6
mnway27_cell77 ML27 gate_way27_cell77 GND GND n1 W=1e-6 L=1e-6
mpway27_cell77 ML27 gate_way27_cell77 GND ML27 p1 W=2.4e-6 L=1e-6
mnway27_cell78 ML27 gate_way27_cell78 GND GND n1 W=1e-6 L=1e-6
mpway27_cell78 ML27 gate_way27_cell78 GND ML27 p1 W=2.4e-6 L=1e-6
mnway27_cell79 ML27 gate_way27_cell79 GND GND n1 W=1e-6 L=1e-6
mpway27_cell79 ML27 gate_way27_cell79 GND ML27 p1 W=2.4e-6 L=1e-6
mnway27_cell80 ML27 gate_way27_cell80 GND GND n1 W=1e-6 L=1e-6
mpway27_cell80 ML27 gate_way27_cell80 GND ML27 p1 W=2.4e-6 L=1e-6
mnway27_cell81 ML27 gate_way27_cell81 GND GND n1 W=1e-6 L=1e-6
mpway27_cell81 ML27 gate_way27_cell81 GND ML27 p1 W=2.4e-6 L=1e-6
mnway27_cell82 ML27 gate_way27_cell82 GND GND n1 W=1e-6 L=1e-6
mpway27_cell82 ML27 gate_way27_cell82 GND ML27 p1 W=2.4e-6 L=1e-6
mnway27_cell83 ML27 gate_way27_cell83 GND GND n1 W=1e-6 L=1e-6
mpway27_cell83 ML27 gate_way27_cell83 GND ML27 p1 W=2.4e-6 L=1e-6
mnway27_cell84 ML27 gate_way27_cell84 GND GND n1 W=1e-6 L=1e-6
mpway27_cell84 ML27 gate_way27_cell84 GND ML27 p1 W=2.4e-6 L=1e-6
mnway27_cell85 ML27 gate_way27_cell85 GND GND n1 W=1e-6 L=1e-6
mpway27_cell85 ML27 gate_way27_cell85 GND ML27 p1 W=2.4e-6 L=1e-6
mnway27_cell86 ML27 gate_way27_cell86 GND GND n1 W=1e-6 L=1e-6
mpway27_cell86 ML27 gate_way27_cell86 GND ML27 p1 W=2.4e-6 L=1e-6
mnway27_cell87 ML27 gate_way27_cell87 GND GND n1 W=1e-6 L=1e-6
mpway27_cell87 ML27 gate_way27_cell87 GND ML27 p1 W=2.4e-6 L=1e-6
mnway27_cell88 ML27 gate_way27_cell88 GND GND n1 W=1e-6 L=1e-6
mpway27_cell88 ML27 gate_way27_cell88 GND ML27 p1 W=2.4e-6 L=1e-6
mnway27_cell89 ML27 gate_way27_cell89 GND GND n1 W=1e-6 L=1e-6
mpway27_cell89 ML27 gate_way27_cell89 GND ML27 p1 W=2.4e-6 L=1e-6
mnway27_cell90 ML27 gate_way27_cell90 GND GND n1 W=1e-6 L=1e-6
mpway27_cell90 ML27 gate_way27_cell90 GND ML27 p1 W=2.4e-6 L=1e-6
mnway27_cell91 ML27 gate_way27_cell91 GND GND n1 W=1e-6 L=1e-6
mpway27_cell91 ML27 gate_way27_cell91 GND ML27 p1 W=2.4e-6 L=1e-6
mnway27_cell92 ML27 gate_way27_cell92 GND GND n1 W=1e-6 L=1e-6
mpway27_cell92 ML27 gate_way27_cell92 GND ML27 p1 W=2.4e-6 L=1e-6
mnway27_cell93 ML27 gate_way27_cell93 GND GND n1 W=1e-6 L=1e-6
mpway27_cell93 ML27 gate_way27_cell93 GND ML27 p1 W=2.4e-6 L=1e-6
mnway27_cell94 ML27 gate_way27_cell94 GND GND n1 W=1e-6 L=1e-6
mpway27_cell94 ML27 gate_way27_cell94 GND ML27 p1 W=2.4e-6 L=1e-6
mnway27_cell95 ML27 gate_way27_cell95 GND GND n1 W=1e-6 L=1e-6
mpway27_cell95 ML27 gate_way27_cell95 GND ML27 p1 W=2.4e-6 L=1e-6
mnway27_cell96 ML27 gate_way27_cell96 GND GND n1 W=1e-6 L=1e-6
mpway27_cell96 ML27 gate_way27_cell96 GND ML27 p1 W=2.4e-6 L=1e-6
mnway27_cell97 ML27 gate_way27_cell97 GND GND n1 W=1e-6 L=1e-6
mpway27_cell97 ML27 gate_way27_cell97 GND ML27 p1 W=2.4e-6 L=1e-6
mnway27_cell98 ML27 gate_way27_cell98 GND GND n1 W=1e-6 L=1e-6
mpway27_cell98 ML27 gate_way27_cell98 GND ML27 p1 W=2.4e-6 L=1e-6
mnway27_cell99 ML27 gate_way27_cell99 GND GND n1 W=1e-6 L=1e-6
mpway27_cell99 ML27 gate_way27_cell99 GND ML27 p1 W=2.4e-6 L=1e-6
mnway28_cell0 ML28 gate_way28_cell0 GND GND n1 W=1e-6 L=1e-6
mpway28_cell0 ML28 gate_way28_cell0 GND ML28 p1 W=2.4e-6 L=1e-6
mnway28_cell1 ML28 gate_way28_cell1 GND GND n1 W=1e-6 L=1e-6
mpway28_cell1 ML28 gate_way28_cell1 GND ML28 p1 W=2.4e-6 L=1e-6
mnway28_cell2 ML28 gate_way28_cell2 GND GND n1 W=1e-6 L=1e-6
mpway28_cell2 ML28 gate_way28_cell2 GND ML28 p1 W=2.4e-6 L=1e-6
mnway28_cell3 ML28 gate_way28_cell3 GND GND n1 W=1e-6 L=1e-6
mpway28_cell3 ML28 gate_way28_cell3 GND ML28 p1 W=2.4e-6 L=1e-6
mnway28_cell4 ML28 gate_way28_cell4 GND GND n1 W=1e-6 L=1e-6
mpway28_cell4 ML28 gate_way28_cell4 GND ML28 p1 W=2.4e-6 L=1e-6
mnway28_cell5 ML28 gate_way28_cell5 GND GND n1 W=1e-6 L=1e-6
mpway28_cell5 ML28 gate_way28_cell5 GND ML28 p1 W=2.4e-6 L=1e-6
mnway28_cell6 ML28 gate_way28_cell6 GND GND n1 W=1e-6 L=1e-6
mpway28_cell6 ML28 gate_way28_cell6 GND ML28 p1 W=2.4e-6 L=1e-6
mnway28_cell7 ML28 gate_way28_cell7 GND GND n1 W=1e-6 L=1e-6
mpway28_cell7 ML28 gate_way28_cell7 GND ML28 p1 W=2.4e-6 L=1e-6
mnway28_cell8 ML28 gate_way28_cell8 GND GND n1 W=1e-6 L=1e-6
mpway28_cell8 ML28 gate_way28_cell8 GND ML28 p1 W=2.4e-6 L=1e-6
mnway28_cell9 ML28 gate_way28_cell9 GND GND n1 W=1e-6 L=1e-6
mpway28_cell9 ML28 gate_way28_cell9 GND ML28 p1 W=2.4e-6 L=1e-6
mnway28_cell10 ML28 gate_way28_cell10 GND GND n1 W=1e-6 L=1e-6
mpway28_cell10 ML28 gate_way28_cell10 GND ML28 p1 W=2.4e-6 L=1e-6
mnway28_cell11 ML28 gate_way28_cell11 GND GND n1 W=1e-6 L=1e-6
mpway28_cell11 ML28 gate_way28_cell11 GND ML28 p1 W=2.4e-6 L=1e-6
mnway28_cell12 ML28 gate_way28_cell12 GND GND n1 W=1e-6 L=1e-6
mpway28_cell12 ML28 gate_way28_cell12 GND ML28 p1 W=2.4e-6 L=1e-6
mnway28_cell13 ML28 gate_way28_cell13 GND GND n1 W=1e-6 L=1e-6
mpway28_cell13 ML28 gate_way28_cell13 GND ML28 p1 W=2.4e-6 L=1e-6
mnway28_cell14 ML28 gate_way28_cell14 GND GND n1 W=1e-6 L=1e-6
mpway28_cell14 ML28 gate_way28_cell14 GND ML28 p1 W=2.4e-6 L=1e-6
mnway28_cell15 ML28 gate_way28_cell15 GND GND n1 W=1e-6 L=1e-6
mpway28_cell15 ML28 gate_way28_cell15 GND ML28 p1 W=2.4e-6 L=1e-6
mnway28_cell16 ML28 gate_way28_cell16 GND GND n1 W=1e-6 L=1e-6
mpway28_cell16 ML28 gate_way28_cell16 GND ML28 p1 W=2.4e-6 L=1e-6
mnway28_cell17 ML28 gate_way28_cell17 GND GND n1 W=1e-6 L=1e-6
mpway28_cell17 ML28 gate_way28_cell17 GND ML28 p1 W=2.4e-6 L=1e-6
mnway28_cell18 ML28 gate_way28_cell18 GND GND n1 W=1e-6 L=1e-6
mpway28_cell18 ML28 gate_way28_cell18 GND ML28 p1 W=2.4e-6 L=1e-6
mnway28_cell19 ML28 gate_way28_cell19 GND GND n1 W=1e-6 L=1e-6
mpway28_cell19 ML28 gate_way28_cell19 GND ML28 p1 W=2.4e-6 L=1e-6
mnway28_cell20 ML28 gate_way28_cell20 GND GND n1 W=1e-6 L=1e-6
mpway28_cell20 ML28 gate_way28_cell20 GND ML28 p1 W=2.4e-6 L=1e-6
mnway28_cell21 ML28 gate_way28_cell21 GND GND n1 W=1e-6 L=1e-6
mpway28_cell21 ML28 gate_way28_cell21 GND ML28 p1 W=2.4e-6 L=1e-6
mnway28_cell22 ML28 gate_way28_cell22 GND GND n1 W=1e-6 L=1e-6
mpway28_cell22 ML28 gate_way28_cell22 GND ML28 p1 W=2.4e-6 L=1e-6
mnway28_cell23 ML28 gate_way28_cell23 GND GND n1 W=1e-6 L=1e-6
mpway28_cell23 ML28 gate_way28_cell23 GND ML28 p1 W=2.4e-6 L=1e-6
mnway28_cell24 ML28 gate_way28_cell24 GND GND n1 W=1e-6 L=1e-6
mpway28_cell24 ML28 gate_way28_cell24 GND ML28 p1 W=2.4e-6 L=1e-6
mnway28_cell25 ML28 gate_way28_cell25 GND GND n1 W=1e-6 L=1e-6
mpway28_cell25 ML28 gate_way28_cell25 GND ML28 p1 W=2.4e-6 L=1e-6
mnway28_cell26 ML28 gate_way28_cell26 GND GND n1 W=1e-6 L=1e-6
mpway28_cell26 ML28 gate_way28_cell26 GND ML28 p1 W=2.4e-6 L=1e-6
mnway28_cell27 ML28 gate_way28_cell27 GND GND n1 W=1e-6 L=1e-6
mpway28_cell27 ML28 gate_way28_cell27 GND ML28 p1 W=2.4e-6 L=1e-6
mnway28_cell28 ML28 gate_way28_cell28 GND GND n1 W=1e-6 L=1e-6
mpway28_cell28 ML28 gate_way28_cell28 GND ML28 p1 W=2.4e-6 L=1e-6
mnway28_cell29 ML28 gate_way28_cell29 GND GND n1 W=1e-6 L=1e-6
mpway28_cell29 ML28 gate_way28_cell29 GND ML28 p1 W=2.4e-6 L=1e-6
mnway28_cell30 ML28 gate_way28_cell30 GND GND n1 W=1e-6 L=1e-6
mpway28_cell30 ML28 gate_way28_cell30 GND ML28 p1 W=2.4e-6 L=1e-6
mnway28_cell31 ML28 gate_way28_cell31 GND GND n1 W=1e-6 L=1e-6
mpway28_cell31 ML28 gate_way28_cell31 GND ML28 p1 W=2.4e-6 L=1e-6
mnway28_cell32 ML28 gate_way28_cell32 GND GND n1 W=1e-6 L=1e-6
mpway28_cell32 ML28 gate_way28_cell32 GND ML28 p1 W=2.4e-6 L=1e-6
mnway28_cell33 ML28 gate_way28_cell33 GND GND n1 W=1e-6 L=1e-6
mpway28_cell33 ML28 gate_way28_cell33 GND ML28 p1 W=2.4e-6 L=1e-6
mnway28_cell34 ML28 gate_way28_cell34 GND GND n1 W=1e-6 L=1e-6
mpway28_cell34 ML28 gate_way28_cell34 GND ML28 p1 W=2.4e-6 L=1e-6
mnway28_cell35 ML28 gate_way28_cell35 GND GND n1 W=1e-6 L=1e-6
mpway28_cell35 ML28 gate_way28_cell35 GND ML28 p1 W=2.4e-6 L=1e-6
mnway28_cell36 ML28 gate_way28_cell36 GND GND n1 W=1e-6 L=1e-6
mpway28_cell36 ML28 gate_way28_cell36 GND ML28 p1 W=2.4e-6 L=1e-6
mnway28_cell37 ML28 gate_way28_cell37 GND GND n1 W=1e-6 L=1e-6
mpway28_cell37 ML28 gate_way28_cell37 GND ML28 p1 W=2.4e-6 L=1e-6
mnway28_cell38 ML28 gate_way28_cell38 GND GND n1 W=1e-6 L=1e-6
mpway28_cell38 ML28 gate_way28_cell38 GND ML28 p1 W=2.4e-6 L=1e-6
mnway28_cell39 ML28 gate_way28_cell39 GND GND n1 W=1e-6 L=1e-6
mpway28_cell39 ML28 gate_way28_cell39 GND ML28 p1 W=2.4e-6 L=1e-6
mnway28_cell40 ML28 gate_way28_cell40 GND GND n1 W=1e-6 L=1e-6
mpway28_cell40 ML28 gate_way28_cell40 GND ML28 p1 W=2.4e-6 L=1e-6
mnway28_cell41 ML28 gate_way28_cell41 GND GND n1 W=1e-6 L=1e-6
mpway28_cell41 ML28 gate_way28_cell41 GND ML28 p1 W=2.4e-6 L=1e-6
mnway28_cell42 ML28 gate_way28_cell42 GND GND n1 W=1e-6 L=1e-6
mpway28_cell42 ML28 gate_way28_cell42 GND ML28 p1 W=2.4e-6 L=1e-6
mnway28_cell43 ML28 gate_way28_cell43 GND GND n1 W=1e-6 L=1e-6
mpway28_cell43 ML28 gate_way28_cell43 GND ML28 p1 W=2.4e-6 L=1e-6
mnway28_cell44 ML28 gate_way28_cell44 GND GND n1 W=1e-6 L=1e-6
mpway28_cell44 ML28 gate_way28_cell44 GND ML28 p1 W=2.4e-6 L=1e-6
mnway28_cell45 ML28 gate_way28_cell45 GND GND n1 W=1e-6 L=1e-6
mpway28_cell45 ML28 gate_way28_cell45 GND ML28 p1 W=2.4e-6 L=1e-6
mnway28_cell46 ML28 gate_way28_cell46 GND GND n1 W=1e-6 L=1e-6
mpway28_cell46 ML28 gate_way28_cell46 GND ML28 p1 W=2.4e-6 L=1e-6
mnway28_cell47 ML28 gate_way28_cell47 GND GND n1 W=1e-6 L=1e-6
mpway28_cell47 ML28 gate_way28_cell47 GND ML28 p1 W=2.4e-6 L=1e-6
mnway28_cell48 ML28 gate_way28_cell48 GND GND n1 W=1e-6 L=1e-6
mpway28_cell48 ML28 gate_way28_cell48 GND ML28 p1 W=2.4e-6 L=1e-6
mnway28_cell49 ML28 gate_way28_cell49 GND GND n1 W=1e-6 L=1e-6
mpway28_cell49 ML28 gate_way28_cell49 GND ML28 p1 W=2.4e-6 L=1e-6
mnway28_cell50 ML28 gate_way28_cell50 GND GND n1 W=1e-6 L=1e-6
mpway28_cell50 ML28 gate_way28_cell50 GND ML28 p1 W=2.4e-6 L=1e-6
mnway28_cell51 ML28 gate_way28_cell51 GND GND n1 W=1e-6 L=1e-6
mpway28_cell51 ML28 gate_way28_cell51 GND ML28 p1 W=2.4e-6 L=1e-6
mnway28_cell52 ML28 gate_way28_cell52 GND GND n1 W=1e-6 L=1e-6
mpway28_cell52 ML28 gate_way28_cell52 GND ML28 p1 W=2.4e-6 L=1e-6
mnway28_cell53 ML28 gate_way28_cell53 GND GND n1 W=1e-6 L=1e-6
mpway28_cell53 ML28 gate_way28_cell53 GND ML28 p1 W=2.4e-6 L=1e-6
mnway28_cell54 ML28 gate_way28_cell54 GND GND n1 W=1e-6 L=1e-6
mpway28_cell54 ML28 gate_way28_cell54 GND ML28 p1 W=2.4e-6 L=1e-6
mnway28_cell55 ML28 gate_way28_cell55 GND GND n1 W=1e-6 L=1e-6
mpway28_cell55 ML28 gate_way28_cell55 GND ML28 p1 W=2.4e-6 L=1e-6
mnway28_cell56 ML28 gate_way28_cell56 GND GND n1 W=1e-6 L=1e-6
mpway28_cell56 ML28 gate_way28_cell56 GND ML28 p1 W=2.4e-6 L=1e-6
mnway28_cell57 ML28 gate_way28_cell57 GND GND n1 W=1e-6 L=1e-6
mpway28_cell57 ML28 gate_way28_cell57 GND ML28 p1 W=2.4e-6 L=1e-6
mnway28_cell58 ML28 gate_way28_cell58 GND GND n1 W=1e-6 L=1e-6
mpway28_cell58 ML28 gate_way28_cell58 GND ML28 p1 W=2.4e-6 L=1e-6
mnway28_cell59 ML28 gate_way28_cell59 GND GND n1 W=1e-6 L=1e-6
mpway28_cell59 ML28 gate_way28_cell59 GND ML28 p1 W=2.4e-6 L=1e-6
mnway28_cell60 ML28 gate_way28_cell60 GND GND n1 W=1e-6 L=1e-6
mpway28_cell60 ML28 gate_way28_cell60 GND ML28 p1 W=2.4e-6 L=1e-6
mnway28_cell61 ML28 gate_way28_cell61 GND GND n1 W=1e-6 L=1e-6
mpway28_cell61 ML28 gate_way28_cell61 GND ML28 p1 W=2.4e-6 L=1e-6
mnway28_cell62 ML28 gate_way28_cell62 GND GND n1 W=1e-6 L=1e-6
mpway28_cell62 ML28 gate_way28_cell62 GND ML28 p1 W=2.4e-6 L=1e-6
mnway28_cell63 ML28 gate_way28_cell63 GND GND n1 W=1e-6 L=1e-6
mpway28_cell63 ML28 gate_way28_cell63 GND ML28 p1 W=2.4e-6 L=1e-6
mnway28_cell64 ML28 gate_way28_cell64 GND GND n1 W=1e-6 L=1e-6
mpway28_cell64 ML28 gate_way28_cell64 GND ML28 p1 W=2.4e-6 L=1e-6
mnway28_cell65 ML28 gate_way28_cell65 GND GND n1 W=1e-6 L=1e-6
mpway28_cell65 ML28 gate_way28_cell65 GND ML28 p1 W=2.4e-6 L=1e-6
mnway28_cell66 ML28 gate_way28_cell66 GND GND n1 W=1e-6 L=1e-6
mpway28_cell66 ML28 gate_way28_cell66 GND ML28 p1 W=2.4e-6 L=1e-6
mnway28_cell67 ML28 gate_way28_cell67 GND GND n1 W=1e-6 L=1e-6
mpway28_cell67 ML28 gate_way28_cell67 GND ML28 p1 W=2.4e-6 L=1e-6
mnway28_cell68 ML28 gate_way28_cell68 GND GND n1 W=1e-6 L=1e-6
mpway28_cell68 ML28 gate_way28_cell68 GND ML28 p1 W=2.4e-6 L=1e-6
mnway28_cell69 ML28 gate_way28_cell69 GND GND n1 W=1e-6 L=1e-6
mpway28_cell69 ML28 gate_way28_cell69 GND ML28 p1 W=2.4e-6 L=1e-6
mnway28_cell70 ML28 gate_way28_cell70 GND GND n1 W=1e-6 L=1e-6
mpway28_cell70 ML28 gate_way28_cell70 GND ML28 p1 W=2.4e-6 L=1e-6
mnway28_cell71 ML28 gate_way28_cell71 GND GND n1 W=1e-6 L=1e-6
mpway28_cell71 ML28 gate_way28_cell71 GND ML28 p1 W=2.4e-6 L=1e-6
mnway28_cell72 ML28 gate_way28_cell72 GND GND n1 W=1e-6 L=1e-6
mpway28_cell72 ML28 gate_way28_cell72 GND ML28 p1 W=2.4e-6 L=1e-6
mnway28_cell73 ML28 gate_way28_cell73 GND GND n1 W=1e-6 L=1e-6
mpway28_cell73 ML28 gate_way28_cell73 GND ML28 p1 W=2.4e-6 L=1e-6
mnway28_cell74 ML28 gate_way28_cell74 GND GND n1 W=1e-6 L=1e-6
mpway28_cell74 ML28 gate_way28_cell74 GND ML28 p1 W=2.4e-6 L=1e-6
mnway28_cell75 ML28 gate_way28_cell75 GND GND n1 W=1e-6 L=1e-6
mpway28_cell75 ML28 gate_way28_cell75 GND ML28 p1 W=2.4e-6 L=1e-6
mnway28_cell76 ML28 gate_way28_cell76 GND GND n1 W=1e-6 L=1e-6
mpway28_cell76 ML28 gate_way28_cell76 GND ML28 p1 W=2.4e-6 L=1e-6
mnway28_cell77 ML28 gate_way28_cell77 GND GND n1 W=1e-6 L=1e-6
mpway28_cell77 ML28 gate_way28_cell77 GND ML28 p1 W=2.4e-6 L=1e-6
mnway28_cell78 ML28 gate_way28_cell78 GND GND n1 W=1e-6 L=1e-6
mpway28_cell78 ML28 gate_way28_cell78 GND ML28 p1 W=2.4e-6 L=1e-6
mnway28_cell79 ML28 gate_way28_cell79 GND GND n1 W=1e-6 L=1e-6
mpway28_cell79 ML28 gate_way28_cell79 GND ML28 p1 W=2.4e-6 L=1e-6
mnway28_cell80 ML28 gate_way28_cell80 GND GND n1 W=1e-6 L=1e-6
mpway28_cell80 ML28 gate_way28_cell80 GND ML28 p1 W=2.4e-6 L=1e-6
mnway28_cell81 ML28 gate_way28_cell81 GND GND n1 W=1e-6 L=1e-6
mpway28_cell81 ML28 gate_way28_cell81 GND ML28 p1 W=2.4e-6 L=1e-6
mnway28_cell82 ML28 gate_way28_cell82 GND GND n1 W=1e-6 L=1e-6
mpway28_cell82 ML28 gate_way28_cell82 GND ML28 p1 W=2.4e-6 L=1e-6
mnway28_cell83 ML28 gate_way28_cell83 GND GND n1 W=1e-6 L=1e-6
mpway28_cell83 ML28 gate_way28_cell83 GND ML28 p1 W=2.4e-6 L=1e-6
mnway28_cell84 ML28 gate_way28_cell84 GND GND n1 W=1e-6 L=1e-6
mpway28_cell84 ML28 gate_way28_cell84 GND ML28 p1 W=2.4e-6 L=1e-6
mnway28_cell85 ML28 gate_way28_cell85 GND GND n1 W=1e-6 L=1e-6
mpway28_cell85 ML28 gate_way28_cell85 GND ML28 p1 W=2.4e-6 L=1e-6
mnway28_cell86 ML28 gate_way28_cell86 GND GND n1 W=1e-6 L=1e-6
mpway28_cell86 ML28 gate_way28_cell86 GND ML28 p1 W=2.4e-6 L=1e-6
mnway28_cell87 ML28 gate_way28_cell87 GND GND n1 W=1e-6 L=1e-6
mpway28_cell87 ML28 gate_way28_cell87 GND ML28 p1 W=2.4e-6 L=1e-6
mnway28_cell88 ML28 gate_way28_cell88 GND GND n1 W=1e-6 L=1e-6
mpway28_cell88 ML28 gate_way28_cell88 GND ML28 p1 W=2.4e-6 L=1e-6
mnway28_cell89 ML28 gate_way28_cell89 GND GND n1 W=1e-6 L=1e-6
mpway28_cell89 ML28 gate_way28_cell89 GND ML28 p1 W=2.4e-6 L=1e-6
mnway28_cell90 ML28 gate_way28_cell90 GND GND n1 W=1e-6 L=1e-6
mpway28_cell90 ML28 gate_way28_cell90 GND ML28 p1 W=2.4e-6 L=1e-6
mnway28_cell91 ML28 gate_way28_cell91 GND GND n1 W=1e-6 L=1e-6
mpway28_cell91 ML28 gate_way28_cell91 GND ML28 p1 W=2.4e-6 L=1e-6
mnway28_cell92 ML28 gate_way28_cell92 GND GND n1 W=1e-6 L=1e-6
mpway28_cell92 ML28 gate_way28_cell92 GND ML28 p1 W=2.4e-6 L=1e-6
mnway28_cell93 ML28 gate_way28_cell93 GND GND n1 W=1e-6 L=1e-6
mpway28_cell93 ML28 gate_way28_cell93 GND ML28 p1 W=2.4e-6 L=1e-6
mnway28_cell94 ML28 gate_way28_cell94 GND GND n1 W=1e-6 L=1e-6
mpway28_cell94 ML28 gate_way28_cell94 GND ML28 p1 W=2.4e-6 L=1e-6
mnway28_cell95 ML28 gate_way28_cell95 GND GND n1 W=1e-6 L=1e-6
mpway28_cell95 ML28 gate_way28_cell95 GND ML28 p1 W=2.4e-6 L=1e-6
mnway28_cell96 ML28 gate_way28_cell96 GND GND n1 W=1e-6 L=1e-6
mpway28_cell96 ML28 gate_way28_cell96 GND ML28 p1 W=2.4e-6 L=1e-6
mnway28_cell97 ML28 gate_way28_cell97 GND GND n1 W=1e-6 L=1e-6
mpway28_cell97 ML28 gate_way28_cell97 GND ML28 p1 W=2.4e-6 L=1e-6
mnway28_cell98 ML28 gate_way28_cell98 GND GND n1 W=1e-6 L=1e-6
mpway28_cell98 ML28 gate_way28_cell98 GND ML28 p1 W=2.4e-6 L=1e-6
mnway28_cell99 ML28 gate_way28_cell99 GND GND n1 W=1e-6 L=1e-6
mpway28_cell99 ML28 gate_way28_cell99 GND ML28 p1 W=2.4e-6 L=1e-6
mnway29_cell0 ML29 gate_way29_cell0 GND GND n1 W=1e-6 L=1e-6
mpway29_cell0 ML29 gate_way29_cell0 GND ML29 p1 W=2.4e-6 L=1e-6
mnway29_cell1 ML29 gate_way29_cell1 GND GND n1 W=1e-6 L=1e-6
mpway29_cell1 ML29 gate_way29_cell1 GND ML29 p1 W=2.4e-6 L=1e-6
mnway29_cell2 ML29 gate_way29_cell2 GND GND n1 W=1e-6 L=1e-6
mpway29_cell2 ML29 gate_way29_cell2 GND ML29 p1 W=2.4e-6 L=1e-6
mnway29_cell3 ML29 gate_way29_cell3 GND GND n1 W=1e-6 L=1e-6
mpway29_cell3 ML29 gate_way29_cell3 GND ML29 p1 W=2.4e-6 L=1e-6
mnway29_cell4 ML29 gate_way29_cell4 GND GND n1 W=1e-6 L=1e-6
mpway29_cell4 ML29 gate_way29_cell4 GND ML29 p1 W=2.4e-6 L=1e-6
mnway29_cell5 ML29 gate_way29_cell5 GND GND n1 W=1e-6 L=1e-6
mpway29_cell5 ML29 gate_way29_cell5 GND ML29 p1 W=2.4e-6 L=1e-6
mnway29_cell6 ML29 gate_way29_cell6 GND GND n1 W=1e-6 L=1e-6
mpway29_cell6 ML29 gate_way29_cell6 GND ML29 p1 W=2.4e-6 L=1e-6
mnway29_cell7 ML29 gate_way29_cell7 GND GND n1 W=1e-6 L=1e-6
mpway29_cell7 ML29 gate_way29_cell7 GND ML29 p1 W=2.4e-6 L=1e-6
mnway29_cell8 ML29 gate_way29_cell8 GND GND n1 W=1e-6 L=1e-6
mpway29_cell8 ML29 gate_way29_cell8 GND ML29 p1 W=2.4e-6 L=1e-6
mnway29_cell9 ML29 gate_way29_cell9 GND GND n1 W=1e-6 L=1e-6
mpway29_cell9 ML29 gate_way29_cell9 GND ML29 p1 W=2.4e-6 L=1e-6
mnway29_cell10 ML29 gate_way29_cell10 GND GND n1 W=1e-6 L=1e-6
mpway29_cell10 ML29 gate_way29_cell10 GND ML29 p1 W=2.4e-6 L=1e-6
mnway29_cell11 ML29 gate_way29_cell11 GND GND n1 W=1e-6 L=1e-6
mpway29_cell11 ML29 gate_way29_cell11 GND ML29 p1 W=2.4e-6 L=1e-6
mnway29_cell12 ML29 gate_way29_cell12 GND GND n1 W=1e-6 L=1e-6
mpway29_cell12 ML29 gate_way29_cell12 GND ML29 p1 W=2.4e-6 L=1e-6
mnway29_cell13 ML29 gate_way29_cell13 GND GND n1 W=1e-6 L=1e-6
mpway29_cell13 ML29 gate_way29_cell13 GND ML29 p1 W=2.4e-6 L=1e-6
mnway29_cell14 ML29 gate_way29_cell14 GND GND n1 W=1e-6 L=1e-6
mpway29_cell14 ML29 gate_way29_cell14 GND ML29 p1 W=2.4e-6 L=1e-6
mnway29_cell15 ML29 gate_way29_cell15 GND GND n1 W=1e-6 L=1e-6
mpway29_cell15 ML29 gate_way29_cell15 GND ML29 p1 W=2.4e-6 L=1e-6
mnway29_cell16 ML29 gate_way29_cell16 GND GND n1 W=1e-6 L=1e-6
mpway29_cell16 ML29 gate_way29_cell16 GND ML29 p1 W=2.4e-6 L=1e-6
mnway29_cell17 ML29 gate_way29_cell17 GND GND n1 W=1e-6 L=1e-6
mpway29_cell17 ML29 gate_way29_cell17 GND ML29 p1 W=2.4e-6 L=1e-6
mnway29_cell18 ML29 gate_way29_cell18 GND GND n1 W=1e-6 L=1e-6
mpway29_cell18 ML29 gate_way29_cell18 GND ML29 p1 W=2.4e-6 L=1e-6
mnway29_cell19 ML29 gate_way29_cell19 GND GND n1 W=1e-6 L=1e-6
mpway29_cell19 ML29 gate_way29_cell19 GND ML29 p1 W=2.4e-6 L=1e-6
mnway29_cell20 ML29 gate_way29_cell20 GND GND n1 W=1e-6 L=1e-6
mpway29_cell20 ML29 gate_way29_cell20 GND ML29 p1 W=2.4e-6 L=1e-6
mnway29_cell21 ML29 gate_way29_cell21 GND GND n1 W=1e-6 L=1e-6
mpway29_cell21 ML29 gate_way29_cell21 GND ML29 p1 W=2.4e-6 L=1e-6
mnway29_cell22 ML29 gate_way29_cell22 GND GND n1 W=1e-6 L=1e-6
mpway29_cell22 ML29 gate_way29_cell22 GND ML29 p1 W=2.4e-6 L=1e-6
mnway29_cell23 ML29 gate_way29_cell23 GND GND n1 W=1e-6 L=1e-6
mpway29_cell23 ML29 gate_way29_cell23 GND ML29 p1 W=2.4e-6 L=1e-6
mnway29_cell24 ML29 gate_way29_cell24 GND GND n1 W=1e-6 L=1e-6
mpway29_cell24 ML29 gate_way29_cell24 GND ML29 p1 W=2.4e-6 L=1e-6
mnway29_cell25 ML29 gate_way29_cell25 GND GND n1 W=1e-6 L=1e-6
mpway29_cell25 ML29 gate_way29_cell25 GND ML29 p1 W=2.4e-6 L=1e-6
mnway29_cell26 ML29 gate_way29_cell26 GND GND n1 W=1e-6 L=1e-6
mpway29_cell26 ML29 gate_way29_cell26 GND ML29 p1 W=2.4e-6 L=1e-6
mnway29_cell27 ML29 gate_way29_cell27 GND GND n1 W=1e-6 L=1e-6
mpway29_cell27 ML29 gate_way29_cell27 GND ML29 p1 W=2.4e-6 L=1e-6
mnway29_cell28 ML29 gate_way29_cell28 GND GND n1 W=1e-6 L=1e-6
mpway29_cell28 ML29 gate_way29_cell28 GND ML29 p1 W=2.4e-6 L=1e-6
mnway29_cell29 ML29 gate_way29_cell29 GND GND n1 W=1e-6 L=1e-6
mpway29_cell29 ML29 gate_way29_cell29 GND ML29 p1 W=2.4e-6 L=1e-6
mnway29_cell30 ML29 gate_way29_cell30 GND GND n1 W=1e-6 L=1e-6
mpway29_cell30 ML29 gate_way29_cell30 GND ML29 p1 W=2.4e-6 L=1e-6
mnway29_cell31 ML29 gate_way29_cell31 GND GND n1 W=1e-6 L=1e-6
mpway29_cell31 ML29 gate_way29_cell31 GND ML29 p1 W=2.4e-6 L=1e-6
mnway29_cell32 ML29 gate_way29_cell32 GND GND n1 W=1e-6 L=1e-6
mpway29_cell32 ML29 gate_way29_cell32 GND ML29 p1 W=2.4e-6 L=1e-6
mnway29_cell33 ML29 gate_way29_cell33 GND GND n1 W=1e-6 L=1e-6
mpway29_cell33 ML29 gate_way29_cell33 GND ML29 p1 W=2.4e-6 L=1e-6
mnway29_cell34 ML29 gate_way29_cell34 GND GND n1 W=1e-6 L=1e-6
mpway29_cell34 ML29 gate_way29_cell34 GND ML29 p1 W=2.4e-6 L=1e-6
mnway29_cell35 ML29 gate_way29_cell35 GND GND n1 W=1e-6 L=1e-6
mpway29_cell35 ML29 gate_way29_cell35 GND ML29 p1 W=2.4e-6 L=1e-6
mnway29_cell36 ML29 gate_way29_cell36 GND GND n1 W=1e-6 L=1e-6
mpway29_cell36 ML29 gate_way29_cell36 GND ML29 p1 W=2.4e-6 L=1e-6
mnway29_cell37 ML29 gate_way29_cell37 GND GND n1 W=1e-6 L=1e-6
mpway29_cell37 ML29 gate_way29_cell37 GND ML29 p1 W=2.4e-6 L=1e-6
mnway29_cell38 ML29 gate_way29_cell38 GND GND n1 W=1e-6 L=1e-6
mpway29_cell38 ML29 gate_way29_cell38 GND ML29 p1 W=2.4e-6 L=1e-6
mnway29_cell39 ML29 gate_way29_cell39 GND GND n1 W=1e-6 L=1e-6
mpway29_cell39 ML29 gate_way29_cell39 GND ML29 p1 W=2.4e-6 L=1e-6
mnway29_cell40 ML29 gate_way29_cell40 GND GND n1 W=1e-6 L=1e-6
mpway29_cell40 ML29 gate_way29_cell40 GND ML29 p1 W=2.4e-6 L=1e-6
mnway29_cell41 ML29 gate_way29_cell41 GND GND n1 W=1e-6 L=1e-6
mpway29_cell41 ML29 gate_way29_cell41 GND ML29 p1 W=2.4e-6 L=1e-6
mnway29_cell42 ML29 gate_way29_cell42 GND GND n1 W=1e-6 L=1e-6
mpway29_cell42 ML29 gate_way29_cell42 GND ML29 p1 W=2.4e-6 L=1e-6
mnway29_cell43 ML29 gate_way29_cell43 GND GND n1 W=1e-6 L=1e-6
mpway29_cell43 ML29 gate_way29_cell43 GND ML29 p1 W=2.4e-6 L=1e-6
mnway29_cell44 ML29 gate_way29_cell44 GND GND n1 W=1e-6 L=1e-6
mpway29_cell44 ML29 gate_way29_cell44 GND ML29 p1 W=2.4e-6 L=1e-6
mnway29_cell45 ML29 gate_way29_cell45 GND GND n1 W=1e-6 L=1e-6
mpway29_cell45 ML29 gate_way29_cell45 GND ML29 p1 W=2.4e-6 L=1e-6
mnway29_cell46 ML29 gate_way29_cell46 GND GND n1 W=1e-6 L=1e-6
mpway29_cell46 ML29 gate_way29_cell46 GND ML29 p1 W=2.4e-6 L=1e-6
mnway29_cell47 ML29 gate_way29_cell47 GND GND n1 W=1e-6 L=1e-6
mpway29_cell47 ML29 gate_way29_cell47 GND ML29 p1 W=2.4e-6 L=1e-6
mnway29_cell48 ML29 gate_way29_cell48 GND GND n1 W=1e-6 L=1e-6
mpway29_cell48 ML29 gate_way29_cell48 GND ML29 p1 W=2.4e-6 L=1e-6
mnway29_cell49 ML29 gate_way29_cell49 GND GND n1 W=1e-6 L=1e-6
mpway29_cell49 ML29 gate_way29_cell49 GND ML29 p1 W=2.4e-6 L=1e-6
mnway29_cell50 ML29 gate_way29_cell50 GND GND n1 W=1e-6 L=1e-6
mpway29_cell50 ML29 gate_way29_cell50 GND ML29 p1 W=2.4e-6 L=1e-6
mnway29_cell51 ML29 gate_way29_cell51 GND GND n1 W=1e-6 L=1e-6
mpway29_cell51 ML29 gate_way29_cell51 GND ML29 p1 W=2.4e-6 L=1e-6
mnway29_cell52 ML29 gate_way29_cell52 GND GND n1 W=1e-6 L=1e-6
mpway29_cell52 ML29 gate_way29_cell52 GND ML29 p1 W=2.4e-6 L=1e-6
mnway29_cell53 ML29 gate_way29_cell53 GND GND n1 W=1e-6 L=1e-6
mpway29_cell53 ML29 gate_way29_cell53 GND ML29 p1 W=2.4e-6 L=1e-6
mnway29_cell54 ML29 gate_way29_cell54 GND GND n1 W=1e-6 L=1e-6
mpway29_cell54 ML29 gate_way29_cell54 GND ML29 p1 W=2.4e-6 L=1e-6
mnway29_cell55 ML29 gate_way29_cell55 GND GND n1 W=1e-6 L=1e-6
mpway29_cell55 ML29 gate_way29_cell55 GND ML29 p1 W=2.4e-6 L=1e-6
mnway29_cell56 ML29 gate_way29_cell56 GND GND n1 W=1e-6 L=1e-6
mpway29_cell56 ML29 gate_way29_cell56 GND ML29 p1 W=2.4e-6 L=1e-6
mnway29_cell57 ML29 gate_way29_cell57 GND GND n1 W=1e-6 L=1e-6
mpway29_cell57 ML29 gate_way29_cell57 GND ML29 p1 W=2.4e-6 L=1e-6
mnway29_cell58 ML29 gate_way29_cell58 GND GND n1 W=1e-6 L=1e-6
mpway29_cell58 ML29 gate_way29_cell58 GND ML29 p1 W=2.4e-6 L=1e-6
mnway29_cell59 ML29 gate_way29_cell59 GND GND n1 W=1e-6 L=1e-6
mpway29_cell59 ML29 gate_way29_cell59 GND ML29 p1 W=2.4e-6 L=1e-6
mnway29_cell60 ML29 gate_way29_cell60 GND GND n1 W=1e-6 L=1e-6
mpway29_cell60 ML29 gate_way29_cell60 GND ML29 p1 W=2.4e-6 L=1e-6
mnway29_cell61 ML29 gate_way29_cell61 GND GND n1 W=1e-6 L=1e-6
mpway29_cell61 ML29 gate_way29_cell61 GND ML29 p1 W=2.4e-6 L=1e-6
mnway29_cell62 ML29 gate_way29_cell62 GND GND n1 W=1e-6 L=1e-6
mpway29_cell62 ML29 gate_way29_cell62 GND ML29 p1 W=2.4e-6 L=1e-6
mnway29_cell63 ML29 gate_way29_cell63 GND GND n1 W=1e-6 L=1e-6
mpway29_cell63 ML29 gate_way29_cell63 GND ML29 p1 W=2.4e-6 L=1e-6
mnway29_cell64 ML29 gate_way29_cell64 GND GND n1 W=1e-6 L=1e-6
mpway29_cell64 ML29 gate_way29_cell64 GND ML29 p1 W=2.4e-6 L=1e-6
mnway29_cell65 ML29 gate_way29_cell65 GND GND n1 W=1e-6 L=1e-6
mpway29_cell65 ML29 gate_way29_cell65 GND ML29 p1 W=2.4e-6 L=1e-6
mnway29_cell66 ML29 gate_way29_cell66 GND GND n1 W=1e-6 L=1e-6
mpway29_cell66 ML29 gate_way29_cell66 GND ML29 p1 W=2.4e-6 L=1e-6
mnway29_cell67 ML29 gate_way29_cell67 GND GND n1 W=1e-6 L=1e-6
mpway29_cell67 ML29 gate_way29_cell67 GND ML29 p1 W=2.4e-6 L=1e-6
mnway29_cell68 ML29 gate_way29_cell68 GND GND n1 W=1e-6 L=1e-6
mpway29_cell68 ML29 gate_way29_cell68 GND ML29 p1 W=2.4e-6 L=1e-6
mnway29_cell69 ML29 gate_way29_cell69 GND GND n1 W=1e-6 L=1e-6
mpway29_cell69 ML29 gate_way29_cell69 GND ML29 p1 W=2.4e-6 L=1e-6
mnway29_cell70 ML29 gate_way29_cell70 GND GND n1 W=1e-6 L=1e-6
mpway29_cell70 ML29 gate_way29_cell70 GND ML29 p1 W=2.4e-6 L=1e-6
mnway29_cell71 ML29 gate_way29_cell71 GND GND n1 W=1e-6 L=1e-6
mpway29_cell71 ML29 gate_way29_cell71 GND ML29 p1 W=2.4e-6 L=1e-6
mnway29_cell72 ML29 gate_way29_cell72 GND GND n1 W=1e-6 L=1e-6
mpway29_cell72 ML29 gate_way29_cell72 GND ML29 p1 W=2.4e-6 L=1e-6
mnway29_cell73 ML29 gate_way29_cell73 GND GND n1 W=1e-6 L=1e-6
mpway29_cell73 ML29 gate_way29_cell73 GND ML29 p1 W=2.4e-6 L=1e-6
mnway29_cell74 ML29 gate_way29_cell74 GND GND n1 W=1e-6 L=1e-6
mpway29_cell74 ML29 gate_way29_cell74 GND ML29 p1 W=2.4e-6 L=1e-6
mnway29_cell75 ML29 gate_way29_cell75 GND GND n1 W=1e-6 L=1e-6
mpway29_cell75 ML29 gate_way29_cell75 GND ML29 p1 W=2.4e-6 L=1e-6
mnway29_cell76 ML29 gate_way29_cell76 GND GND n1 W=1e-6 L=1e-6
mpway29_cell76 ML29 gate_way29_cell76 GND ML29 p1 W=2.4e-6 L=1e-6
mnway29_cell77 ML29 gate_way29_cell77 GND GND n1 W=1e-6 L=1e-6
mpway29_cell77 ML29 gate_way29_cell77 GND ML29 p1 W=2.4e-6 L=1e-6
mnway29_cell78 ML29 gate_way29_cell78 GND GND n1 W=1e-6 L=1e-6
mpway29_cell78 ML29 gate_way29_cell78 GND ML29 p1 W=2.4e-6 L=1e-6
mnway29_cell79 ML29 gate_way29_cell79 GND GND n1 W=1e-6 L=1e-6
mpway29_cell79 ML29 gate_way29_cell79 GND ML29 p1 W=2.4e-6 L=1e-6
mnway29_cell80 ML29 gate_way29_cell80 GND GND n1 W=1e-6 L=1e-6
mpway29_cell80 ML29 gate_way29_cell80 GND ML29 p1 W=2.4e-6 L=1e-6
mnway29_cell81 ML29 gate_way29_cell81 GND GND n1 W=1e-6 L=1e-6
mpway29_cell81 ML29 gate_way29_cell81 GND ML29 p1 W=2.4e-6 L=1e-6
mnway29_cell82 ML29 gate_way29_cell82 GND GND n1 W=1e-6 L=1e-6
mpway29_cell82 ML29 gate_way29_cell82 GND ML29 p1 W=2.4e-6 L=1e-6
mnway29_cell83 ML29 gate_way29_cell83 GND GND n1 W=1e-6 L=1e-6
mpway29_cell83 ML29 gate_way29_cell83 GND ML29 p1 W=2.4e-6 L=1e-6
mnway29_cell84 ML29 gate_way29_cell84 GND GND n1 W=1e-6 L=1e-6
mpway29_cell84 ML29 gate_way29_cell84 GND ML29 p1 W=2.4e-6 L=1e-6
mnway29_cell85 ML29 gate_way29_cell85 GND GND n1 W=1e-6 L=1e-6
mpway29_cell85 ML29 gate_way29_cell85 GND ML29 p1 W=2.4e-6 L=1e-6
mnway29_cell86 ML29 gate_way29_cell86 GND GND n1 W=1e-6 L=1e-6
mpway29_cell86 ML29 gate_way29_cell86 GND ML29 p1 W=2.4e-6 L=1e-6
mnway29_cell87 ML29 gate_way29_cell87 GND GND n1 W=1e-6 L=1e-6
mpway29_cell87 ML29 gate_way29_cell87 GND ML29 p1 W=2.4e-6 L=1e-6
mnway29_cell88 ML29 gate_way29_cell88 GND GND n1 W=1e-6 L=1e-6
mpway29_cell88 ML29 gate_way29_cell88 GND ML29 p1 W=2.4e-6 L=1e-6
mnway29_cell89 ML29 gate_way29_cell89 GND GND n1 W=1e-6 L=1e-6
mpway29_cell89 ML29 gate_way29_cell89 GND ML29 p1 W=2.4e-6 L=1e-6
mnway29_cell90 ML29 gate_way29_cell90 GND GND n1 W=1e-6 L=1e-6
mpway29_cell90 ML29 gate_way29_cell90 GND ML29 p1 W=2.4e-6 L=1e-6
mnway29_cell91 ML29 gate_way29_cell91 GND GND n1 W=1e-6 L=1e-6
mpway29_cell91 ML29 gate_way29_cell91 GND ML29 p1 W=2.4e-6 L=1e-6
mnway29_cell92 ML29 gate_way29_cell92 GND GND n1 W=1e-6 L=1e-6
mpway29_cell92 ML29 gate_way29_cell92 GND ML29 p1 W=2.4e-6 L=1e-6
mnway29_cell93 ML29 gate_way29_cell93 GND GND n1 W=1e-6 L=1e-6
mpway29_cell93 ML29 gate_way29_cell93 GND ML29 p1 W=2.4e-6 L=1e-6
mnway29_cell94 ML29 gate_way29_cell94 GND GND n1 W=1e-6 L=1e-6
mpway29_cell94 ML29 gate_way29_cell94 GND ML29 p1 W=2.4e-6 L=1e-6
mnway29_cell95 ML29 gate_way29_cell95 GND GND n1 W=1e-6 L=1e-6
mpway29_cell95 ML29 gate_way29_cell95 GND ML29 p1 W=2.4e-6 L=1e-6
mnway29_cell96 ML29 gate_way29_cell96 GND GND n1 W=1e-6 L=1e-6
mpway29_cell96 ML29 gate_way29_cell96 GND ML29 p1 W=2.4e-6 L=1e-6
mnway29_cell97 ML29 gate_way29_cell97 GND GND n1 W=1e-6 L=1e-6
mpway29_cell97 ML29 gate_way29_cell97 GND ML29 p1 W=2.4e-6 L=1e-6
mnway29_cell98 ML29 gate_way29_cell98 GND GND n1 W=1e-6 L=1e-6
mpway29_cell98 ML29 gate_way29_cell98 GND ML29 p1 W=2.4e-6 L=1e-6
mnway29_cell99 ML29 gate_way29_cell99 GND GND n1 W=1e-6 L=1e-6
mpway29_cell99 ML29 gate_way29_cell99 GND ML29 p1 W=2.4e-6 L=1e-6
mnway30_cell0 ML30 gate_way30_cell0 GND GND n1 W=1e-6 L=1e-6
mpway30_cell0 ML30 gate_way30_cell0 GND ML30 p1 W=2.4e-6 L=1e-6
mnway30_cell1 ML30 gate_way30_cell1 GND GND n1 W=1e-6 L=1e-6
mpway30_cell1 ML30 gate_way30_cell1 GND ML30 p1 W=2.4e-6 L=1e-6
mnway30_cell2 ML30 gate_way30_cell2 GND GND n1 W=1e-6 L=1e-6
mpway30_cell2 ML30 gate_way30_cell2 GND ML30 p1 W=2.4e-6 L=1e-6
mnway30_cell3 ML30 gate_way30_cell3 GND GND n1 W=1e-6 L=1e-6
mpway30_cell3 ML30 gate_way30_cell3 GND ML30 p1 W=2.4e-6 L=1e-6
mnway30_cell4 ML30 gate_way30_cell4 GND GND n1 W=1e-6 L=1e-6
mpway30_cell4 ML30 gate_way30_cell4 GND ML30 p1 W=2.4e-6 L=1e-6
mnway30_cell5 ML30 gate_way30_cell5 GND GND n1 W=1e-6 L=1e-6
mpway30_cell5 ML30 gate_way30_cell5 GND ML30 p1 W=2.4e-6 L=1e-6
mnway30_cell6 ML30 gate_way30_cell6 GND GND n1 W=1e-6 L=1e-6
mpway30_cell6 ML30 gate_way30_cell6 GND ML30 p1 W=2.4e-6 L=1e-6
mnway30_cell7 ML30 gate_way30_cell7 GND GND n1 W=1e-6 L=1e-6
mpway30_cell7 ML30 gate_way30_cell7 GND ML30 p1 W=2.4e-6 L=1e-6
mnway30_cell8 ML30 gate_way30_cell8 GND GND n1 W=1e-6 L=1e-6
mpway30_cell8 ML30 gate_way30_cell8 GND ML30 p1 W=2.4e-6 L=1e-6
mnway30_cell9 ML30 gate_way30_cell9 GND GND n1 W=1e-6 L=1e-6
mpway30_cell9 ML30 gate_way30_cell9 GND ML30 p1 W=2.4e-6 L=1e-6
mnway30_cell10 ML30 gate_way30_cell10 GND GND n1 W=1e-6 L=1e-6
mpway30_cell10 ML30 gate_way30_cell10 GND ML30 p1 W=2.4e-6 L=1e-6
mnway30_cell11 ML30 gate_way30_cell11 GND GND n1 W=1e-6 L=1e-6
mpway30_cell11 ML30 gate_way30_cell11 GND ML30 p1 W=2.4e-6 L=1e-6
mnway30_cell12 ML30 gate_way30_cell12 GND GND n1 W=1e-6 L=1e-6
mpway30_cell12 ML30 gate_way30_cell12 GND ML30 p1 W=2.4e-6 L=1e-6
mnway30_cell13 ML30 gate_way30_cell13 GND GND n1 W=1e-6 L=1e-6
mpway30_cell13 ML30 gate_way30_cell13 GND ML30 p1 W=2.4e-6 L=1e-6
mnway30_cell14 ML30 gate_way30_cell14 GND GND n1 W=1e-6 L=1e-6
mpway30_cell14 ML30 gate_way30_cell14 GND ML30 p1 W=2.4e-6 L=1e-6
mnway30_cell15 ML30 gate_way30_cell15 GND GND n1 W=1e-6 L=1e-6
mpway30_cell15 ML30 gate_way30_cell15 GND ML30 p1 W=2.4e-6 L=1e-6
mnway30_cell16 ML30 gate_way30_cell16 GND GND n1 W=1e-6 L=1e-6
mpway30_cell16 ML30 gate_way30_cell16 GND ML30 p1 W=2.4e-6 L=1e-6
mnway30_cell17 ML30 gate_way30_cell17 GND GND n1 W=1e-6 L=1e-6
mpway30_cell17 ML30 gate_way30_cell17 GND ML30 p1 W=2.4e-6 L=1e-6
mnway30_cell18 ML30 gate_way30_cell18 GND GND n1 W=1e-6 L=1e-6
mpway30_cell18 ML30 gate_way30_cell18 GND ML30 p1 W=2.4e-6 L=1e-6
mnway30_cell19 ML30 gate_way30_cell19 GND GND n1 W=1e-6 L=1e-6
mpway30_cell19 ML30 gate_way30_cell19 GND ML30 p1 W=2.4e-6 L=1e-6
mnway30_cell20 ML30 gate_way30_cell20 GND GND n1 W=1e-6 L=1e-6
mpway30_cell20 ML30 gate_way30_cell20 GND ML30 p1 W=2.4e-6 L=1e-6
mnway30_cell21 ML30 gate_way30_cell21 GND GND n1 W=1e-6 L=1e-6
mpway30_cell21 ML30 gate_way30_cell21 GND ML30 p1 W=2.4e-6 L=1e-6
mnway30_cell22 ML30 gate_way30_cell22 GND GND n1 W=1e-6 L=1e-6
mpway30_cell22 ML30 gate_way30_cell22 GND ML30 p1 W=2.4e-6 L=1e-6
mnway30_cell23 ML30 gate_way30_cell23 GND GND n1 W=1e-6 L=1e-6
mpway30_cell23 ML30 gate_way30_cell23 GND ML30 p1 W=2.4e-6 L=1e-6
mnway30_cell24 ML30 gate_way30_cell24 GND GND n1 W=1e-6 L=1e-6
mpway30_cell24 ML30 gate_way30_cell24 GND ML30 p1 W=2.4e-6 L=1e-6
mnway30_cell25 ML30 gate_way30_cell25 GND GND n1 W=1e-6 L=1e-6
mpway30_cell25 ML30 gate_way30_cell25 GND ML30 p1 W=2.4e-6 L=1e-6
mnway30_cell26 ML30 gate_way30_cell26 GND GND n1 W=1e-6 L=1e-6
mpway30_cell26 ML30 gate_way30_cell26 GND ML30 p1 W=2.4e-6 L=1e-6
mnway30_cell27 ML30 gate_way30_cell27 GND GND n1 W=1e-6 L=1e-6
mpway30_cell27 ML30 gate_way30_cell27 GND ML30 p1 W=2.4e-6 L=1e-6
mnway30_cell28 ML30 gate_way30_cell28 GND GND n1 W=1e-6 L=1e-6
mpway30_cell28 ML30 gate_way30_cell28 GND ML30 p1 W=2.4e-6 L=1e-6
mnway30_cell29 ML30 gate_way30_cell29 GND GND n1 W=1e-6 L=1e-6
mpway30_cell29 ML30 gate_way30_cell29 GND ML30 p1 W=2.4e-6 L=1e-6
mnway30_cell30 ML30 gate_way30_cell30 GND GND n1 W=1e-6 L=1e-6
mpway30_cell30 ML30 gate_way30_cell30 GND ML30 p1 W=2.4e-6 L=1e-6
mnway30_cell31 ML30 gate_way30_cell31 GND GND n1 W=1e-6 L=1e-6
mpway30_cell31 ML30 gate_way30_cell31 GND ML30 p1 W=2.4e-6 L=1e-6
mnway30_cell32 ML30 gate_way30_cell32 GND GND n1 W=1e-6 L=1e-6
mpway30_cell32 ML30 gate_way30_cell32 GND ML30 p1 W=2.4e-6 L=1e-6
mnway30_cell33 ML30 gate_way30_cell33 GND GND n1 W=1e-6 L=1e-6
mpway30_cell33 ML30 gate_way30_cell33 GND ML30 p1 W=2.4e-6 L=1e-6
mnway30_cell34 ML30 gate_way30_cell34 GND GND n1 W=1e-6 L=1e-6
mpway30_cell34 ML30 gate_way30_cell34 GND ML30 p1 W=2.4e-6 L=1e-6
mnway30_cell35 ML30 gate_way30_cell35 GND GND n1 W=1e-6 L=1e-6
mpway30_cell35 ML30 gate_way30_cell35 GND ML30 p1 W=2.4e-6 L=1e-6
mnway30_cell36 ML30 gate_way30_cell36 GND GND n1 W=1e-6 L=1e-6
mpway30_cell36 ML30 gate_way30_cell36 GND ML30 p1 W=2.4e-6 L=1e-6
mnway30_cell37 ML30 gate_way30_cell37 GND GND n1 W=1e-6 L=1e-6
mpway30_cell37 ML30 gate_way30_cell37 GND ML30 p1 W=2.4e-6 L=1e-6
mnway30_cell38 ML30 gate_way30_cell38 GND GND n1 W=1e-6 L=1e-6
mpway30_cell38 ML30 gate_way30_cell38 GND ML30 p1 W=2.4e-6 L=1e-6
mnway30_cell39 ML30 gate_way30_cell39 GND GND n1 W=1e-6 L=1e-6
mpway30_cell39 ML30 gate_way30_cell39 GND ML30 p1 W=2.4e-6 L=1e-6
mnway30_cell40 ML30 gate_way30_cell40 GND GND n1 W=1e-6 L=1e-6
mpway30_cell40 ML30 gate_way30_cell40 GND ML30 p1 W=2.4e-6 L=1e-6
mnway30_cell41 ML30 gate_way30_cell41 GND GND n1 W=1e-6 L=1e-6
mpway30_cell41 ML30 gate_way30_cell41 GND ML30 p1 W=2.4e-6 L=1e-6
mnway30_cell42 ML30 gate_way30_cell42 GND GND n1 W=1e-6 L=1e-6
mpway30_cell42 ML30 gate_way30_cell42 GND ML30 p1 W=2.4e-6 L=1e-6
mnway30_cell43 ML30 gate_way30_cell43 GND GND n1 W=1e-6 L=1e-6
mpway30_cell43 ML30 gate_way30_cell43 GND ML30 p1 W=2.4e-6 L=1e-6
mnway30_cell44 ML30 gate_way30_cell44 GND GND n1 W=1e-6 L=1e-6
mpway30_cell44 ML30 gate_way30_cell44 GND ML30 p1 W=2.4e-6 L=1e-6
mnway30_cell45 ML30 gate_way30_cell45 GND GND n1 W=1e-6 L=1e-6
mpway30_cell45 ML30 gate_way30_cell45 GND ML30 p1 W=2.4e-6 L=1e-6
mnway30_cell46 ML30 gate_way30_cell46 GND GND n1 W=1e-6 L=1e-6
mpway30_cell46 ML30 gate_way30_cell46 GND ML30 p1 W=2.4e-6 L=1e-6
mnway30_cell47 ML30 gate_way30_cell47 GND GND n1 W=1e-6 L=1e-6
mpway30_cell47 ML30 gate_way30_cell47 GND ML30 p1 W=2.4e-6 L=1e-6
mnway30_cell48 ML30 gate_way30_cell48 GND GND n1 W=1e-6 L=1e-6
mpway30_cell48 ML30 gate_way30_cell48 GND ML30 p1 W=2.4e-6 L=1e-6
mnway30_cell49 ML30 gate_way30_cell49 GND GND n1 W=1e-6 L=1e-6
mpway30_cell49 ML30 gate_way30_cell49 GND ML30 p1 W=2.4e-6 L=1e-6
mnway30_cell50 ML30 gate_way30_cell50 GND GND n1 W=1e-6 L=1e-6
mpway30_cell50 ML30 gate_way30_cell50 GND ML30 p1 W=2.4e-6 L=1e-6
mnway30_cell51 ML30 gate_way30_cell51 GND GND n1 W=1e-6 L=1e-6
mpway30_cell51 ML30 gate_way30_cell51 GND ML30 p1 W=2.4e-6 L=1e-6
mnway30_cell52 ML30 gate_way30_cell52 GND GND n1 W=1e-6 L=1e-6
mpway30_cell52 ML30 gate_way30_cell52 GND ML30 p1 W=2.4e-6 L=1e-6
mnway30_cell53 ML30 gate_way30_cell53 GND GND n1 W=1e-6 L=1e-6
mpway30_cell53 ML30 gate_way30_cell53 GND ML30 p1 W=2.4e-6 L=1e-6
mnway30_cell54 ML30 gate_way30_cell54 GND GND n1 W=1e-6 L=1e-6
mpway30_cell54 ML30 gate_way30_cell54 GND ML30 p1 W=2.4e-6 L=1e-6
mnway30_cell55 ML30 gate_way30_cell55 GND GND n1 W=1e-6 L=1e-6
mpway30_cell55 ML30 gate_way30_cell55 GND ML30 p1 W=2.4e-6 L=1e-6
mnway30_cell56 ML30 gate_way30_cell56 GND GND n1 W=1e-6 L=1e-6
mpway30_cell56 ML30 gate_way30_cell56 GND ML30 p1 W=2.4e-6 L=1e-6
mnway30_cell57 ML30 gate_way30_cell57 GND GND n1 W=1e-6 L=1e-6
mpway30_cell57 ML30 gate_way30_cell57 GND ML30 p1 W=2.4e-6 L=1e-6
mnway30_cell58 ML30 gate_way30_cell58 GND GND n1 W=1e-6 L=1e-6
mpway30_cell58 ML30 gate_way30_cell58 GND ML30 p1 W=2.4e-6 L=1e-6
mnway30_cell59 ML30 gate_way30_cell59 GND GND n1 W=1e-6 L=1e-6
mpway30_cell59 ML30 gate_way30_cell59 GND ML30 p1 W=2.4e-6 L=1e-6
mnway30_cell60 ML30 gate_way30_cell60 GND GND n1 W=1e-6 L=1e-6
mpway30_cell60 ML30 gate_way30_cell60 GND ML30 p1 W=2.4e-6 L=1e-6
mnway30_cell61 ML30 gate_way30_cell61 GND GND n1 W=1e-6 L=1e-6
mpway30_cell61 ML30 gate_way30_cell61 GND ML30 p1 W=2.4e-6 L=1e-6
mnway30_cell62 ML30 gate_way30_cell62 GND GND n1 W=1e-6 L=1e-6
mpway30_cell62 ML30 gate_way30_cell62 GND ML30 p1 W=2.4e-6 L=1e-6
mnway30_cell63 ML30 gate_way30_cell63 GND GND n1 W=1e-6 L=1e-6
mpway30_cell63 ML30 gate_way30_cell63 GND ML30 p1 W=2.4e-6 L=1e-6
mnway30_cell64 ML30 gate_way30_cell64 GND GND n1 W=1e-6 L=1e-6
mpway30_cell64 ML30 gate_way30_cell64 GND ML30 p1 W=2.4e-6 L=1e-6
mnway30_cell65 ML30 gate_way30_cell65 GND GND n1 W=1e-6 L=1e-6
mpway30_cell65 ML30 gate_way30_cell65 GND ML30 p1 W=2.4e-6 L=1e-6
mnway30_cell66 ML30 gate_way30_cell66 GND GND n1 W=1e-6 L=1e-6
mpway30_cell66 ML30 gate_way30_cell66 GND ML30 p1 W=2.4e-6 L=1e-6
mnway30_cell67 ML30 gate_way30_cell67 GND GND n1 W=1e-6 L=1e-6
mpway30_cell67 ML30 gate_way30_cell67 GND ML30 p1 W=2.4e-6 L=1e-6
mnway30_cell68 ML30 gate_way30_cell68 GND GND n1 W=1e-6 L=1e-6
mpway30_cell68 ML30 gate_way30_cell68 GND ML30 p1 W=2.4e-6 L=1e-6
mnway30_cell69 ML30 gate_way30_cell69 GND GND n1 W=1e-6 L=1e-6
mpway30_cell69 ML30 gate_way30_cell69 GND ML30 p1 W=2.4e-6 L=1e-6
mnway30_cell70 ML30 gate_way30_cell70 GND GND n1 W=1e-6 L=1e-6
mpway30_cell70 ML30 gate_way30_cell70 GND ML30 p1 W=2.4e-6 L=1e-6
mnway30_cell71 ML30 gate_way30_cell71 GND GND n1 W=1e-6 L=1e-6
mpway30_cell71 ML30 gate_way30_cell71 GND ML30 p1 W=2.4e-6 L=1e-6
mnway30_cell72 ML30 gate_way30_cell72 GND GND n1 W=1e-6 L=1e-6
mpway30_cell72 ML30 gate_way30_cell72 GND ML30 p1 W=2.4e-6 L=1e-6
mnway30_cell73 ML30 gate_way30_cell73 GND GND n1 W=1e-6 L=1e-6
mpway30_cell73 ML30 gate_way30_cell73 GND ML30 p1 W=2.4e-6 L=1e-6
mnway30_cell74 ML30 gate_way30_cell74 GND GND n1 W=1e-6 L=1e-6
mpway30_cell74 ML30 gate_way30_cell74 GND ML30 p1 W=2.4e-6 L=1e-6
mnway30_cell75 ML30 gate_way30_cell75 GND GND n1 W=1e-6 L=1e-6
mpway30_cell75 ML30 gate_way30_cell75 GND ML30 p1 W=2.4e-6 L=1e-6
mnway30_cell76 ML30 gate_way30_cell76 GND GND n1 W=1e-6 L=1e-6
mpway30_cell76 ML30 gate_way30_cell76 GND ML30 p1 W=2.4e-6 L=1e-6
mnway30_cell77 ML30 gate_way30_cell77 GND GND n1 W=1e-6 L=1e-6
mpway30_cell77 ML30 gate_way30_cell77 GND ML30 p1 W=2.4e-6 L=1e-6
mnway30_cell78 ML30 gate_way30_cell78 GND GND n1 W=1e-6 L=1e-6
mpway30_cell78 ML30 gate_way30_cell78 GND ML30 p1 W=2.4e-6 L=1e-6
mnway30_cell79 ML30 gate_way30_cell79 GND GND n1 W=1e-6 L=1e-6
mpway30_cell79 ML30 gate_way30_cell79 GND ML30 p1 W=2.4e-6 L=1e-6
mnway30_cell80 ML30 gate_way30_cell80 GND GND n1 W=1e-6 L=1e-6
mpway30_cell80 ML30 gate_way30_cell80 GND ML30 p1 W=2.4e-6 L=1e-6
mnway30_cell81 ML30 gate_way30_cell81 GND GND n1 W=1e-6 L=1e-6
mpway30_cell81 ML30 gate_way30_cell81 GND ML30 p1 W=2.4e-6 L=1e-6
mnway30_cell82 ML30 gate_way30_cell82 GND GND n1 W=1e-6 L=1e-6
mpway30_cell82 ML30 gate_way30_cell82 GND ML30 p1 W=2.4e-6 L=1e-6
mnway30_cell83 ML30 gate_way30_cell83 GND GND n1 W=1e-6 L=1e-6
mpway30_cell83 ML30 gate_way30_cell83 GND ML30 p1 W=2.4e-6 L=1e-6
mnway30_cell84 ML30 gate_way30_cell84 GND GND n1 W=1e-6 L=1e-6
mpway30_cell84 ML30 gate_way30_cell84 GND ML30 p1 W=2.4e-6 L=1e-6
mnway30_cell85 ML30 gate_way30_cell85 GND GND n1 W=1e-6 L=1e-6
mpway30_cell85 ML30 gate_way30_cell85 GND ML30 p1 W=2.4e-6 L=1e-6
mnway30_cell86 ML30 gate_way30_cell86 GND GND n1 W=1e-6 L=1e-6
mpway30_cell86 ML30 gate_way30_cell86 GND ML30 p1 W=2.4e-6 L=1e-6
mnway30_cell87 ML30 gate_way30_cell87 GND GND n1 W=1e-6 L=1e-6
mpway30_cell87 ML30 gate_way30_cell87 GND ML30 p1 W=2.4e-6 L=1e-6
mnway30_cell88 ML30 gate_way30_cell88 GND GND n1 W=1e-6 L=1e-6
mpway30_cell88 ML30 gate_way30_cell88 GND ML30 p1 W=2.4e-6 L=1e-6
mnway30_cell89 ML30 gate_way30_cell89 GND GND n1 W=1e-6 L=1e-6
mpway30_cell89 ML30 gate_way30_cell89 GND ML30 p1 W=2.4e-6 L=1e-6
mnway30_cell90 ML30 gate_way30_cell90 GND GND n1 W=1e-6 L=1e-6
mpway30_cell90 ML30 gate_way30_cell90 GND ML30 p1 W=2.4e-6 L=1e-6
mnway30_cell91 ML30 gate_way30_cell91 GND GND n1 W=1e-6 L=1e-6
mpway30_cell91 ML30 gate_way30_cell91 GND ML30 p1 W=2.4e-6 L=1e-6
mnway30_cell92 ML30 gate_way30_cell92 GND GND n1 W=1e-6 L=1e-6
mpway30_cell92 ML30 gate_way30_cell92 GND ML30 p1 W=2.4e-6 L=1e-6
mnway30_cell93 ML30 gate_way30_cell93 GND GND n1 W=1e-6 L=1e-6
mpway30_cell93 ML30 gate_way30_cell93 GND ML30 p1 W=2.4e-6 L=1e-6
mnway30_cell94 ML30 gate_way30_cell94 GND GND n1 W=1e-6 L=1e-6
mpway30_cell94 ML30 gate_way30_cell94 GND ML30 p1 W=2.4e-6 L=1e-6
mnway30_cell95 ML30 gate_way30_cell95 GND GND n1 W=1e-6 L=1e-6
mpway30_cell95 ML30 gate_way30_cell95 GND ML30 p1 W=2.4e-6 L=1e-6
mnway30_cell96 ML30 gate_way30_cell96 GND GND n1 W=1e-6 L=1e-6
mpway30_cell96 ML30 gate_way30_cell96 GND ML30 p1 W=2.4e-6 L=1e-6
mnway30_cell97 ML30 gate_way30_cell97 GND GND n1 W=1e-6 L=1e-6
mpway30_cell97 ML30 gate_way30_cell97 GND ML30 p1 W=2.4e-6 L=1e-6
mnway30_cell98 ML30 gate_way30_cell98 GND GND n1 W=1e-6 L=1e-6
mpway30_cell98 ML30 gate_way30_cell98 GND ML30 p1 W=2.4e-6 L=1e-6
mnway30_cell99 ML30 gate_way30_cell99 GND GND n1 W=1e-6 L=1e-6
mpway30_cell99 ML30 gate_way30_cell99 GND ML30 p1 W=2.4e-6 L=1e-6
mnway31_cell0 ML31 gate_way31_cell0 GND GND n1 W=1e-6 L=1e-6
mpway31_cell0 ML31 gate_way31_cell0 GND ML31 p1 W=2.4e-6 L=1e-6
mnway31_cell1 ML31 gate_way31_cell1 GND GND n1 W=1e-6 L=1e-6
mpway31_cell1 ML31 gate_way31_cell1 GND ML31 p1 W=2.4e-6 L=1e-6
mnway31_cell2 ML31 gate_way31_cell2 GND GND n1 W=1e-6 L=1e-6
mpway31_cell2 ML31 gate_way31_cell2 GND ML31 p1 W=2.4e-6 L=1e-6
mnway31_cell3 ML31 gate_way31_cell3 GND GND n1 W=1e-6 L=1e-6
mpway31_cell3 ML31 gate_way31_cell3 GND ML31 p1 W=2.4e-6 L=1e-6
mnway31_cell4 ML31 gate_way31_cell4 GND GND n1 W=1e-6 L=1e-6
mpway31_cell4 ML31 gate_way31_cell4 GND ML31 p1 W=2.4e-6 L=1e-6
mnway31_cell5 ML31 gate_way31_cell5 GND GND n1 W=1e-6 L=1e-6
mpway31_cell5 ML31 gate_way31_cell5 GND ML31 p1 W=2.4e-6 L=1e-6
mnway31_cell6 ML31 gate_way31_cell6 GND GND n1 W=1e-6 L=1e-6
mpway31_cell6 ML31 gate_way31_cell6 GND ML31 p1 W=2.4e-6 L=1e-6
mnway31_cell7 ML31 gate_way31_cell7 GND GND n1 W=1e-6 L=1e-6
mpway31_cell7 ML31 gate_way31_cell7 GND ML31 p1 W=2.4e-6 L=1e-6
mnway31_cell8 ML31 gate_way31_cell8 GND GND n1 W=1e-6 L=1e-6
mpway31_cell8 ML31 gate_way31_cell8 GND ML31 p1 W=2.4e-6 L=1e-6
mnway31_cell9 ML31 gate_way31_cell9 GND GND n1 W=1e-6 L=1e-6
mpway31_cell9 ML31 gate_way31_cell9 GND ML31 p1 W=2.4e-6 L=1e-6
mnway31_cell10 ML31 gate_way31_cell10 GND GND n1 W=1e-6 L=1e-6
mpway31_cell10 ML31 gate_way31_cell10 GND ML31 p1 W=2.4e-6 L=1e-6
mnway31_cell11 ML31 gate_way31_cell11 GND GND n1 W=1e-6 L=1e-6
mpway31_cell11 ML31 gate_way31_cell11 GND ML31 p1 W=2.4e-6 L=1e-6
mnway31_cell12 ML31 gate_way31_cell12 GND GND n1 W=1e-6 L=1e-6
mpway31_cell12 ML31 gate_way31_cell12 GND ML31 p1 W=2.4e-6 L=1e-6
mnway31_cell13 ML31 gate_way31_cell13 GND GND n1 W=1e-6 L=1e-6
mpway31_cell13 ML31 gate_way31_cell13 GND ML31 p1 W=2.4e-6 L=1e-6
mnway31_cell14 ML31 gate_way31_cell14 GND GND n1 W=1e-6 L=1e-6
mpway31_cell14 ML31 gate_way31_cell14 GND ML31 p1 W=2.4e-6 L=1e-6
mnway31_cell15 ML31 gate_way31_cell15 GND GND n1 W=1e-6 L=1e-6
mpway31_cell15 ML31 gate_way31_cell15 GND ML31 p1 W=2.4e-6 L=1e-6
mnway31_cell16 ML31 gate_way31_cell16 GND GND n1 W=1e-6 L=1e-6
mpway31_cell16 ML31 gate_way31_cell16 GND ML31 p1 W=2.4e-6 L=1e-6
mnway31_cell17 ML31 gate_way31_cell17 GND GND n1 W=1e-6 L=1e-6
mpway31_cell17 ML31 gate_way31_cell17 GND ML31 p1 W=2.4e-6 L=1e-6
mnway31_cell18 ML31 gate_way31_cell18 GND GND n1 W=1e-6 L=1e-6
mpway31_cell18 ML31 gate_way31_cell18 GND ML31 p1 W=2.4e-6 L=1e-6
mnway31_cell19 ML31 gate_way31_cell19 GND GND n1 W=1e-6 L=1e-6
mpway31_cell19 ML31 gate_way31_cell19 GND ML31 p1 W=2.4e-6 L=1e-6
mnway31_cell20 ML31 gate_way31_cell20 GND GND n1 W=1e-6 L=1e-6
mpway31_cell20 ML31 gate_way31_cell20 GND ML31 p1 W=2.4e-6 L=1e-6
mnway31_cell21 ML31 gate_way31_cell21 GND GND n1 W=1e-6 L=1e-6
mpway31_cell21 ML31 gate_way31_cell21 GND ML31 p1 W=2.4e-6 L=1e-6
mnway31_cell22 ML31 gate_way31_cell22 GND GND n1 W=1e-6 L=1e-6
mpway31_cell22 ML31 gate_way31_cell22 GND ML31 p1 W=2.4e-6 L=1e-6
mnway31_cell23 ML31 gate_way31_cell23 GND GND n1 W=1e-6 L=1e-6
mpway31_cell23 ML31 gate_way31_cell23 GND ML31 p1 W=2.4e-6 L=1e-6
mnway31_cell24 ML31 gate_way31_cell24 GND GND n1 W=1e-6 L=1e-6
mpway31_cell24 ML31 gate_way31_cell24 GND ML31 p1 W=2.4e-6 L=1e-6
mnway31_cell25 ML31 gate_way31_cell25 GND GND n1 W=1e-6 L=1e-6
mpway31_cell25 ML31 gate_way31_cell25 GND ML31 p1 W=2.4e-6 L=1e-6
mnway31_cell26 ML31 gate_way31_cell26 GND GND n1 W=1e-6 L=1e-6
mpway31_cell26 ML31 gate_way31_cell26 GND ML31 p1 W=2.4e-6 L=1e-6
mnway31_cell27 ML31 gate_way31_cell27 GND GND n1 W=1e-6 L=1e-6
mpway31_cell27 ML31 gate_way31_cell27 GND ML31 p1 W=2.4e-6 L=1e-6
mnway31_cell28 ML31 gate_way31_cell28 GND GND n1 W=1e-6 L=1e-6
mpway31_cell28 ML31 gate_way31_cell28 GND ML31 p1 W=2.4e-6 L=1e-6
mnway31_cell29 ML31 gate_way31_cell29 GND GND n1 W=1e-6 L=1e-6
mpway31_cell29 ML31 gate_way31_cell29 GND ML31 p1 W=2.4e-6 L=1e-6
mnway31_cell30 ML31 gate_way31_cell30 GND GND n1 W=1e-6 L=1e-6
mpway31_cell30 ML31 gate_way31_cell30 GND ML31 p1 W=2.4e-6 L=1e-6
mnway31_cell31 ML31 gate_way31_cell31 GND GND n1 W=1e-6 L=1e-6
mpway31_cell31 ML31 gate_way31_cell31 GND ML31 p1 W=2.4e-6 L=1e-6
mnway31_cell32 ML31 gate_way31_cell32 GND GND n1 W=1e-6 L=1e-6
mpway31_cell32 ML31 gate_way31_cell32 GND ML31 p1 W=2.4e-6 L=1e-6
mnway31_cell33 ML31 gate_way31_cell33 GND GND n1 W=1e-6 L=1e-6
mpway31_cell33 ML31 gate_way31_cell33 GND ML31 p1 W=2.4e-6 L=1e-6
mnway31_cell34 ML31 gate_way31_cell34 GND GND n1 W=1e-6 L=1e-6
mpway31_cell34 ML31 gate_way31_cell34 GND ML31 p1 W=2.4e-6 L=1e-6
mnway31_cell35 ML31 gate_way31_cell35 GND GND n1 W=1e-6 L=1e-6
mpway31_cell35 ML31 gate_way31_cell35 GND ML31 p1 W=2.4e-6 L=1e-6
mnway31_cell36 ML31 gate_way31_cell36 GND GND n1 W=1e-6 L=1e-6
mpway31_cell36 ML31 gate_way31_cell36 GND ML31 p1 W=2.4e-6 L=1e-6
mnway31_cell37 ML31 gate_way31_cell37 GND GND n1 W=1e-6 L=1e-6
mpway31_cell37 ML31 gate_way31_cell37 GND ML31 p1 W=2.4e-6 L=1e-6
mnway31_cell38 ML31 gate_way31_cell38 GND GND n1 W=1e-6 L=1e-6
mpway31_cell38 ML31 gate_way31_cell38 GND ML31 p1 W=2.4e-6 L=1e-6
mnway31_cell39 ML31 gate_way31_cell39 GND GND n1 W=1e-6 L=1e-6
mpway31_cell39 ML31 gate_way31_cell39 GND ML31 p1 W=2.4e-6 L=1e-6
mnway31_cell40 ML31 gate_way31_cell40 GND GND n1 W=1e-6 L=1e-6
mpway31_cell40 ML31 gate_way31_cell40 GND ML31 p1 W=2.4e-6 L=1e-6
mnway31_cell41 ML31 gate_way31_cell41 GND GND n1 W=1e-6 L=1e-6
mpway31_cell41 ML31 gate_way31_cell41 GND ML31 p1 W=2.4e-6 L=1e-6
mnway31_cell42 ML31 gate_way31_cell42 GND GND n1 W=1e-6 L=1e-6
mpway31_cell42 ML31 gate_way31_cell42 GND ML31 p1 W=2.4e-6 L=1e-6
mnway31_cell43 ML31 gate_way31_cell43 GND GND n1 W=1e-6 L=1e-6
mpway31_cell43 ML31 gate_way31_cell43 GND ML31 p1 W=2.4e-6 L=1e-6
mnway31_cell44 ML31 gate_way31_cell44 GND GND n1 W=1e-6 L=1e-6
mpway31_cell44 ML31 gate_way31_cell44 GND ML31 p1 W=2.4e-6 L=1e-6
mnway31_cell45 ML31 gate_way31_cell45 GND GND n1 W=1e-6 L=1e-6
mpway31_cell45 ML31 gate_way31_cell45 GND ML31 p1 W=2.4e-6 L=1e-6
mnway31_cell46 ML31 gate_way31_cell46 GND GND n1 W=1e-6 L=1e-6
mpway31_cell46 ML31 gate_way31_cell46 GND ML31 p1 W=2.4e-6 L=1e-6
mnway31_cell47 ML31 gate_way31_cell47 GND GND n1 W=1e-6 L=1e-6
mpway31_cell47 ML31 gate_way31_cell47 GND ML31 p1 W=2.4e-6 L=1e-6
mnway31_cell48 ML31 gate_way31_cell48 GND GND n1 W=1e-6 L=1e-6
mpway31_cell48 ML31 gate_way31_cell48 GND ML31 p1 W=2.4e-6 L=1e-6
mnway31_cell49 ML31 gate_way31_cell49 GND GND n1 W=1e-6 L=1e-6
mpway31_cell49 ML31 gate_way31_cell49 GND ML31 p1 W=2.4e-6 L=1e-6
mnway31_cell50 ML31 gate_way31_cell50 GND GND n1 W=1e-6 L=1e-6
mpway31_cell50 ML31 gate_way31_cell50 GND ML31 p1 W=2.4e-6 L=1e-6
mnway31_cell51 ML31 gate_way31_cell51 GND GND n1 W=1e-6 L=1e-6
mpway31_cell51 ML31 gate_way31_cell51 GND ML31 p1 W=2.4e-6 L=1e-6
mnway31_cell52 ML31 gate_way31_cell52 GND GND n1 W=1e-6 L=1e-6
mpway31_cell52 ML31 gate_way31_cell52 GND ML31 p1 W=2.4e-6 L=1e-6
mnway31_cell53 ML31 gate_way31_cell53 GND GND n1 W=1e-6 L=1e-6
mpway31_cell53 ML31 gate_way31_cell53 GND ML31 p1 W=2.4e-6 L=1e-6
mnway31_cell54 ML31 gate_way31_cell54 GND GND n1 W=1e-6 L=1e-6
mpway31_cell54 ML31 gate_way31_cell54 GND ML31 p1 W=2.4e-6 L=1e-6
mnway31_cell55 ML31 gate_way31_cell55 GND GND n1 W=1e-6 L=1e-6
mpway31_cell55 ML31 gate_way31_cell55 GND ML31 p1 W=2.4e-6 L=1e-6
mnway31_cell56 ML31 gate_way31_cell56 GND GND n1 W=1e-6 L=1e-6
mpway31_cell56 ML31 gate_way31_cell56 GND ML31 p1 W=2.4e-6 L=1e-6
mnway31_cell57 ML31 gate_way31_cell57 GND GND n1 W=1e-6 L=1e-6
mpway31_cell57 ML31 gate_way31_cell57 GND ML31 p1 W=2.4e-6 L=1e-6
mnway31_cell58 ML31 gate_way31_cell58 GND GND n1 W=1e-6 L=1e-6
mpway31_cell58 ML31 gate_way31_cell58 GND ML31 p1 W=2.4e-6 L=1e-6
mnway31_cell59 ML31 gate_way31_cell59 GND GND n1 W=1e-6 L=1e-6
mpway31_cell59 ML31 gate_way31_cell59 GND ML31 p1 W=2.4e-6 L=1e-6
mnway31_cell60 ML31 gate_way31_cell60 GND GND n1 W=1e-6 L=1e-6
mpway31_cell60 ML31 gate_way31_cell60 GND ML31 p1 W=2.4e-6 L=1e-6
mnway31_cell61 ML31 gate_way31_cell61 GND GND n1 W=1e-6 L=1e-6
mpway31_cell61 ML31 gate_way31_cell61 GND ML31 p1 W=2.4e-6 L=1e-6
mnway31_cell62 ML31 gate_way31_cell62 GND GND n1 W=1e-6 L=1e-6
mpway31_cell62 ML31 gate_way31_cell62 GND ML31 p1 W=2.4e-6 L=1e-6
mnway31_cell63 ML31 gate_way31_cell63 GND GND n1 W=1e-6 L=1e-6
mpway31_cell63 ML31 gate_way31_cell63 GND ML31 p1 W=2.4e-6 L=1e-6
mnway31_cell64 ML31 gate_way31_cell64 GND GND n1 W=1e-6 L=1e-6
mpway31_cell64 ML31 gate_way31_cell64 GND ML31 p1 W=2.4e-6 L=1e-6
mnway31_cell65 ML31 gate_way31_cell65 GND GND n1 W=1e-6 L=1e-6
mpway31_cell65 ML31 gate_way31_cell65 GND ML31 p1 W=2.4e-6 L=1e-6
mnway31_cell66 ML31 gate_way31_cell66 GND GND n1 W=1e-6 L=1e-6
mpway31_cell66 ML31 gate_way31_cell66 GND ML31 p1 W=2.4e-6 L=1e-6
mnway31_cell67 ML31 gate_way31_cell67 GND GND n1 W=1e-6 L=1e-6
mpway31_cell67 ML31 gate_way31_cell67 GND ML31 p1 W=2.4e-6 L=1e-6
mnway31_cell68 ML31 gate_way31_cell68 GND GND n1 W=1e-6 L=1e-6
mpway31_cell68 ML31 gate_way31_cell68 GND ML31 p1 W=2.4e-6 L=1e-6
mnway31_cell69 ML31 gate_way31_cell69 GND GND n1 W=1e-6 L=1e-6
mpway31_cell69 ML31 gate_way31_cell69 GND ML31 p1 W=2.4e-6 L=1e-6
mnway31_cell70 ML31 gate_way31_cell70 GND GND n1 W=1e-6 L=1e-6
mpway31_cell70 ML31 gate_way31_cell70 GND ML31 p1 W=2.4e-6 L=1e-6
mnway31_cell71 ML31 gate_way31_cell71 GND GND n1 W=1e-6 L=1e-6
mpway31_cell71 ML31 gate_way31_cell71 GND ML31 p1 W=2.4e-6 L=1e-6
mnway31_cell72 ML31 gate_way31_cell72 GND GND n1 W=1e-6 L=1e-6
mpway31_cell72 ML31 gate_way31_cell72 GND ML31 p1 W=2.4e-6 L=1e-6
mnway31_cell73 ML31 gate_way31_cell73 GND GND n1 W=1e-6 L=1e-6
mpway31_cell73 ML31 gate_way31_cell73 GND ML31 p1 W=2.4e-6 L=1e-6
mnway31_cell74 ML31 gate_way31_cell74 GND GND n1 W=1e-6 L=1e-6
mpway31_cell74 ML31 gate_way31_cell74 GND ML31 p1 W=2.4e-6 L=1e-6
mnway31_cell75 ML31 gate_way31_cell75 GND GND n1 W=1e-6 L=1e-6
mpway31_cell75 ML31 gate_way31_cell75 GND ML31 p1 W=2.4e-6 L=1e-6
mnway31_cell76 ML31 gate_way31_cell76 GND GND n1 W=1e-6 L=1e-6
mpway31_cell76 ML31 gate_way31_cell76 GND ML31 p1 W=2.4e-6 L=1e-6
mnway31_cell77 ML31 gate_way31_cell77 GND GND n1 W=1e-6 L=1e-6
mpway31_cell77 ML31 gate_way31_cell77 GND ML31 p1 W=2.4e-6 L=1e-6
mnway31_cell78 ML31 gate_way31_cell78 GND GND n1 W=1e-6 L=1e-6
mpway31_cell78 ML31 gate_way31_cell78 GND ML31 p1 W=2.4e-6 L=1e-6
mnway31_cell79 ML31 gate_way31_cell79 GND GND n1 W=1e-6 L=1e-6
mpway31_cell79 ML31 gate_way31_cell79 GND ML31 p1 W=2.4e-6 L=1e-6
mnway31_cell80 ML31 gate_way31_cell80 GND GND n1 W=1e-6 L=1e-6
mpway31_cell80 ML31 gate_way31_cell80 GND ML31 p1 W=2.4e-6 L=1e-6
mnway31_cell81 ML31 gate_way31_cell81 GND GND n1 W=1e-6 L=1e-6
mpway31_cell81 ML31 gate_way31_cell81 GND ML31 p1 W=2.4e-6 L=1e-6
mnway31_cell82 ML31 gate_way31_cell82 GND GND n1 W=1e-6 L=1e-6
mpway31_cell82 ML31 gate_way31_cell82 GND ML31 p1 W=2.4e-6 L=1e-6
mnway31_cell83 ML31 gate_way31_cell83 GND GND n1 W=1e-6 L=1e-6
mpway31_cell83 ML31 gate_way31_cell83 GND ML31 p1 W=2.4e-6 L=1e-6
mnway31_cell84 ML31 gate_way31_cell84 GND GND n1 W=1e-6 L=1e-6
mpway31_cell84 ML31 gate_way31_cell84 GND ML31 p1 W=2.4e-6 L=1e-6
mnway31_cell85 ML31 gate_way31_cell85 GND GND n1 W=1e-6 L=1e-6
mpway31_cell85 ML31 gate_way31_cell85 GND ML31 p1 W=2.4e-6 L=1e-6
mnway31_cell86 ML31 gate_way31_cell86 GND GND n1 W=1e-6 L=1e-6
mpway31_cell86 ML31 gate_way31_cell86 GND ML31 p1 W=2.4e-6 L=1e-6
mnway31_cell87 ML31 gate_way31_cell87 GND GND n1 W=1e-6 L=1e-6
mpway31_cell87 ML31 gate_way31_cell87 GND ML31 p1 W=2.4e-6 L=1e-6
mnway31_cell88 ML31 gate_way31_cell88 GND GND n1 W=1e-6 L=1e-6
mpway31_cell88 ML31 gate_way31_cell88 GND ML31 p1 W=2.4e-6 L=1e-6
mnway31_cell89 ML31 gate_way31_cell89 GND GND n1 W=1e-6 L=1e-6
mpway31_cell89 ML31 gate_way31_cell89 GND ML31 p1 W=2.4e-6 L=1e-6
mnway31_cell90 ML31 gate_way31_cell90 GND GND n1 W=1e-6 L=1e-6
mpway31_cell90 ML31 gate_way31_cell90 GND ML31 p1 W=2.4e-6 L=1e-6
mnway31_cell91 ML31 gate_way31_cell91 GND GND n1 W=1e-6 L=1e-6
mpway31_cell91 ML31 gate_way31_cell91 GND ML31 p1 W=2.4e-6 L=1e-6
mnway31_cell92 ML31 gate_way31_cell92 GND GND n1 W=1e-6 L=1e-6
mpway31_cell92 ML31 gate_way31_cell92 GND ML31 p1 W=2.4e-6 L=1e-6
mnway31_cell93 ML31 gate_way31_cell93 GND GND n1 W=1e-6 L=1e-6
mpway31_cell93 ML31 gate_way31_cell93 GND ML31 p1 W=2.4e-6 L=1e-6
mnway31_cell94 ML31 gate_way31_cell94 GND GND n1 W=1e-6 L=1e-6
mpway31_cell94 ML31 gate_way31_cell94 GND ML31 p1 W=2.4e-6 L=1e-6
mnway31_cell95 ML31 gate_way31_cell95 GND GND n1 W=1e-6 L=1e-6
mpway31_cell95 ML31 gate_way31_cell95 GND ML31 p1 W=2.4e-6 L=1e-6
mnway31_cell96 ML31 gate_way31_cell96 GND GND n1 W=1e-6 L=1e-6
mpway31_cell96 ML31 gate_way31_cell96 GND ML31 p1 W=2.4e-6 L=1e-6
mnway31_cell97 ML31 gate_way31_cell97 GND GND n1 W=1e-6 L=1e-6
mpway31_cell97 ML31 gate_way31_cell97 GND ML31 p1 W=2.4e-6 L=1e-6
mnway31_cell98 ML31 gate_way31_cell98 GND GND n1 W=1e-6 L=1e-6
mpway31_cell98 ML31 gate_way31_cell98 GND ML31 p1 W=2.4e-6 L=1e-6
mnway31_cell99 ML31 gate_way31_cell99 GND GND n1 W=1e-6 L=1e-6
mpway31_cell99 ML31 gate_way31_cell99 GND ML31 p1 W=2.4e-6 L=1e-6
mnway32_cell0 ML32 gate_way32_cell0 GND GND n1 W=1e-6 L=1e-6
mpway32_cell0 ML32 gate_way32_cell0 GND ML32 p1 W=2.4e-6 L=1e-6
mnway32_cell1 ML32 gate_way32_cell1 GND GND n1 W=1e-6 L=1e-6
mpway32_cell1 ML32 gate_way32_cell1 GND ML32 p1 W=2.4e-6 L=1e-6
mnway32_cell2 ML32 gate_way32_cell2 GND GND n1 W=1e-6 L=1e-6
mpway32_cell2 ML32 gate_way32_cell2 GND ML32 p1 W=2.4e-6 L=1e-6
mnway32_cell3 ML32 gate_way32_cell3 GND GND n1 W=1e-6 L=1e-6
mpway32_cell3 ML32 gate_way32_cell3 GND ML32 p1 W=2.4e-6 L=1e-6
mnway32_cell4 ML32 gate_way32_cell4 GND GND n1 W=1e-6 L=1e-6
mpway32_cell4 ML32 gate_way32_cell4 GND ML32 p1 W=2.4e-6 L=1e-6
mnway32_cell5 ML32 gate_way32_cell5 GND GND n1 W=1e-6 L=1e-6
mpway32_cell5 ML32 gate_way32_cell5 GND ML32 p1 W=2.4e-6 L=1e-6
mnway32_cell6 ML32 gate_way32_cell6 GND GND n1 W=1e-6 L=1e-6
mpway32_cell6 ML32 gate_way32_cell6 GND ML32 p1 W=2.4e-6 L=1e-6
mnway32_cell7 ML32 gate_way32_cell7 GND GND n1 W=1e-6 L=1e-6
mpway32_cell7 ML32 gate_way32_cell7 GND ML32 p1 W=2.4e-6 L=1e-6
mnway32_cell8 ML32 gate_way32_cell8 GND GND n1 W=1e-6 L=1e-6
mpway32_cell8 ML32 gate_way32_cell8 GND ML32 p1 W=2.4e-6 L=1e-6
mnway32_cell9 ML32 gate_way32_cell9 GND GND n1 W=1e-6 L=1e-6
mpway32_cell9 ML32 gate_way32_cell9 GND ML32 p1 W=2.4e-6 L=1e-6
mnway32_cell10 ML32 gate_way32_cell10 GND GND n1 W=1e-6 L=1e-6
mpway32_cell10 ML32 gate_way32_cell10 GND ML32 p1 W=2.4e-6 L=1e-6
mnway32_cell11 ML32 gate_way32_cell11 GND GND n1 W=1e-6 L=1e-6
mpway32_cell11 ML32 gate_way32_cell11 GND ML32 p1 W=2.4e-6 L=1e-6
mnway32_cell12 ML32 gate_way32_cell12 GND GND n1 W=1e-6 L=1e-6
mpway32_cell12 ML32 gate_way32_cell12 GND ML32 p1 W=2.4e-6 L=1e-6
mnway32_cell13 ML32 gate_way32_cell13 GND GND n1 W=1e-6 L=1e-6
mpway32_cell13 ML32 gate_way32_cell13 GND ML32 p1 W=2.4e-6 L=1e-6
mnway32_cell14 ML32 gate_way32_cell14 GND GND n1 W=1e-6 L=1e-6
mpway32_cell14 ML32 gate_way32_cell14 GND ML32 p1 W=2.4e-6 L=1e-6
mnway32_cell15 ML32 gate_way32_cell15 GND GND n1 W=1e-6 L=1e-6
mpway32_cell15 ML32 gate_way32_cell15 GND ML32 p1 W=2.4e-6 L=1e-6
mnway32_cell16 ML32 gate_way32_cell16 GND GND n1 W=1e-6 L=1e-6
mpway32_cell16 ML32 gate_way32_cell16 GND ML32 p1 W=2.4e-6 L=1e-6
mnway32_cell17 ML32 gate_way32_cell17 GND GND n1 W=1e-6 L=1e-6
mpway32_cell17 ML32 gate_way32_cell17 GND ML32 p1 W=2.4e-6 L=1e-6
mnway32_cell18 ML32 gate_way32_cell18 GND GND n1 W=1e-6 L=1e-6
mpway32_cell18 ML32 gate_way32_cell18 GND ML32 p1 W=2.4e-6 L=1e-6
mnway32_cell19 ML32 gate_way32_cell19 GND GND n1 W=1e-6 L=1e-6
mpway32_cell19 ML32 gate_way32_cell19 GND ML32 p1 W=2.4e-6 L=1e-6
mnway32_cell20 ML32 gate_way32_cell20 GND GND n1 W=1e-6 L=1e-6
mpway32_cell20 ML32 gate_way32_cell20 GND ML32 p1 W=2.4e-6 L=1e-6
mnway32_cell21 ML32 gate_way32_cell21 GND GND n1 W=1e-6 L=1e-6
mpway32_cell21 ML32 gate_way32_cell21 GND ML32 p1 W=2.4e-6 L=1e-6
mnway32_cell22 ML32 gate_way32_cell22 GND GND n1 W=1e-6 L=1e-6
mpway32_cell22 ML32 gate_way32_cell22 GND ML32 p1 W=2.4e-6 L=1e-6
mnway32_cell23 ML32 gate_way32_cell23 GND GND n1 W=1e-6 L=1e-6
mpway32_cell23 ML32 gate_way32_cell23 GND ML32 p1 W=2.4e-6 L=1e-6
mnway32_cell24 ML32 gate_way32_cell24 GND GND n1 W=1e-6 L=1e-6
mpway32_cell24 ML32 gate_way32_cell24 GND ML32 p1 W=2.4e-6 L=1e-6
mnway32_cell25 ML32 gate_way32_cell25 GND GND n1 W=1e-6 L=1e-6
mpway32_cell25 ML32 gate_way32_cell25 GND ML32 p1 W=2.4e-6 L=1e-6
mnway32_cell26 ML32 gate_way32_cell26 GND GND n1 W=1e-6 L=1e-6
mpway32_cell26 ML32 gate_way32_cell26 GND ML32 p1 W=2.4e-6 L=1e-6
mnway32_cell27 ML32 gate_way32_cell27 GND GND n1 W=1e-6 L=1e-6
mpway32_cell27 ML32 gate_way32_cell27 GND ML32 p1 W=2.4e-6 L=1e-6
mnway32_cell28 ML32 gate_way32_cell28 GND GND n1 W=1e-6 L=1e-6
mpway32_cell28 ML32 gate_way32_cell28 GND ML32 p1 W=2.4e-6 L=1e-6
mnway32_cell29 ML32 gate_way32_cell29 GND GND n1 W=1e-6 L=1e-6
mpway32_cell29 ML32 gate_way32_cell29 GND ML32 p1 W=2.4e-6 L=1e-6
mnway32_cell30 ML32 gate_way32_cell30 GND GND n1 W=1e-6 L=1e-6
mpway32_cell30 ML32 gate_way32_cell30 GND ML32 p1 W=2.4e-6 L=1e-6
mnway32_cell31 ML32 gate_way32_cell31 GND GND n1 W=1e-6 L=1e-6
mpway32_cell31 ML32 gate_way32_cell31 GND ML32 p1 W=2.4e-6 L=1e-6
mnway32_cell32 ML32 gate_way32_cell32 GND GND n1 W=1e-6 L=1e-6
mpway32_cell32 ML32 gate_way32_cell32 GND ML32 p1 W=2.4e-6 L=1e-6
mnway32_cell33 ML32 gate_way32_cell33 GND GND n1 W=1e-6 L=1e-6
mpway32_cell33 ML32 gate_way32_cell33 GND ML32 p1 W=2.4e-6 L=1e-6
mnway32_cell34 ML32 gate_way32_cell34 GND GND n1 W=1e-6 L=1e-6
mpway32_cell34 ML32 gate_way32_cell34 GND ML32 p1 W=2.4e-6 L=1e-6
mnway32_cell35 ML32 gate_way32_cell35 GND GND n1 W=1e-6 L=1e-6
mpway32_cell35 ML32 gate_way32_cell35 GND ML32 p1 W=2.4e-6 L=1e-6
mnway32_cell36 ML32 gate_way32_cell36 GND GND n1 W=1e-6 L=1e-6
mpway32_cell36 ML32 gate_way32_cell36 GND ML32 p1 W=2.4e-6 L=1e-6
mnway32_cell37 ML32 gate_way32_cell37 GND GND n1 W=1e-6 L=1e-6
mpway32_cell37 ML32 gate_way32_cell37 GND ML32 p1 W=2.4e-6 L=1e-6
mnway32_cell38 ML32 gate_way32_cell38 GND GND n1 W=1e-6 L=1e-6
mpway32_cell38 ML32 gate_way32_cell38 GND ML32 p1 W=2.4e-6 L=1e-6
mnway32_cell39 ML32 gate_way32_cell39 GND GND n1 W=1e-6 L=1e-6
mpway32_cell39 ML32 gate_way32_cell39 GND ML32 p1 W=2.4e-6 L=1e-6
mnway32_cell40 ML32 gate_way32_cell40 GND GND n1 W=1e-6 L=1e-6
mpway32_cell40 ML32 gate_way32_cell40 GND ML32 p1 W=2.4e-6 L=1e-6
mnway32_cell41 ML32 gate_way32_cell41 GND GND n1 W=1e-6 L=1e-6
mpway32_cell41 ML32 gate_way32_cell41 GND ML32 p1 W=2.4e-6 L=1e-6
mnway32_cell42 ML32 gate_way32_cell42 GND GND n1 W=1e-6 L=1e-6
mpway32_cell42 ML32 gate_way32_cell42 GND ML32 p1 W=2.4e-6 L=1e-6
mnway32_cell43 ML32 gate_way32_cell43 GND GND n1 W=1e-6 L=1e-6
mpway32_cell43 ML32 gate_way32_cell43 GND ML32 p1 W=2.4e-6 L=1e-6
mnway32_cell44 ML32 gate_way32_cell44 GND GND n1 W=1e-6 L=1e-6
mpway32_cell44 ML32 gate_way32_cell44 GND ML32 p1 W=2.4e-6 L=1e-6
mnway32_cell45 ML32 gate_way32_cell45 GND GND n1 W=1e-6 L=1e-6
mpway32_cell45 ML32 gate_way32_cell45 GND ML32 p1 W=2.4e-6 L=1e-6
mnway32_cell46 ML32 gate_way32_cell46 GND GND n1 W=1e-6 L=1e-6
mpway32_cell46 ML32 gate_way32_cell46 GND ML32 p1 W=2.4e-6 L=1e-6
mnway32_cell47 ML32 gate_way32_cell47 GND GND n1 W=1e-6 L=1e-6
mpway32_cell47 ML32 gate_way32_cell47 GND ML32 p1 W=2.4e-6 L=1e-6
mnway32_cell48 ML32 gate_way32_cell48 GND GND n1 W=1e-6 L=1e-6
mpway32_cell48 ML32 gate_way32_cell48 GND ML32 p1 W=2.4e-6 L=1e-6
mnway32_cell49 ML32 gate_way32_cell49 GND GND n1 W=1e-6 L=1e-6
mpway32_cell49 ML32 gate_way32_cell49 GND ML32 p1 W=2.4e-6 L=1e-6
mnway32_cell50 ML32 gate_way32_cell50 GND GND n1 W=1e-6 L=1e-6
mpway32_cell50 ML32 gate_way32_cell50 GND ML32 p1 W=2.4e-6 L=1e-6
mnway32_cell51 ML32 gate_way32_cell51 GND GND n1 W=1e-6 L=1e-6
mpway32_cell51 ML32 gate_way32_cell51 GND ML32 p1 W=2.4e-6 L=1e-6
mnway32_cell52 ML32 gate_way32_cell52 GND GND n1 W=1e-6 L=1e-6
mpway32_cell52 ML32 gate_way32_cell52 GND ML32 p1 W=2.4e-6 L=1e-6
mnway32_cell53 ML32 gate_way32_cell53 GND GND n1 W=1e-6 L=1e-6
mpway32_cell53 ML32 gate_way32_cell53 GND ML32 p1 W=2.4e-6 L=1e-6
mnway32_cell54 ML32 gate_way32_cell54 GND GND n1 W=1e-6 L=1e-6
mpway32_cell54 ML32 gate_way32_cell54 GND ML32 p1 W=2.4e-6 L=1e-6
mnway32_cell55 ML32 gate_way32_cell55 GND GND n1 W=1e-6 L=1e-6
mpway32_cell55 ML32 gate_way32_cell55 GND ML32 p1 W=2.4e-6 L=1e-6
mnway32_cell56 ML32 gate_way32_cell56 GND GND n1 W=1e-6 L=1e-6
mpway32_cell56 ML32 gate_way32_cell56 GND ML32 p1 W=2.4e-6 L=1e-6
mnway32_cell57 ML32 gate_way32_cell57 GND GND n1 W=1e-6 L=1e-6
mpway32_cell57 ML32 gate_way32_cell57 GND ML32 p1 W=2.4e-6 L=1e-6
mnway32_cell58 ML32 gate_way32_cell58 GND GND n1 W=1e-6 L=1e-6
mpway32_cell58 ML32 gate_way32_cell58 GND ML32 p1 W=2.4e-6 L=1e-6
mnway32_cell59 ML32 gate_way32_cell59 GND GND n1 W=1e-6 L=1e-6
mpway32_cell59 ML32 gate_way32_cell59 GND ML32 p1 W=2.4e-6 L=1e-6
mnway32_cell60 ML32 gate_way32_cell60 GND GND n1 W=1e-6 L=1e-6
mpway32_cell60 ML32 gate_way32_cell60 GND ML32 p1 W=2.4e-6 L=1e-6
mnway32_cell61 ML32 gate_way32_cell61 GND GND n1 W=1e-6 L=1e-6
mpway32_cell61 ML32 gate_way32_cell61 GND ML32 p1 W=2.4e-6 L=1e-6
mnway32_cell62 ML32 gate_way32_cell62 GND GND n1 W=1e-6 L=1e-6
mpway32_cell62 ML32 gate_way32_cell62 GND ML32 p1 W=2.4e-6 L=1e-6
mnway32_cell63 ML32 gate_way32_cell63 GND GND n1 W=1e-6 L=1e-6
mpway32_cell63 ML32 gate_way32_cell63 GND ML32 p1 W=2.4e-6 L=1e-6
mnway32_cell64 ML32 gate_way32_cell64 GND GND n1 W=1e-6 L=1e-6
mpway32_cell64 ML32 gate_way32_cell64 GND ML32 p1 W=2.4e-6 L=1e-6
mnway32_cell65 ML32 gate_way32_cell65 GND GND n1 W=1e-6 L=1e-6
mpway32_cell65 ML32 gate_way32_cell65 GND ML32 p1 W=2.4e-6 L=1e-6
mnway32_cell66 ML32 gate_way32_cell66 GND GND n1 W=1e-6 L=1e-6
mpway32_cell66 ML32 gate_way32_cell66 GND ML32 p1 W=2.4e-6 L=1e-6
mnway32_cell67 ML32 gate_way32_cell67 GND GND n1 W=1e-6 L=1e-6
mpway32_cell67 ML32 gate_way32_cell67 GND ML32 p1 W=2.4e-6 L=1e-6
mnway32_cell68 ML32 gate_way32_cell68 GND GND n1 W=1e-6 L=1e-6
mpway32_cell68 ML32 gate_way32_cell68 GND ML32 p1 W=2.4e-6 L=1e-6
mnway32_cell69 ML32 gate_way32_cell69 GND GND n1 W=1e-6 L=1e-6
mpway32_cell69 ML32 gate_way32_cell69 GND ML32 p1 W=2.4e-6 L=1e-6
mnway32_cell70 ML32 gate_way32_cell70 GND GND n1 W=1e-6 L=1e-6
mpway32_cell70 ML32 gate_way32_cell70 GND ML32 p1 W=2.4e-6 L=1e-6
mnway32_cell71 ML32 gate_way32_cell71 GND GND n1 W=1e-6 L=1e-6
mpway32_cell71 ML32 gate_way32_cell71 GND ML32 p1 W=2.4e-6 L=1e-6
mnway32_cell72 ML32 gate_way32_cell72 GND GND n1 W=1e-6 L=1e-6
mpway32_cell72 ML32 gate_way32_cell72 GND ML32 p1 W=2.4e-6 L=1e-6
mnway32_cell73 ML32 gate_way32_cell73 GND GND n1 W=1e-6 L=1e-6
mpway32_cell73 ML32 gate_way32_cell73 GND ML32 p1 W=2.4e-6 L=1e-6
mnway32_cell74 ML32 gate_way32_cell74 GND GND n1 W=1e-6 L=1e-6
mpway32_cell74 ML32 gate_way32_cell74 GND ML32 p1 W=2.4e-6 L=1e-6
mnway32_cell75 ML32 gate_way32_cell75 GND GND n1 W=1e-6 L=1e-6
mpway32_cell75 ML32 gate_way32_cell75 GND ML32 p1 W=2.4e-6 L=1e-6
mnway32_cell76 ML32 gate_way32_cell76 GND GND n1 W=1e-6 L=1e-6
mpway32_cell76 ML32 gate_way32_cell76 GND ML32 p1 W=2.4e-6 L=1e-6
mnway32_cell77 ML32 gate_way32_cell77 GND GND n1 W=1e-6 L=1e-6
mpway32_cell77 ML32 gate_way32_cell77 GND ML32 p1 W=2.4e-6 L=1e-6
mnway32_cell78 ML32 gate_way32_cell78 GND GND n1 W=1e-6 L=1e-6
mpway32_cell78 ML32 gate_way32_cell78 GND ML32 p1 W=2.4e-6 L=1e-6
mnway32_cell79 ML32 gate_way32_cell79 GND GND n1 W=1e-6 L=1e-6
mpway32_cell79 ML32 gate_way32_cell79 GND ML32 p1 W=2.4e-6 L=1e-6
mnway32_cell80 ML32 gate_way32_cell80 GND GND n1 W=1e-6 L=1e-6
mpway32_cell80 ML32 gate_way32_cell80 GND ML32 p1 W=2.4e-6 L=1e-6
mnway32_cell81 ML32 gate_way32_cell81 GND GND n1 W=1e-6 L=1e-6
mpway32_cell81 ML32 gate_way32_cell81 GND ML32 p1 W=2.4e-6 L=1e-6
mnway32_cell82 ML32 gate_way32_cell82 GND GND n1 W=1e-6 L=1e-6
mpway32_cell82 ML32 gate_way32_cell82 GND ML32 p1 W=2.4e-6 L=1e-6
mnway32_cell83 ML32 gate_way32_cell83 GND GND n1 W=1e-6 L=1e-6
mpway32_cell83 ML32 gate_way32_cell83 GND ML32 p1 W=2.4e-6 L=1e-6
mnway32_cell84 ML32 gate_way32_cell84 GND GND n1 W=1e-6 L=1e-6
mpway32_cell84 ML32 gate_way32_cell84 GND ML32 p1 W=2.4e-6 L=1e-6
mnway32_cell85 ML32 gate_way32_cell85 GND GND n1 W=1e-6 L=1e-6
mpway32_cell85 ML32 gate_way32_cell85 GND ML32 p1 W=2.4e-6 L=1e-6
mnway32_cell86 ML32 gate_way32_cell86 GND GND n1 W=1e-6 L=1e-6
mpway32_cell86 ML32 gate_way32_cell86 GND ML32 p1 W=2.4e-6 L=1e-6
mnway32_cell87 ML32 gate_way32_cell87 GND GND n1 W=1e-6 L=1e-6
mpway32_cell87 ML32 gate_way32_cell87 GND ML32 p1 W=2.4e-6 L=1e-6
mnway32_cell88 ML32 gate_way32_cell88 GND GND n1 W=1e-6 L=1e-6
mpway32_cell88 ML32 gate_way32_cell88 GND ML32 p1 W=2.4e-6 L=1e-6
mnway32_cell89 ML32 gate_way32_cell89 GND GND n1 W=1e-6 L=1e-6
mpway32_cell89 ML32 gate_way32_cell89 GND ML32 p1 W=2.4e-6 L=1e-6
mnway32_cell90 ML32 gate_way32_cell90 GND GND n1 W=1e-6 L=1e-6
mpway32_cell90 ML32 gate_way32_cell90 GND ML32 p1 W=2.4e-6 L=1e-6
mnway32_cell91 ML32 gate_way32_cell91 GND GND n1 W=1e-6 L=1e-6
mpway32_cell91 ML32 gate_way32_cell91 GND ML32 p1 W=2.4e-6 L=1e-6
mnway32_cell92 ML32 gate_way32_cell92 GND GND n1 W=1e-6 L=1e-6
mpway32_cell92 ML32 gate_way32_cell92 GND ML32 p1 W=2.4e-6 L=1e-6
mnway32_cell93 ML32 gate_way32_cell93 GND GND n1 W=1e-6 L=1e-6
mpway32_cell93 ML32 gate_way32_cell93 GND ML32 p1 W=2.4e-6 L=1e-6
mnway32_cell94 ML32 gate_way32_cell94 GND GND n1 W=1e-6 L=1e-6
mpway32_cell94 ML32 gate_way32_cell94 GND ML32 p1 W=2.4e-6 L=1e-6
mnway32_cell95 ML32 gate_way32_cell95 GND GND n1 W=1e-6 L=1e-6
mpway32_cell95 ML32 gate_way32_cell95 GND ML32 p1 W=2.4e-6 L=1e-6
mnway32_cell96 ML32 gate_way32_cell96 GND GND n1 W=1e-6 L=1e-6
mpway32_cell96 ML32 gate_way32_cell96 GND ML32 p1 W=2.4e-6 L=1e-6
mnway32_cell97 ML32 gate_way32_cell97 GND GND n1 W=1e-6 L=1e-6
mpway32_cell97 ML32 gate_way32_cell97 GND ML32 p1 W=2.4e-6 L=1e-6
mnway32_cell98 ML32 gate_way32_cell98 GND GND n1 W=1e-6 L=1e-6
mpway32_cell98 ML32 gate_way32_cell98 GND ML32 p1 W=2.4e-6 L=1e-6
mnway32_cell99 ML32 gate_way32_cell99 GND GND n1 W=1e-6 L=1e-6
mpway32_cell99 ML32 gate_way32_cell99 GND ML32 p1 W=2.4e-6 L=1e-6
mnway33_cell0 ML33 gate_way33_cell0 GND GND n1 W=1e-6 L=1e-6
mpway33_cell0 ML33 gate_way33_cell0 GND ML33 p1 W=2.4e-6 L=1e-6
mnway33_cell1 ML33 gate_way33_cell1 GND GND n1 W=1e-6 L=1e-6
mpway33_cell1 ML33 gate_way33_cell1 GND ML33 p1 W=2.4e-6 L=1e-6
mnway33_cell2 ML33 gate_way33_cell2 GND GND n1 W=1e-6 L=1e-6
mpway33_cell2 ML33 gate_way33_cell2 GND ML33 p1 W=2.4e-6 L=1e-6
mnway33_cell3 ML33 gate_way33_cell3 GND GND n1 W=1e-6 L=1e-6
mpway33_cell3 ML33 gate_way33_cell3 GND ML33 p1 W=2.4e-6 L=1e-6
mnway33_cell4 ML33 gate_way33_cell4 GND GND n1 W=1e-6 L=1e-6
mpway33_cell4 ML33 gate_way33_cell4 GND ML33 p1 W=2.4e-6 L=1e-6
mnway33_cell5 ML33 gate_way33_cell5 GND GND n1 W=1e-6 L=1e-6
mpway33_cell5 ML33 gate_way33_cell5 GND ML33 p1 W=2.4e-6 L=1e-6
mnway33_cell6 ML33 gate_way33_cell6 GND GND n1 W=1e-6 L=1e-6
mpway33_cell6 ML33 gate_way33_cell6 GND ML33 p1 W=2.4e-6 L=1e-6
mnway33_cell7 ML33 gate_way33_cell7 GND GND n1 W=1e-6 L=1e-6
mpway33_cell7 ML33 gate_way33_cell7 GND ML33 p1 W=2.4e-6 L=1e-6
mnway33_cell8 ML33 gate_way33_cell8 GND GND n1 W=1e-6 L=1e-6
mpway33_cell8 ML33 gate_way33_cell8 GND ML33 p1 W=2.4e-6 L=1e-6
mnway33_cell9 ML33 gate_way33_cell9 GND GND n1 W=1e-6 L=1e-6
mpway33_cell9 ML33 gate_way33_cell9 GND ML33 p1 W=2.4e-6 L=1e-6
mnway33_cell10 ML33 gate_way33_cell10 GND GND n1 W=1e-6 L=1e-6
mpway33_cell10 ML33 gate_way33_cell10 GND ML33 p1 W=2.4e-6 L=1e-6
mnway33_cell11 ML33 gate_way33_cell11 GND GND n1 W=1e-6 L=1e-6
mpway33_cell11 ML33 gate_way33_cell11 GND ML33 p1 W=2.4e-6 L=1e-6
mnway33_cell12 ML33 gate_way33_cell12 GND GND n1 W=1e-6 L=1e-6
mpway33_cell12 ML33 gate_way33_cell12 GND ML33 p1 W=2.4e-6 L=1e-6
mnway33_cell13 ML33 gate_way33_cell13 GND GND n1 W=1e-6 L=1e-6
mpway33_cell13 ML33 gate_way33_cell13 GND ML33 p1 W=2.4e-6 L=1e-6
mnway33_cell14 ML33 gate_way33_cell14 GND GND n1 W=1e-6 L=1e-6
mpway33_cell14 ML33 gate_way33_cell14 GND ML33 p1 W=2.4e-6 L=1e-6
mnway33_cell15 ML33 gate_way33_cell15 GND GND n1 W=1e-6 L=1e-6
mpway33_cell15 ML33 gate_way33_cell15 GND ML33 p1 W=2.4e-6 L=1e-6
mnway33_cell16 ML33 gate_way33_cell16 GND GND n1 W=1e-6 L=1e-6
mpway33_cell16 ML33 gate_way33_cell16 GND ML33 p1 W=2.4e-6 L=1e-6
mnway33_cell17 ML33 gate_way33_cell17 GND GND n1 W=1e-6 L=1e-6
mpway33_cell17 ML33 gate_way33_cell17 GND ML33 p1 W=2.4e-6 L=1e-6
mnway33_cell18 ML33 gate_way33_cell18 GND GND n1 W=1e-6 L=1e-6
mpway33_cell18 ML33 gate_way33_cell18 GND ML33 p1 W=2.4e-6 L=1e-6
mnway33_cell19 ML33 gate_way33_cell19 GND GND n1 W=1e-6 L=1e-6
mpway33_cell19 ML33 gate_way33_cell19 GND ML33 p1 W=2.4e-6 L=1e-6
mnway33_cell20 ML33 gate_way33_cell20 GND GND n1 W=1e-6 L=1e-6
mpway33_cell20 ML33 gate_way33_cell20 GND ML33 p1 W=2.4e-6 L=1e-6
mnway33_cell21 ML33 gate_way33_cell21 GND GND n1 W=1e-6 L=1e-6
mpway33_cell21 ML33 gate_way33_cell21 GND ML33 p1 W=2.4e-6 L=1e-6
mnway33_cell22 ML33 gate_way33_cell22 GND GND n1 W=1e-6 L=1e-6
mpway33_cell22 ML33 gate_way33_cell22 GND ML33 p1 W=2.4e-6 L=1e-6
mnway33_cell23 ML33 gate_way33_cell23 GND GND n1 W=1e-6 L=1e-6
mpway33_cell23 ML33 gate_way33_cell23 GND ML33 p1 W=2.4e-6 L=1e-6
mnway33_cell24 ML33 gate_way33_cell24 GND GND n1 W=1e-6 L=1e-6
mpway33_cell24 ML33 gate_way33_cell24 GND ML33 p1 W=2.4e-6 L=1e-6
mnway33_cell25 ML33 gate_way33_cell25 GND GND n1 W=1e-6 L=1e-6
mpway33_cell25 ML33 gate_way33_cell25 GND ML33 p1 W=2.4e-6 L=1e-6
mnway33_cell26 ML33 gate_way33_cell26 GND GND n1 W=1e-6 L=1e-6
mpway33_cell26 ML33 gate_way33_cell26 GND ML33 p1 W=2.4e-6 L=1e-6
mnway33_cell27 ML33 gate_way33_cell27 GND GND n1 W=1e-6 L=1e-6
mpway33_cell27 ML33 gate_way33_cell27 GND ML33 p1 W=2.4e-6 L=1e-6
mnway33_cell28 ML33 gate_way33_cell28 GND GND n1 W=1e-6 L=1e-6
mpway33_cell28 ML33 gate_way33_cell28 GND ML33 p1 W=2.4e-6 L=1e-6
mnway33_cell29 ML33 gate_way33_cell29 GND GND n1 W=1e-6 L=1e-6
mpway33_cell29 ML33 gate_way33_cell29 GND ML33 p1 W=2.4e-6 L=1e-6
mnway33_cell30 ML33 gate_way33_cell30 GND GND n1 W=1e-6 L=1e-6
mpway33_cell30 ML33 gate_way33_cell30 GND ML33 p1 W=2.4e-6 L=1e-6
mnway33_cell31 ML33 gate_way33_cell31 GND GND n1 W=1e-6 L=1e-6
mpway33_cell31 ML33 gate_way33_cell31 GND ML33 p1 W=2.4e-6 L=1e-6
mnway33_cell32 ML33 gate_way33_cell32 GND GND n1 W=1e-6 L=1e-6
mpway33_cell32 ML33 gate_way33_cell32 GND ML33 p1 W=2.4e-6 L=1e-6
mnway33_cell33 ML33 gate_way33_cell33 GND GND n1 W=1e-6 L=1e-6
mpway33_cell33 ML33 gate_way33_cell33 GND ML33 p1 W=2.4e-6 L=1e-6
mnway33_cell34 ML33 gate_way33_cell34 GND GND n1 W=1e-6 L=1e-6
mpway33_cell34 ML33 gate_way33_cell34 GND ML33 p1 W=2.4e-6 L=1e-6
mnway33_cell35 ML33 gate_way33_cell35 GND GND n1 W=1e-6 L=1e-6
mpway33_cell35 ML33 gate_way33_cell35 GND ML33 p1 W=2.4e-6 L=1e-6
mnway33_cell36 ML33 gate_way33_cell36 GND GND n1 W=1e-6 L=1e-6
mpway33_cell36 ML33 gate_way33_cell36 GND ML33 p1 W=2.4e-6 L=1e-6
mnway33_cell37 ML33 gate_way33_cell37 GND GND n1 W=1e-6 L=1e-6
mpway33_cell37 ML33 gate_way33_cell37 GND ML33 p1 W=2.4e-6 L=1e-6
mnway33_cell38 ML33 gate_way33_cell38 GND GND n1 W=1e-6 L=1e-6
mpway33_cell38 ML33 gate_way33_cell38 GND ML33 p1 W=2.4e-6 L=1e-6
mnway33_cell39 ML33 gate_way33_cell39 GND GND n1 W=1e-6 L=1e-6
mpway33_cell39 ML33 gate_way33_cell39 GND ML33 p1 W=2.4e-6 L=1e-6
mnway33_cell40 ML33 gate_way33_cell40 GND GND n1 W=1e-6 L=1e-6
mpway33_cell40 ML33 gate_way33_cell40 GND ML33 p1 W=2.4e-6 L=1e-6
mnway33_cell41 ML33 gate_way33_cell41 GND GND n1 W=1e-6 L=1e-6
mpway33_cell41 ML33 gate_way33_cell41 GND ML33 p1 W=2.4e-6 L=1e-6
mnway33_cell42 ML33 gate_way33_cell42 GND GND n1 W=1e-6 L=1e-6
mpway33_cell42 ML33 gate_way33_cell42 GND ML33 p1 W=2.4e-6 L=1e-6
mnway33_cell43 ML33 gate_way33_cell43 GND GND n1 W=1e-6 L=1e-6
mpway33_cell43 ML33 gate_way33_cell43 GND ML33 p1 W=2.4e-6 L=1e-6
mnway33_cell44 ML33 gate_way33_cell44 GND GND n1 W=1e-6 L=1e-6
mpway33_cell44 ML33 gate_way33_cell44 GND ML33 p1 W=2.4e-6 L=1e-6
mnway33_cell45 ML33 gate_way33_cell45 GND GND n1 W=1e-6 L=1e-6
mpway33_cell45 ML33 gate_way33_cell45 GND ML33 p1 W=2.4e-6 L=1e-6
mnway33_cell46 ML33 gate_way33_cell46 GND GND n1 W=1e-6 L=1e-6
mpway33_cell46 ML33 gate_way33_cell46 GND ML33 p1 W=2.4e-6 L=1e-6
mnway33_cell47 ML33 gate_way33_cell47 GND GND n1 W=1e-6 L=1e-6
mpway33_cell47 ML33 gate_way33_cell47 GND ML33 p1 W=2.4e-6 L=1e-6
mnway33_cell48 ML33 gate_way33_cell48 GND GND n1 W=1e-6 L=1e-6
mpway33_cell48 ML33 gate_way33_cell48 GND ML33 p1 W=2.4e-6 L=1e-6
mnway33_cell49 ML33 gate_way33_cell49 GND GND n1 W=1e-6 L=1e-6
mpway33_cell49 ML33 gate_way33_cell49 GND ML33 p1 W=2.4e-6 L=1e-6
mnway33_cell50 ML33 gate_way33_cell50 GND GND n1 W=1e-6 L=1e-6
mpway33_cell50 ML33 gate_way33_cell50 GND ML33 p1 W=2.4e-6 L=1e-6
mnway33_cell51 ML33 gate_way33_cell51 GND GND n1 W=1e-6 L=1e-6
mpway33_cell51 ML33 gate_way33_cell51 GND ML33 p1 W=2.4e-6 L=1e-6
mnway33_cell52 ML33 gate_way33_cell52 GND GND n1 W=1e-6 L=1e-6
mpway33_cell52 ML33 gate_way33_cell52 GND ML33 p1 W=2.4e-6 L=1e-6
mnway33_cell53 ML33 gate_way33_cell53 GND GND n1 W=1e-6 L=1e-6
mpway33_cell53 ML33 gate_way33_cell53 GND ML33 p1 W=2.4e-6 L=1e-6
mnway33_cell54 ML33 gate_way33_cell54 GND GND n1 W=1e-6 L=1e-6
mpway33_cell54 ML33 gate_way33_cell54 GND ML33 p1 W=2.4e-6 L=1e-6
mnway33_cell55 ML33 gate_way33_cell55 GND GND n1 W=1e-6 L=1e-6
mpway33_cell55 ML33 gate_way33_cell55 GND ML33 p1 W=2.4e-6 L=1e-6
mnway33_cell56 ML33 gate_way33_cell56 GND GND n1 W=1e-6 L=1e-6
mpway33_cell56 ML33 gate_way33_cell56 GND ML33 p1 W=2.4e-6 L=1e-6
mnway33_cell57 ML33 gate_way33_cell57 GND GND n1 W=1e-6 L=1e-6
mpway33_cell57 ML33 gate_way33_cell57 GND ML33 p1 W=2.4e-6 L=1e-6
mnway33_cell58 ML33 gate_way33_cell58 GND GND n1 W=1e-6 L=1e-6
mpway33_cell58 ML33 gate_way33_cell58 GND ML33 p1 W=2.4e-6 L=1e-6
mnway33_cell59 ML33 gate_way33_cell59 GND GND n1 W=1e-6 L=1e-6
mpway33_cell59 ML33 gate_way33_cell59 GND ML33 p1 W=2.4e-6 L=1e-6
mnway33_cell60 ML33 gate_way33_cell60 GND GND n1 W=1e-6 L=1e-6
mpway33_cell60 ML33 gate_way33_cell60 GND ML33 p1 W=2.4e-6 L=1e-6
mnway33_cell61 ML33 gate_way33_cell61 GND GND n1 W=1e-6 L=1e-6
mpway33_cell61 ML33 gate_way33_cell61 GND ML33 p1 W=2.4e-6 L=1e-6
mnway33_cell62 ML33 gate_way33_cell62 GND GND n1 W=1e-6 L=1e-6
mpway33_cell62 ML33 gate_way33_cell62 GND ML33 p1 W=2.4e-6 L=1e-6
mnway33_cell63 ML33 gate_way33_cell63 GND GND n1 W=1e-6 L=1e-6
mpway33_cell63 ML33 gate_way33_cell63 GND ML33 p1 W=2.4e-6 L=1e-6
mnway33_cell64 ML33 gate_way33_cell64 GND GND n1 W=1e-6 L=1e-6
mpway33_cell64 ML33 gate_way33_cell64 GND ML33 p1 W=2.4e-6 L=1e-6
mnway33_cell65 ML33 gate_way33_cell65 GND GND n1 W=1e-6 L=1e-6
mpway33_cell65 ML33 gate_way33_cell65 GND ML33 p1 W=2.4e-6 L=1e-6
mnway33_cell66 ML33 gate_way33_cell66 GND GND n1 W=1e-6 L=1e-6
mpway33_cell66 ML33 gate_way33_cell66 GND ML33 p1 W=2.4e-6 L=1e-6
mnway33_cell67 ML33 gate_way33_cell67 GND GND n1 W=1e-6 L=1e-6
mpway33_cell67 ML33 gate_way33_cell67 GND ML33 p1 W=2.4e-6 L=1e-6
mnway33_cell68 ML33 gate_way33_cell68 GND GND n1 W=1e-6 L=1e-6
mpway33_cell68 ML33 gate_way33_cell68 GND ML33 p1 W=2.4e-6 L=1e-6
mnway33_cell69 ML33 gate_way33_cell69 GND GND n1 W=1e-6 L=1e-6
mpway33_cell69 ML33 gate_way33_cell69 GND ML33 p1 W=2.4e-6 L=1e-6
mnway33_cell70 ML33 gate_way33_cell70 GND GND n1 W=1e-6 L=1e-6
mpway33_cell70 ML33 gate_way33_cell70 GND ML33 p1 W=2.4e-6 L=1e-6
mnway33_cell71 ML33 gate_way33_cell71 GND GND n1 W=1e-6 L=1e-6
mpway33_cell71 ML33 gate_way33_cell71 GND ML33 p1 W=2.4e-6 L=1e-6
mnway33_cell72 ML33 gate_way33_cell72 GND GND n1 W=1e-6 L=1e-6
mpway33_cell72 ML33 gate_way33_cell72 GND ML33 p1 W=2.4e-6 L=1e-6
mnway33_cell73 ML33 gate_way33_cell73 GND GND n1 W=1e-6 L=1e-6
mpway33_cell73 ML33 gate_way33_cell73 GND ML33 p1 W=2.4e-6 L=1e-6
mnway33_cell74 ML33 gate_way33_cell74 GND GND n1 W=1e-6 L=1e-6
mpway33_cell74 ML33 gate_way33_cell74 GND ML33 p1 W=2.4e-6 L=1e-6
mnway33_cell75 ML33 gate_way33_cell75 GND GND n1 W=1e-6 L=1e-6
mpway33_cell75 ML33 gate_way33_cell75 GND ML33 p1 W=2.4e-6 L=1e-6
mnway33_cell76 ML33 gate_way33_cell76 GND GND n1 W=1e-6 L=1e-6
mpway33_cell76 ML33 gate_way33_cell76 GND ML33 p1 W=2.4e-6 L=1e-6
mnway33_cell77 ML33 gate_way33_cell77 GND GND n1 W=1e-6 L=1e-6
mpway33_cell77 ML33 gate_way33_cell77 GND ML33 p1 W=2.4e-6 L=1e-6
mnway33_cell78 ML33 gate_way33_cell78 GND GND n1 W=1e-6 L=1e-6
mpway33_cell78 ML33 gate_way33_cell78 GND ML33 p1 W=2.4e-6 L=1e-6
mnway33_cell79 ML33 gate_way33_cell79 GND GND n1 W=1e-6 L=1e-6
mpway33_cell79 ML33 gate_way33_cell79 GND ML33 p1 W=2.4e-6 L=1e-6
mnway33_cell80 ML33 gate_way33_cell80 GND GND n1 W=1e-6 L=1e-6
mpway33_cell80 ML33 gate_way33_cell80 GND ML33 p1 W=2.4e-6 L=1e-6
mnway33_cell81 ML33 gate_way33_cell81 GND GND n1 W=1e-6 L=1e-6
mpway33_cell81 ML33 gate_way33_cell81 GND ML33 p1 W=2.4e-6 L=1e-6
mnway33_cell82 ML33 gate_way33_cell82 GND GND n1 W=1e-6 L=1e-6
mpway33_cell82 ML33 gate_way33_cell82 GND ML33 p1 W=2.4e-6 L=1e-6
mnway33_cell83 ML33 gate_way33_cell83 GND GND n1 W=1e-6 L=1e-6
mpway33_cell83 ML33 gate_way33_cell83 GND ML33 p1 W=2.4e-6 L=1e-6
mnway33_cell84 ML33 gate_way33_cell84 GND GND n1 W=1e-6 L=1e-6
mpway33_cell84 ML33 gate_way33_cell84 GND ML33 p1 W=2.4e-6 L=1e-6
mnway33_cell85 ML33 gate_way33_cell85 GND GND n1 W=1e-6 L=1e-6
mpway33_cell85 ML33 gate_way33_cell85 GND ML33 p1 W=2.4e-6 L=1e-6
mnway33_cell86 ML33 gate_way33_cell86 GND GND n1 W=1e-6 L=1e-6
mpway33_cell86 ML33 gate_way33_cell86 GND ML33 p1 W=2.4e-6 L=1e-6
mnway33_cell87 ML33 gate_way33_cell87 GND GND n1 W=1e-6 L=1e-6
mpway33_cell87 ML33 gate_way33_cell87 GND ML33 p1 W=2.4e-6 L=1e-6
mnway33_cell88 ML33 gate_way33_cell88 GND GND n1 W=1e-6 L=1e-6
mpway33_cell88 ML33 gate_way33_cell88 GND ML33 p1 W=2.4e-6 L=1e-6
mnway33_cell89 ML33 gate_way33_cell89 GND GND n1 W=1e-6 L=1e-6
mpway33_cell89 ML33 gate_way33_cell89 GND ML33 p1 W=2.4e-6 L=1e-6
mnway33_cell90 ML33 gate_way33_cell90 GND GND n1 W=1e-6 L=1e-6
mpway33_cell90 ML33 gate_way33_cell90 GND ML33 p1 W=2.4e-6 L=1e-6
mnway33_cell91 ML33 gate_way33_cell91 GND GND n1 W=1e-6 L=1e-6
mpway33_cell91 ML33 gate_way33_cell91 GND ML33 p1 W=2.4e-6 L=1e-6
mnway33_cell92 ML33 gate_way33_cell92 GND GND n1 W=1e-6 L=1e-6
mpway33_cell92 ML33 gate_way33_cell92 GND ML33 p1 W=2.4e-6 L=1e-6
mnway33_cell93 ML33 gate_way33_cell93 GND GND n1 W=1e-6 L=1e-6
mpway33_cell93 ML33 gate_way33_cell93 GND ML33 p1 W=2.4e-6 L=1e-6
mnway33_cell94 ML33 gate_way33_cell94 GND GND n1 W=1e-6 L=1e-6
mpway33_cell94 ML33 gate_way33_cell94 GND ML33 p1 W=2.4e-6 L=1e-6
mnway33_cell95 ML33 gate_way33_cell95 GND GND n1 W=1e-6 L=1e-6
mpway33_cell95 ML33 gate_way33_cell95 GND ML33 p1 W=2.4e-6 L=1e-6
mnway33_cell96 ML33 gate_way33_cell96 GND GND n1 W=1e-6 L=1e-6
mpway33_cell96 ML33 gate_way33_cell96 GND ML33 p1 W=2.4e-6 L=1e-6
mnway33_cell97 ML33 gate_way33_cell97 GND GND n1 W=1e-6 L=1e-6
mpway33_cell97 ML33 gate_way33_cell97 GND ML33 p1 W=2.4e-6 L=1e-6
mnway33_cell98 ML33 gate_way33_cell98 GND GND n1 W=1e-6 L=1e-6
mpway33_cell98 ML33 gate_way33_cell98 GND ML33 p1 W=2.4e-6 L=1e-6
mnway33_cell99 ML33 gate_way33_cell99 GND GND n1 W=1e-6 L=1e-6
mpway33_cell99 ML33 gate_way33_cell99 GND ML33 p1 W=2.4e-6 L=1e-6
mnway34_cell0 ML34 gate_way34_cell0 GND GND n1 W=1e-6 L=1e-6
mpway34_cell0 ML34 gate_way34_cell0 GND ML34 p1 W=2.4e-6 L=1e-6
mnway34_cell1 ML34 gate_way34_cell1 GND GND n1 W=1e-6 L=1e-6
mpway34_cell1 ML34 gate_way34_cell1 GND ML34 p1 W=2.4e-6 L=1e-6
mnway34_cell2 ML34 gate_way34_cell2 GND GND n1 W=1e-6 L=1e-6
mpway34_cell2 ML34 gate_way34_cell2 GND ML34 p1 W=2.4e-6 L=1e-6
mnway34_cell3 ML34 gate_way34_cell3 GND GND n1 W=1e-6 L=1e-6
mpway34_cell3 ML34 gate_way34_cell3 GND ML34 p1 W=2.4e-6 L=1e-6
mnway34_cell4 ML34 gate_way34_cell4 GND GND n1 W=1e-6 L=1e-6
mpway34_cell4 ML34 gate_way34_cell4 GND ML34 p1 W=2.4e-6 L=1e-6
mnway34_cell5 ML34 gate_way34_cell5 GND GND n1 W=1e-6 L=1e-6
mpway34_cell5 ML34 gate_way34_cell5 GND ML34 p1 W=2.4e-6 L=1e-6
mnway34_cell6 ML34 gate_way34_cell6 GND GND n1 W=1e-6 L=1e-6
mpway34_cell6 ML34 gate_way34_cell6 GND ML34 p1 W=2.4e-6 L=1e-6
mnway34_cell7 ML34 gate_way34_cell7 GND GND n1 W=1e-6 L=1e-6
mpway34_cell7 ML34 gate_way34_cell7 GND ML34 p1 W=2.4e-6 L=1e-6
mnway34_cell8 ML34 gate_way34_cell8 GND GND n1 W=1e-6 L=1e-6
mpway34_cell8 ML34 gate_way34_cell8 GND ML34 p1 W=2.4e-6 L=1e-6
mnway34_cell9 ML34 gate_way34_cell9 GND GND n1 W=1e-6 L=1e-6
mpway34_cell9 ML34 gate_way34_cell9 GND ML34 p1 W=2.4e-6 L=1e-6
mnway34_cell10 ML34 gate_way34_cell10 GND GND n1 W=1e-6 L=1e-6
mpway34_cell10 ML34 gate_way34_cell10 GND ML34 p1 W=2.4e-6 L=1e-6
mnway34_cell11 ML34 gate_way34_cell11 GND GND n1 W=1e-6 L=1e-6
mpway34_cell11 ML34 gate_way34_cell11 GND ML34 p1 W=2.4e-6 L=1e-6
mnway34_cell12 ML34 gate_way34_cell12 GND GND n1 W=1e-6 L=1e-6
mpway34_cell12 ML34 gate_way34_cell12 GND ML34 p1 W=2.4e-6 L=1e-6
mnway34_cell13 ML34 gate_way34_cell13 GND GND n1 W=1e-6 L=1e-6
mpway34_cell13 ML34 gate_way34_cell13 GND ML34 p1 W=2.4e-6 L=1e-6
mnway34_cell14 ML34 gate_way34_cell14 GND GND n1 W=1e-6 L=1e-6
mpway34_cell14 ML34 gate_way34_cell14 GND ML34 p1 W=2.4e-6 L=1e-6
mnway34_cell15 ML34 gate_way34_cell15 GND GND n1 W=1e-6 L=1e-6
mpway34_cell15 ML34 gate_way34_cell15 GND ML34 p1 W=2.4e-6 L=1e-6
mnway34_cell16 ML34 gate_way34_cell16 GND GND n1 W=1e-6 L=1e-6
mpway34_cell16 ML34 gate_way34_cell16 GND ML34 p1 W=2.4e-6 L=1e-6
mnway34_cell17 ML34 gate_way34_cell17 GND GND n1 W=1e-6 L=1e-6
mpway34_cell17 ML34 gate_way34_cell17 GND ML34 p1 W=2.4e-6 L=1e-6
mnway34_cell18 ML34 gate_way34_cell18 GND GND n1 W=1e-6 L=1e-6
mpway34_cell18 ML34 gate_way34_cell18 GND ML34 p1 W=2.4e-6 L=1e-6
mnway34_cell19 ML34 gate_way34_cell19 GND GND n1 W=1e-6 L=1e-6
mpway34_cell19 ML34 gate_way34_cell19 GND ML34 p1 W=2.4e-6 L=1e-6
mnway34_cell20 ML34 gate_way34_cell20 GND GND n1 W=1e-6 L=1e-6
mpway34_cell20 ML34 gate_way34_cell20 GND ML34 p1 W=2.4e-6 L=1e-6
mnway34_cell21 ML34 gate_way34_cell21 GND GND n1 W=1e-6 L=1e-6
mpway34_cell21 ML34 gate_way34_cell21 GND ML34 p1 W=2.4e-6 L=1e-6
mnway34_cell22 ML34 gate_way34_cell22 GND GND n1 W=1e-6 L=1e-6
mpway34_cell22 ML34 gate_way34_cell22 GND ML34 p1 W=2.4e-6 L=1e-6
mnway34_cell23 ML34 gate_way34_cell23 GND GND n1 W=1e-6 L=1e-6
mpway34_cell23 ML34 gate_way34_cell23 GND ML34 p1 W=2.4e-6 L=1e-6
mnway34_cell24 ML34 gate_way34_cell24 GND GND n1 W=1e-6 L=1e-6
mpway34_cell24 ML34 gate_way34_cell24 GND ML34 p1 W=2.4e-6 L=1e-6
mnway34_cell25 ML34 gate_way34_cell25 GND GND n1 W=1e-6 L=1e-6
mpway34_cell25 ML34 gate_way34_cell25 GND ML34 p1 W=2.4e-6 L=1e-6
mnway34_cell26 ML34 gate_way34_cell26 GND GND n1 W=1e-6 L=1e-6
mpway34_cell26 ML34 gate_way34_cell26 GND ML34 p1 W=2.4e-6 L=1e-6
mnway34_cell27 ML34 gate_way34_cell27 GND GND n1 W=1e-6 L=1e-6
mpway34_cell27 ML34 gate_way34_cell27 GND ML34 p1 W=2.4e-6 L=1e-6
mnway34_cell28 ML34 gate_way34_cell28 GND GND n1 W=1e-6 L=1e-6
mpway34_cell28 ML34 gate_way34_cell28 GND ML34 p1 W=2.4e-6 L=1e-6
mnway34_cell29 ML34 gate_way34_cell29 GND GND n1 W=1e-6 L=1e-6
mpway34_cell29 ML34 gate_way34_cell29 GND ML34 p1 W=2.4e-6 L=1e-6
mnway34_cell30 ML34 gate_way34_cell30 GND GND n1 W=1e-6 L=1e-6
mpway34_cell30 ML34 gate_way34_cell30 GND ML34 p1 W=2.4e-6 L=1e-6
mnway34_cell31 ML34 gate_way34_cell31 GND GND n1 W=1e-6 L=1e-6
mpway34_cell31 ML34 gate_way34_cell31 GND ML34 p1 W=2.4e-6 L=1e-6
mnway34_cell32 ML34 gate_way34_cell32 GND GND n1 W=1e-6 L=1e-6
mpway34_cell32 ML34 gate_way34_cell32 GND ML34 p1 W=2.4e-6 L=1e-6
mnway34_cell33 ML34 gate_way34_cell33 GND GND n1 W=1e-6 L=1e-6
mpway34_cell33 ML34 gate_way34_cell33 GND ML34 p1 W=2.4e-6 L=1e-6
mnway34_cell34 ML34 gate_way34_cell34 GND GND n1 W=1e-6 L=1e-6
mpway34_cell34 ML34 gate_way34_cell34 GND ML34 p1 W=2.4e-6 L=1e-6
mnway34_cell35 ML34 gate_way34_cell35 GND GND n1 W=1e-6 L=1e-6
mpway34_cell35 ML34 gate_way34_cell35 GND ML34 p1 W=2.4e-6 L=1e-6
mnway34_cell36 ML34 gate_way34_cell36 GND GND n1 W=1e-6 L=1e-6
mpway34_cell36 ML34 gate_way34_cell36 GND ML34 p1 W=2.4e-6 L=1e-6
mnway34_cell37 ML34 gate_way34_cell37 GND GND n1 W=1e-6 L=1e-6
mpway34_cell37 ML34 gate_way34_cell37 GND ML34 p1 W=2.4e-6 L=1e-6
mnway34_cell38 ML34 gate_way34_cell38 GND GND n1 W=1e-6 L=1e-6
mpway34_cell38 ML34 gate_way34_cell38 GND ML34 p1 W=2.4e-6 L=1e-6
mnway34_cell39 ML34 gate_way34_cell39 GND GND n1 W=1e-6 L=1e-6
mpway34_cell39 ML34 gate_way34_cell39 GND ML34 p1 W=2.4e-6 L=1e-6
mnway34_cell40 ML34 gate_way34_cell40 GND GND n1 W=1e-6 L=1e-6
mpway34_cell40 ML34 gate_way34_cell40 GND ML34 p1 W=2.4e-6 L=1e-6
mnway34_cell41 ML34 gate_way34_cell41 GND GND n1 W=1e-6 L=1e-6
mpway34_cell41 ML34 gate_way34_cell41 GND ML34 p1 W=2.4e-6 L=1e-6
mnway34_cell42 ML34 gate_way34_cell42 GND GND n1 W=1e-6 L=1e-6
mpway34_cell42 ML34 gate_way34_cell42 GND ML34 p1 W=2.4e-6 L=1e-6
mnway34_cell43 ML34 gate_way34_cell43 GND GND n1 W=1e-6 L=1e-6
mpway34_cell43 ML34 gate_way34_cell43 GND ML34 p1 W=2.4e-6 L=1e-6
mnway34_cell44 ML34 gate_way34_cell44 GND GND n1 W=1e-6 L=1e-6
mpway34_cell44 ML34 gate_way34_cell44 GND ML34 p1 W=2.4e-6 L=1e-6
mnway34_cell45 ML34 gate_way34_cell45 GND GND n1 W=1e-6 L=1e-6
mpway34_cell45 ML34 gate_way34_cell45 GND ML34 p1 W=2.4e-6 L=1e-6
mnway34_cell46 ML34 gate_way34_cell46 GND GND n1 W=1e-6 L=1e-6
mpway34_cell46 ML34 gate_way34_cell46 GND ML34 p1 W=2.4e-6 L=1e-6
mnway34_cell47 ML34 gate_way34_cell47 GND GND n1 W=1e-6 L=1e-6
mpway34_cell47 ML34 gate_way34_cell47 GND ML34 p1 W=2.4e-6 L=1e-6
mnway34_cell48 ML34 gate_way34_cell48 GND GND n1 W=1e-6 L=1e-6
mpway34_cell48 ML34 gate_way34_cell48 GND ML34 p1 W=2.4e-6 L=1e-6
mnway34_cell49 ML34 gate_way34_cell49 GND GND n1 W=1e-6 L=1e-6
mpway34_cell49 ML34 gate_way34_cell49 GND ML34 p1 W=2.4e-6 L=1e-6
mnway34_cell50 ML34 gate_way34_cell50 GND GND n1 W=1e-6 L=1e-6
mpway34_cell50 ML34 gate_way34_cell50 GND ML34 p1 W=2.4e-6 L=1e-6
mnway34_cell51 ML34 gate_way34_cell51 GND GND n1 W=1e-6 L=1e-6
mpway34_cell51 ML34 gate_way34_cell51 GND ML34 p1 W=2.4e-6 L=1e-6
mnway34_cell52 ML34 gate_way34_cell52 GND GND n1 W=1e-6 L=1e-6
mpway34_cell52 ML34 gate_way34_cell52 GND ML34 p1 W=2.4e-6 L=1e-6
mnway34_cell53 ML34 gate_way34_cell53 GND GND n1 W=1e-6 L=1e-6
mpway34_cell53 ML34 gate_way34_cell53 GND ML34 p1 W=2.4e-6 L=1e-6
mnway34_cell54 ML34 gate_way34_cell54 GND GND n1 W=1e-6 L=1e-6
mpway34_cell54 ML34 gate_way34_cell54 GND ML34 p1 W=2.4e-6 L=1e-6
mnway34_cell55 ML34 gate_way34_cell55 GND GND n1 W=1e-6 L=1e-6
mpway34_cell55 ML34 gate_way34_cell55 GND ML34 p1 W=2.4e-6 L=1e-6
mnway34_cell56 ML34 gate_way34_cell56 GND GND n1 W=1e-6 L=1e-6
mpway34_cell56 ML34 gate_way34_cell56 GND ML34 p1 W=2.4e-6 L=1e-6
mnway34_cell57 ML34 gate_way34_cell57 GND GND n1 W=1e-6 L=1e-6
mpway34_cell57 ML34 gate_way34_cell57 GND ML34 p1 W=2.4e-6 L=1e-6
mnway34_cell58 ML34 gate_way34_cell58 GND GND n1 W=1e-6 L=1e-6
mpway34_cell58 ML34 gate_way34_cell58 GND ML34 p1 W=2.4e-6 L=1e-6
mnway34_cell59 ML34 gate_way34_cell59 GND GND n1 W=1e-6 L=1e-6
mpway34_cell59 ML34 gate_way34_cell59 GND ML34 p1 W=2.4e-6 L=1e-6
mnway34_cell60 ML34 gate_way34_cell60 GND GND n1 W=1e-6 L=1e-6
mpway34_cell60 ML34 gate_way34_cell60 GND ML34 p1 W=2.4e-6 L=1e-6
mnway34_cell61 ML34 gate_way34_cell61 GND GND n1 W=1e-6 L=1e-6
mpway34_cell61 ML34 gate_way34_cell61 GND ML34 p1 W=2.4e-6 L=1e-6
mnway34_cell62 ML34 gate_way34_cell62 GND GND n1 W=1e-6 L=1e-6
mpway34_cell62 ML34 gate_way34_cell62 GND ML34 p1 W=2.4e-6 L=1e-6
mnway34_cell63 ML34 gate_way34_cell63 GND GND n1 W=1e-6 L=1e-6
mpway34_cell63 ML34 gate_way34_cell63 GND ML34 p1 W=2.4e-6 L=1e-6
mnway34_cell64 ML34 gate_way34_cell64 GND GND n1 W=1e-6 L=1e-6
mpway34_cell64 ML34 gate_way34_cell64 GND ML34 p1 W=2.4e-6 L=1e-6
mnway34_cell65 ML34 gate_way34_cell65 GND GND n1 W=1e-6 L=1e-6
mpway34_cell65 ML34 gate_way34_cell65 GND ML34 p1 W=2.4e-6 L=1e-6
mnway34_cell66 ML34 gate_way34_cell66 GND GND n1 W=1e-6 L=1e-6
mpway34_cell66 ML34 gate_way34_cell66 GND ML34 p1 W=2.4e-6 L=1e-6
mnway34_cell67 ML34 gate_way34_cell67 GND GND n1 W=1e-6 L=1e-6
mpway34_cell67 ML34 gate_way34_cell67 GND ML34 p1 W=2.4e-6 L=1e-6
mnway34_cell68 ML34 gate_way34_cell68 GND GND n1 W=1e-6 L=1e-6
mpway34_cell68 ML34 gate_way34_cell68 GND ML34 p1 W=2.4e-6 L=1e-6
mnway34_cell69 ML34 gate_way34_cell69 GND GND n1 W=1e-6 L=1e-6
mpway34_cell69 ML34 gate_way34_cell69 GND ML34 p1 W=2.4e-6 L=1e-6
mnway34_cell70 ML34 gate_way34_cell70 GND GND n1 W=1e-6 L=1e-6
mpway34_cell70 ML34 gate_way34_cell70 GND ML34 p1 W=2.4e-6 L=1e-6
mnway34_cell71 ML34 gate_way34_cell71 GND GND n1 W=1e-6 L=1e-6
mpway34_cell71 ML34 gate_way34_cell71 GND ML34 p1 W=2.4e-6 L=1e-6
mnway34_cell72 ML34 gate_way34_cell72 GND GND n1 W=1e-6 L=1e-6
mpway34_cell72 ML34 gate_way34_cell72 GND ML34 p1 W=2.4e-6 L=1e-6
mnway34_cell73 ML34 gate_way34_cell73 GND GND n1 W=1e-6 L=1e-6
mpway34_cell73 ML34 gate_way34_cell73 GND ML34 p1 W=2.4e-6 L=1e-6
mnway34_cell74 ML34 gate_way34_cell74 GND GND n1 W=1e-6 L=1e-6
mpway34_cell74 ML34 gate_way34_cell74 GND ML34 p1 W=2.4e-6 L=1e-6
mnway34_cell75 ML34 gate_way34_cell75 GND GND n1 W=1e-6 L=1e-6
mpway34_cell75 ML34 gate_way34_cell75 GND ML34 p1 W=2.4e-6 L=1e-6
mnway34_cell76 ML34 gate_way34_cell76 GND GND n1 W=1e-6 L=1e-6
mpway34_cell76 ML34 gate_way34_cell76 GND ML34 p1 W=2.4e-6 L=1e-6
mnway34_cell77 ML34 gate_way34_cell77 GND GND n1 W=1e-6 L=1e-6
mpway34_cell77 ML34 gate_way34_cell77 GND ML34 p1 W=2.4e-6 L=1e-6
mnway34_cell78 ML34 gate_way34_cell78 GND GND n1 W=1e-6 L=1e-6
mpway34_cell78 ML34 gate_way34_cell78 GND ML34 p1 W=2.4e-6 L=1e-6
mnway34_cell79 ML34 gate_way34_cell79 GND GND n1 W=1e-6 L=1e-6
mpway34_cell79 ML34 gate_way34_cell79 GND ML34 p1 W=2.4e-6 L=1e-6
mnway34_cell80 ML34 gate_way34_cell80 GND GND n1 W=1e-6 L=1e-6
mpway34_cell80 ML34 gate_way34_cell80 GND ML34 p1 W=2.4e-6 L=1e-6
mnway34_cell81 ML34 gate_way34_cell81 GND GND n1 W=1e-6 L=1e-6
mpway34_cell81 ML34 gate_way34_cell81 GND ML34 p1 W=2.4e-6 L=1e-6
mnway34_cell82 ML34 gate_way34_cell82 GND GND n1 W=1e-6 L=1e-6
mpway34_cell82 ML34 gate_way34_cell82 GND ML34 p1 W=2.4e-6 L=1e-6
mnway34_cell83 ML34 gate_way34_cell83 GND GND n1 W=1e-6 L=1e-6
mpway34_cell83 ML34 gate_way34_cell83 GND ML34 p1 W=2.4e-6 L=1e-6
mnway34_cell84 ML34 gate_way34_cell84 GND GND n1 W=1e-6 L=1e-6
mpway34_cell84 ML34 gate_way34_cell84 GND ML34 p1 W=2.4e-6 L=1e-6
mnway34_cell85 ML34 gate_way34_cell85 GND GND n1 W=1e-6 L=1e-6
mpway34_cell85 ML34 gate_way34_cell85 GND ML34 p1 W=2.4e-6 L=1e-6
mnway34_cell86 ML34 gate_way34_cell86 GND GND n1 W=1e-6 L=1e-6
mpway34_cell86 ML34 gate_way34_cell86 GND ML34 p1 W=2.4e-6 L=1e-6
mnway34_cell87 ML34 gate_way34_cell87 GND GND n1 W=1e-6 L=1e-6
mpway34_cell87 ML34 gate_way34_cell87 GND ML34 p1 W=2.4e-6 L=1e-6
mnway34_cell88 ML34 gate_way34_cell88 GND GND n1 W=1e-6 L=1e-6
mpway34_cell88 ML34 gate_way34_cell88 GND ML34 p1 W=2.4e-6 L=1e-6
mnway34_cell89 ML34 gate_way34_cell89 GND GND n1 W=1e-6 L=1e-6
mpway34_cell89 ML34 gate_way34_cell89 GND ML34 p1 W=2.4e-6 L=1e-6
mnway34_cell90 ML34 gate_way34_cell90 GND GND n1 W=1e-6 L=1e-6
mpway34_cell90 ML34 gate_way34_cell90 GND ML34 p1 W=2.4e-6 L=1e-6
mnway34_cell91 ML34 gate_way34_cell91 GND GND n1 W=1e-6 L=1e-6
mpway34_cell91 ML34 gate_way34_cell91 GND ML34 p1 W=2.4e-6 L=1e-6
mnway34_cell92 ML34 gate_way34_cell92 GND GND n1 W=1e-6 L=1e-6
mpway34_cell92 ML34 gate_way34_cell92 GND ML34 p1 W=2.4e-6 L=1e-6
mnway34_cell93 ML34 gate_way34_cell93 GND GND n1 W=1e-6 L=1e-6
mpway34_cell93 ML34 gate_way34_cell93 GND ML34 p1 W=2.4e-6 L=1e-6
mnway34_cell94 ML34 gate_way34_cell94 GND GND n1 W=1e-6 L=1e-6
mpway34_cell94 ML34 gate_way34_cell94 GND ML34 p1 W=2.4e-6 L=1e-6
mnway34_cell95 ML34 gate_way34_cell95 GND GND n1 W=1e-6 L=1e-6
mpway34_cell95 ML34 gate_way34_cell95 GND ML34 p1 W=2.4e-6 L=1e-6
mnway34_cell96 ML34 gate_way34_cell96 GND GND n1 W=1e-6 L=1e-6
mpway34_cell96 ML34 gate_way34_cell96 GND ML34 p1 W=2.4e-6 L=1e-6
mnway34_cell97 ML34 gate_way34_cell97 GND GND n1 W=1e-6 L=1e-6
mpway34_cell97 ML34 gate_way34_cell97 GND ML34 p1 W=2.4e-6 L=1e-6
mnway34_cell98 ML34 gate_way34_cell98 GND GND n1 W=1e-6 L=1e-6
mpway34_cell98 ML34 gate_way34_cell98 GND ML34 p1 W=2.4e-6 L=1e-6
mnway34_cell99 ML34 gate_way34_cell99 GND GND n1 W=1e-6 L=1e-6
mpway34_cell99 ML34 gate_way34_cell99 GND ML34 p1 W=2.4e-6 L=1e-6
mnway35_cell0 ML35 gate_way35_cell0 GND GND n1 W=1e-6 L=1e-6
mpway35_cell0 ML35 gate_way35_cell0 GND ML35 p1 W=2.4e-6 L=1e-6
mnway35_cell1 ML35 gate_way35_cell1 GND GND n1 W=1e-6 L=1e-6
mpway35_cell1 ML35 gate_way35_cell1 GND ML35 p1 W=2.4e-6 L=1e-6
mnway35_cell2 ML35 gate_way35_cell2 GND GND n1 W=1e-6 L=1e-6
mpway35_cell2 ML35 gate_way35_cell2 GND ML35 p1 W=2.4e-6 L=1e-6
mnway35_cell3 ML35 gate_way35_cell3 GND GND n1 W=1e-6 L=1e-6
mpway35_cell3 ML35 gate_way35_cell3 GND ML35 p1 W=2.4e-6 L=1e-6
mnway35_cell4 ML35 gate_way35_cell4 GND GND n1 W=1e-6 L=1e-6
mpway35_cell4 ML35 gate_way35_cell4 GND ML35 p1 W=2.4e-6 L=1e-6
mnway35_cell5 ML35 gate_way35_cell5 GND GND n1 W=1e-6 L=1e-6
mpway35_cell5 ML35 gate_way35_cell5 GND ML35 p1 W=2.4e-6 L=1e-6
mnway35_cell6 ML35 gate_way35_cell6 GND GND n1 W=1e-6 L=1e-6
mpway35_cell6 ML35 gate_way35_cell6 GND ML35 p1 W=2.4e-6 L=1e-6
mnway35_cell7 ML35 gate_way35_cell7 GND GND n1 W=1e-6 L=1e-6
mpway35_cell7 ML35 gate_way35_cell7 GND ML35 p1 W=2.4e-6 L=1e-6
mnway35_cell8 ML35 gate_way35_cell8 GND GND n1 W=1e-6 L=1e-6
mpway35_cell8 ML35 gate_way35_cell8 GND ML35 p1 W=2.4e-6 L=1e-6
mnway35_cell9 ML35 gate_way35_cell9 GND GND n1 W=1e-6 L=1e-6
mpway35_cell9 ML35 gate_way35_cell9 GND ML35 p1 W=2.4e-6 L=1e-6
mnway35_cell10 ML35 gate_way35_cell10 GND GND n1 W=1e-6 L=1e-6
mpway35_cell10 ML35 gate_way35_cell10 GND ML35 p1 W=2.4e-6 L=1e-6
mnway35_cell11 ML35 gate_way35_cell11 GND GND n1 W=1e-6 L=1e-6
mpway35_cell11 ML35 gate_way35_cell11 GND ML35 p1 W=2.4e-6 L=1e-6
mnway35_cell12 ML35 gate_way35_cell12 GND GND n1 W=1e-6 L=1e-6
mpway35_cell12 ML35 gate_way35_cell12 GND ML35 p1 W=2.4e-6 L=1e-6
mnway35_cell13 ML35 gate_way35_cell13 GND GND n1 W=1e-6 L=1e-6
mpway35_cell13 ML35 gate_way35_cell13 GND ML35 p1 W=2.4e-6 L=1e-6
mnway35_cell14 ML35 gate_way35_cell14 GND GND n1 W=1e-6 L=1e-6
mpway35_cell14 ML35 gate_way35_cell14 GND ML35 p1 W=2.4e-6 L=1e-6
mnway35_cell15 ML35 gate_way35_cell15 GND GND n1 W=1e-6 L=1e-6
mpway35_cell15 ML35 gate_way35_cell15 GND ML35 p1 W=2.4e-6 L=1e-6
mnway35_cell16 ML35 gate_way35_cell16 GND GND n1 W=1e-6 L=1e-6
mpway35_cell16 ML35 gate_way35_cell16 GND ML35 p1 W=2.4e-6 L=1e-6
mnway35_cell17 ML35 gate_way35_cell17 GND GND n1 W=1e-6 L=1e-6
mpway35_cell17 ML35 gate_way35_cell17 GND ML35 p1 W=2.4e-6 L=1e-6
mnway35_cell18 ML35 gate_way35_cell18 GND GND n1 W=1e-6 L=1e-6
mpway35_cell18 ML35 gate_way35_cell18 GND ML35 p1 W=2.4e-6 L=1e-6
mnway35_cell19 ML35 gate_way35_cell19 GND GND n1 W=1e-6 L=1e-6
mpway35_cell19 ML35 gate_way35_cell19 GND ML35 p1 W=2.4e-6 L=1e-6
mnway35_cell20 ML35 gate_way35_cell20 GND GND n1 W=1e-6 L=1e-6
mpway35_cell20 ML35 gate_way35_cell20 GND ML35 p1 W=2.4e-6 L=1e-6
mnway35_cell21 ML35 gate_way35_cell21 GND GND n1 W=1e-6 L=1e-6
mpway35_cell21 ML35 gate_way35_cell21 GND ML35 p1 W=2.4e-6 L=1e-6
mnway35_cell22 ML35 gate_way35_cell22 GND GND n1 W=1e-6 L=1e-6
mpway35_cell22 ML35 gate_way35_cell22 GND ML35 p1 W=2.4e-6 L=1e-6
mnway35_cell23 ML35 gate_way35_cell23 GND GND n1 W=1e-6 L=1e-6
mpway35_cell23 ML35 gate_way35_cell23 GND ML35 p1 W=2.4e-6 L=1e-6
mnway35_cell24 ML35 gate_way35_cell24 GND GND n1 W=1e-6 L=1e-6
mpway35_cell24 ML35 gate_way35_cell24 GND ML35 p1 W=2.4e-6 L=1e-6
mnway35_cell25 ML35 gate_way35_cell25 GND GND n1 W=1e-6 L=1e-6
mpway35_cell25 ML35 gate_way35_cell25 GND ML35 p1 W=2.4e-6 L=1e-6
mnway35_cell26 ML35 gate_way35_cell26 GND GND n1 W=1e-6 L=1e-6
mpway35_cell26 ML35 gate_way35_cell26 GND ML35 p1 W=2.4e-6 L=1e-6
mnway35_cell27 ML35 gate_way35_cell27 GND GND n1 W=1e-6 L=1e-6
mpway35_cell27 ML35 gate_way35_cell27 GND ML35 p1 W=2.4e-6 L=1e-6
mnway35_cell28 ML35 gate_way35_cell28 GND GND n1 W=1e-6 L=1e-6
mpway35_cell28 ML35 gate_way35_cell28 GND ML35 p1 W=2.4e-6 L=1e-6
mnway35_cell29 ML35 gate_way35_cell29 GND GND n1 W=1e-6 L=1e-6
mpway35_cell29 ML35 gate_way35_cell29 GND ML35 p1 W=2.4e-6 L=1e-6
mnway35_cell30 ML35 gate_way35_cell30 GND GND n1 W=1e-6 L=1e-6
mpway35_cell30 ML35 gate_way35_cell30 GND ML35 p1 W=2.4e-6 L=1e-6
mnway35_cell31 ML35 gate_way35_cell31 GND GND n1 W=1e-6 L=1e-6
mpway35_cell31 ML35 gate_way35_cell31 GND ML35 p1 W=2.4e-6 L=1e-6
mnway35_cell32 ML35 gate_way35_cell32 GND GND n1 W=1e-6 L=1e-6
mpway35_cell32 ML35 gate_way35_cell32 GND ML35 p1 W=2.4e-6 L=1e-6
mnway35_cell33 ML35 gate_way35_cell33 GND GND n1 W=1e-6 L=1e-6
mpway35_cell33 ML35 gate_way35_cell33 GND ML35 p1 W=2.4e-6 L=1e-6
mnway35_cell34 ML35 gate_way35_cell34 GND GND n1 W=1e-6 L=1e-6
mpway35_cell34 ML35 gate_way35_cell34 GND ML35 p1 W=2.4e-6 L=1e-6
mnway35_cell35 ML35 gate_way35_cell35 GND GND n1 W=1e-6 L=1e-6
mpway35_cell35 ML35 gate_way35_cell35 GND ML35 p1 W=2.4e-6 L=1e-6
mnway35_cell36 ML35 gate_way35_cell36 GND GND n1 W=1e-6 L=1e-6
mpway35_cell36 ML35 gate_way35_cell36 GND ML35 p1 W=2.4e-6 L=1e-6
mnway35_cell37 ML35 gate_way35_cell37 GND GND n1 W=1e-6 L=1e-6
mpway35_cell37 ML35 gate_way35_cell37 GND ML35 p1 W=2.4e-6 L=1e-6
mnway35_cell38 ML35 gate_way35_cell38 GND GND n1 W=1e-6 L=1e-6
mpway35_cell38 ML35 gate_way35_cell38 GND ML35 p1 W=2.4e-6 L=1e-6
mnway35_cell39 ML35 gate_way35_cell39 GND GND n1 W=1e-6 L=1e-6
mpway35_cell39 ML35 gate_way35_cell39 GND ML35 p1 W=2.4e-6 L=1e-6
mnway35_cell40 ML35 gate_way35_cell40 GND GND n1 W=1e-6 L=1e-6
mpway35_cell40 ML35 gate_way35_cell40 GND ML35 p1 W=2.4e-6 L=1e-6
mnway35_cell41 ML35 gate_way35_cell41 GND GND n1 W=1e-6 L=1e-6
mpway35_cell41 ML35 gate_way35_cell41 GND ML35 p1 W=2.4e-6 L=1e-6
mnway35_cell42 ML35 gate_way35_cell42 GND GND n1 W=1e-6 L=1e-6
mpway35_cell42 ML35 gate_way35_cell42 GND ML35 p1 W=2.4e-6 L=1e-6
mnway35_cell43 ML35 gate_way35_cell43 GND GND n1 W=1e-6 L=1e-6
mpway35_cell43 ML35 gate_way35_cell43 GND ML35 p1 W=2.4e-6 L=1e-6
mnway35_cell44 ML35 gate_way35_cell44 GND GND n1 W=1e-6 L=1e-6
mpway35_cell44 ML35 gate_way35_cell44 GND ML35 p1 W=2.4e-6 L=1e-6
mnway35_cell45 ML35 gate_way35_cell45 GND GND n1 W=1e-6 L=1e-6
mpway35_cell45 ML35 gate_way35_cell45 GND ML35 p1 W=2.4e-6 L=1e-6
mnway35_cell46 ML35 gate_way35_cell46 GND GND n1 W=1e-6 L=1e-6
mpway35_cell46 ML35 gate_way35_cell46 GND ML35 p1 W=2.4e-6 L=1e-6
mnway35_cell47 ML35 gate_way35_cell47 GND GND n1 W=1e-6 L=1e-6
mpway35_cell47 ML35 gate_way35_cell47 GND ML35 p1 W=2.4e-6 L=1e-6
mnway35_cell48 ML35 gate_way35_cell48 GND GND n1 W=1e-6 L=1e-6
mpway35_cell48 ML35 gate_way35_cell48 GND ML35 p1 W=2.4e-6 L=1e-6
mnway35_cell49 ML35 gate_way35_cell49 GND GND n1 W=1e-6 L=1e-6
mpway35_cell49 ML35 gate_way35_cell49 GND ML35 p1 W=2.4e-6 L=1e-6
mnway35_cell50 ML35 gate_way35_cell50 GND GND n1 W=1e-6 L=1e-6
mpway35_cell50 ML35 gate_way35_cell50 GND ML35 p1 W=2.4e-6 L=1e-6
mnway35_cell51 ML35 gate_way35_cell51 GND GND n1 W=1e-6 L=1e-6
mpway35_cell51 ML35 gate_way35_cell51 GND ML35 p1 W=2.4e-6 L=1e-6
mnway35_cell52 ML35 gate_way35_cell52 GND GND n1 W=1e-6 L=1e-6
mpway35_cell52 ML35 gate_way35_cell52 GND ML35 p1 W=2.4e-6 L=1e-6
mnway35_cell53 ML35 gate_way35_cell53 GND GND n1 W=1e-6 L=1e-6
mpway35_cell53 ML35 gate_way35_cell53 GND ML35 p1 W=2.4e-6 L=1e-6
mnway35_cell54 ML35 gate_way35_cell54 GND GND n1 W=1e-6 L=1e-6
mpway35_cell54 ML35 gate_way35_cell54 GND ML35 p1 W=2.4e-6 L=1e-6
mnway35_cell55 ML35 gate_way35_cell55 GND GND n1 W=1e-6 L=1e-6
mpway35_cell55 ML35 gate_way35_cell55 GND ML35 p1 W=2.4e-6 L=1e-6
mnway35_cell56 ML35 gate_way35_cell56 GND GND n1 W=1e-6 L=1e-6
mpway35_cell56 ML35 gate_way35_cell56 GND ML35 p1 W=2.4e-6 L=1e-6
mnway35_cell57 ML35 gate_way35_cell57 GND GND n1 W=1e-6 L=1e-6
mpway35_cell57 ML35 gate_way35_cell57 GND ML35 p1 W=2.4e-6 L=1e-6
mnway35_cell58 ML35 gate_way35_cell58 GND GND n1 W=1e-6 L=1e-6
mpway35_cell58 ML35 gate_way35_cell58 GND ML35 p1 W=2.4e-6 L=1e-6
mnway35_cell59 ML35 gate_way35_cell59 GND GND n1 W=1e-6 L=1e-6
mpway35_cell59 ML35 gate_way35_cell59 GND ML35 p1 W=2.4e-6 L=1e-6
mnway35_cell60 ML35 gate_way35_cell60 GND GND n1 W=1e-6 L=1e-6
mpway35_cell60 ML35 gate_way35_cell60 GND ML35 p1 W=2.4e-6 L=1e-6
mnway35_cell61 ML35 gate_way35_cell61 GND GND n1 W=1e-6 L=1e-6
mpway35_cell61 ML35 gate_way35_cell61 GND ML35 p1 W=2.4e-6 L=1e-6
mnway35_cell62 ML35 gate_way35_cell62 GND GND n1 W=1e-6 L=1e-6
mpway35_cell62 ML35 gate_way35_cell62 GND ML35 p1 W=2.4e-6 L=1e-6
mnway35_cell63 ML35 gate_way35_cell63 GND GND n1 W=1e-6 L=1e-6
mpway35_cell63 ML35 gate_way35_cell63 GND ML35 p1 W=2.4e-6 L=1e-6
mnway35_cell64 ML35 gate_way35_cell64 GND GND n1 W=1e-6 L=1e-6
mpway35_cell64 ML35 gate_way35_cell64 GND ML35 p1 W=2.4e-6 L=1e-6
mnway35_cell65 ML35 gate_way35_cell65 GND GND n1 W=1e-6 L=1e-6
mpway35_cell65 ML35 gate_way35_cell65 GND ML35 p1 W=2.4e-6 L=1e-6
mnway35_cell66 ML35 gate_way35_cell66 GND GND n1 W=1e-6 L=1e-6
mpway35_cell66 ML35 gate_way35_cell66 GND ML35 p1 W=2.4e-6 L=1e-6
mnway35_cell67 ML35 gate_way35_cell67 GND GND n1 W=1e-6 L=1e-6
mpway35_cell67 ML35 gate_way35_cell67 GND ML35 p1 W=2.4e-6 L=1e-6
mnway35_cell68 ML35 gate_way35_cell68 GND GND n1 W=1e-6 L=1e-6
mpway35_cell68 ML35 gate_way35_cell68 GND ML35 p1 W=2.4e-6 L=1e-6
mnway35_cell69 ML35 gate_way35_cell69 GND GND n1 W=1e-6 L=1e-6
mpway35_cell69 ML35 gate_way35_cell69 GND ML35 p1 W=2.4e-6 L=1e-6
mnway35_cell70 ML35 gate_way35_cell70 GND GND n1 W=1e-6 L=1e-6
mpway35_cell70 ML35 gate_way35_cell70 GND ML35 p1 W=2.4e-6 L=1e-6
mnway35_cell71 ML35 gate_way35_cell71 GND GND n1 W=1e-6 L=1e-6
mpway35_cell71 ML35 gate_way35_cell71 GND ML35 p1 W=2.4e-6 L=1e-6
mnway35_cell72 ML35 gate_way35_cell72 GND GND n1 W=1e-6 L=1e-6
mpway35_cell72 ML35 gate_way35_cell72 GND ML35 p1 W=2.4e-6 L=1e-6
mnway35_cell73 ML35 gate_way35_cell73 GND GND n1 W=1e-6 L=1e-6
mpway35_cell73 ML35 gate_way35_cell73 GND ML35 p1 W=2.4e-6 L=1e-6
mnway35_cell74 ML35 gate_way35_cell74 GND GND n1 W=1e-6 L=1e-6
mpway35_cell74 ML35 gate_way35_cell74 GND ML35 p1 W=2.4e-6 L=1e-6
mnway35_cell75 ML35 gate_way35_cell75 GND GND n1 W=1e-6 L=1e-6
mpway35_cell75 ML35 gate_way35_cell75 GND ML35 p1 W=2.4e-6 L=1e-6
mnway35_cell76 ML35 gate_way35_cell76 GND GND n1 W=1e-6 L=1e-6
mpway35_cell76 ML35 gate_way35_cell76 GND ML35 p1 W=2.4e-6 L=1e-6
mnway35_cell77 ML35 gate_way35_cell77 GND GND n1 W=1e-6 L=1e-6
mpway35_cell77 ML35 gate_way35_cell77 GND ML35 p1 W=2.4e-6 L=1e-6
mnway35_cell78 ML35 gate_way35_cell78 GND GND n1 W=1e-6 L=1e-6
mpway35_cell78 ML35 gate_way35_cell78 GND ML35 p1 W=2.4e-6 L=1e-6
mnway35_cell79 ML35 gate_way35_cell79 GND GND n1 W=1e-6 L=1e-6
mpway35_cell79 ML35 gate_way35_cell79 GND ML35 p1 W=2.4e-6 L=1e-6
mnway35_cell80 ML35 gate_way35_cell80 GND GND n1 W=1e-6 L=1e-6
mpway35_cell80 ML35 gate_way35_cell80 GND ML35 p1 W=2.4e-6 L=1e-6
mnway35_cell81 ML35 gate_way35_cell81 GND GND n1 W=1e-6 L=1e-6
mpway35_cell81 ML35 gate_way35_cell81 GND ML35 p1 W=2.4e-6 L=1e-6
mnway35_cell82 ML35 gate_way35_cell82 GND GND n1 W=1e-6 L=1e-6
mpway35_cell82 ML35 gate_way35_cell82 GND ML35 p1 W=2.4e-6 L=1e-6
mnway35_cell83 ML35 gate_way35_cell83 GND GND n1 W=1e-6 L=1e-6
mpway35_cell83 ML35 gate_way35_cell83 GND ML35 p1 W=2.4e-6 L=1e-6
mnway35_cell84 ML35 gate_way35_cell84 GND GND n1 W=1e-6 L=1e-6
mpway35_cell84 ML35 gate_way35_cell84 GND ML35 p1 W=2.4e-6 L=1e-6
mnway35_cell85 ML35 gate_way35_cell85 GND GND n1 W=1e-6 L=1e-6
mpway35_cell85 ML35 gate_way35_cell85 GND ML35 p1 W=2.4e-6 L=1e-6
mnway35_cell86 ML35 gate_way35_cell86 GND GND n1 W=1e-6 L=1e-6
mpway35_cell86 ML35 gate_way35_cell86 GND ML35 p1 W=2.4e-6 L=1e-6
mnway35_cell87 ML35 gate_way35_cell87 GND GND n1 W=1e-6 L=1e-6
mpway35_cell87 ML35 gate_way35_cell87 GND ML35 p1 W=2.4e-6 L=1e-6
mnway35_cell88 ML35 gate_way35_cell88 GND GND n1 W=1e-6 L=1e-6
mpway35_cell88 ML35 gate_way35_cell88 GND ML35 p1 W=2.4e-6 L=1e-6
mnway35_cell89 ML35 gate_way35_cell89 GND GND n1 W=1e-6 L=1e-6
mpway35_cell89 ML35 gate_way35_cell89 GND ML35 p1 W=2.4e-6 L=1e-6
mnway35_cell90 ML35 gate_way35_cell90 GND GND n1 W=1e-6 L=1e-6
mpway35_cell90 ML35 gate_way35_cell90 GND ML35 p1 W=2.4e-6 L=1e-6
mnway35_cell91 ML35 gate_way35_cell91 GND GND n1 W=1e-6 L=1e-6
mpway35_cell91 ML35 gate_way35_cell91 GND ML35 p1 W=2.4e-6 L=1e-6
mnway35_cell92 ML35 gate_way35_cell92 GND GND n1 W=1e-6 L=1e-6
mpway35_cell92 ML35 gate_way35_cell92 GND ML35 p1 W=2.4e-6 L=1e-6
mnway35_cell93 ML35 gate_way35_cell93 GND GND n1 W=1e-6 L=1e-6
mpway35_cell93 ML35 gate_way35_cell93 GND ML35 p1 W=2.4e-6 L=1e-6
mnway35_cell94 ML35 gate_way35_cell94 GND GND n1 W=1e-6 L=1e-6
mpway35_cell94 ML35 gate_way35_cell94 GND ML35 p1 W=2.4e-6 L=1e-6
mnway35_cell95 ML35 gate_way35_cell95 GND GND n1 W=1e-6 L=1e-6
mpway35_cell95 ML35 gate_way35_cell95 GND ML35 p1 W=2.4e-6 L=1e-6
mnway35_cell96 ML35 gate_way35_cell96 GND GND n1 W=1e-6 L=1e-6
mpway35_cell96 ML35 gate_way35_cell96 GND ML35 p1 W=2.4e-6 L=1e-6
mnway35_cell97 ML35 gate_way35_cell97 GND GND n1 W=1e-6 L=1e-6
mpway35_cell97 ML35 gate_way35_cell97 GND ML35 p1 W=2.4e-6 L=1e-6
mnway35_cell98 ML35 gate_way35_cell98 GND GND n1 W=1e-6 L=1e-6
mpway35_cell98 ML35 gate_way35_cell98 GND ML35 p1 W=2.4e-6 L=1e-6
mnway35_cell99 ML35 gate_way35_cell99 GND GND n1 W=1e-6 L=1e-6
mpway35_cell99 ML35 gate_way35_cell99 GND ML35 p1 W=2.4e-6 L=1e-6
mnway36_cell0 ML36 gate_way36_cell0 GND GND n1 W=1e-6 L=1e-6
mpway36_cell0 ML36 gate_way36_cell0 GND ML36 p1 W=2.4e-6 L=1e-6
mnway36_cell1 ML36 gate_way36_cell1 GND GND n1 W=1e-6 L=1e-6
mpway36_cell1 ML36 gate_way36_cell1 GND ML36 p1 W=2.4e-6 L=1e-6
mnway36_cell2 ML36 gate_way36_cell2 GND GND n1 W=1e-6 L=1e-6
mpway36_cell2 ML36 gate_way36_cell2 GND ML36 p1 W=2.4e-6 L=1e-6
mnway36_cell3 ML36 gate_way36_cell3 GND GND n1 W=1e-6 L=1e-6
mpway36_cell3 ML36 gate_way36_cell3 GND ML36 p1 W=2.4e-6 L=1e-6
mnway36_cell4 ML36 gate_way36_cell4 GND GND n1 W=1e-6 L=1e-6
mpway36_cell4 ML36 gate_way36_cell4 GND ML36 p1 W=2.4e-6 L=1e-6
mnway36_cell5 ML36 gate_way36_cell5 GND GND n1 W=1e-6 L=1e-6
mpway36_cell5 ML36 gate_way36_cell5 GND ML36 p1 W=2.4e-6 L=1e-6
mnway36_cell6 ML36 gate_way36_cell6 GND GND n1 W=1e-6 L=1e-6
mpway36_cell6 ML36 gate_way36_cell6 GND ML36 p1 W=2.4e-6 L=1e-6
mnway36_cell7 ML36 gate_way36_cell7 GND GND n1 W=1e-6 L=1e-6
mpway36_cell7 ML36 gate_way36_cell7 GND ML36 p1 W=2.4e-6 L=1e-6
mnway36_cell8 ML36 gate_way36_cell8 GND GND n1 W=1e-6 L=1e-6
mpway36_cell8 ML36 gate_way36_cell8 GND ML36 p1 W=2.4e-6 L=1e-6
mnway36_cell9 ML36 gate_way36_cell9 GND GND n1 W=1e-6 L=1e-6
mpway36_cell9 ML36 gate_way36_cell9 GND ML36 p1 W=2.4e-6 L=1e-6
mnway36_cell10 ML36 gate_way36_cell10 GND GND n1 W=1e-6 L=1e-6
mpway36_cell10 ML36 gate_way36_cell10 GND ML36 p1 W=2.4e-6 L=1e-6
mnway36_cell11 ML36 gate_way36_cell11 GND GND n1 W=1e-6 L=1e-6
mpway36_cell11 ML36 gate_way36_cell11 GND ML36 p1 W=2.4e-6 L=1e-6
mnway36_cell12 ML36 gate_way36_cell12 GND GND n1 W=1e-6 L=1e-6
mpway36_cell12 ML36 gate_way36_cell12 GND ML36 p1 W=2.4e-6 L=1e-6
mnway36_cell13 ML36 gate_way36_cell13 GND GND n1 W=1e-6 L=1e-6
mpway36_cell13 ML36 gate_way36_cell13 GND ML36 p1 W=2.4e-6 L=1e-6
mnway36_cell14 ML36 gate_way36_cell14 GND GND n1 W=1e-6 L=1e-6
mpway36_cell14 ML36 gate_way36_cell14 GND ML36 p1 W=2.4e-6 L=1e-6
mnway36_cell15 ML36 gate_way36_cell15 GND GND n1 W=1e-6 L=1e-6
mpway36_cell15 ML36 gate_way36_cell15 GND ML36 p1 W=2.4e-6 L=1e-6
mnway36_cell16 ML36 gate_way36_cell16 GND GND n1 W=1e-6 L=1e-6
mpway36_cell16 ML36 gate_way36_cell16 GND ML36 p1 W=2.4e-6 L=1e-6
mnway36_cell17 ML36 gate_way36_cell17 GND GND n1 W=1e-6 L=1e-6
mpway36_cell17 ML36 gate_way36_cell17 GND ML36 p1 W=2.4e-6 L=1e-6
mnway36_cell18 ML36 gate_way36_cell18 GND GND n1 W=1e-6 L=1e-6
mpway36_cell18 ML36 gate_way36_cell18 GND ML36 p1 W=2.4e-6 L=1e-6
mnway36_cell19 ML36 gate_way36_cell19 GND GND n1 W=1e-6 L=1e-6
mpway36_cell19 ML36 gate_way36_cell19 GND ML36 p1 W=2.4e-6 L=1e-6
mnway36_cell20 ML36 gate_way36_cell20 GND GND n1 W=1e-6 L=1e-6
mpway36_cell20 ML36 gate_way36_cell20 GND ML36 p1 W=2.4e-6 L=1e-6
mnway36_cell21 ML36 gate_way36_cell21 GND GND n1 W=1e-6 L=1e-6
mpway36_cell21 ML36 gate_way36_cell21 GND ML36 p1 W=2.4e-6 L=1e-6
mnway36_cell22 ML36 gate_way36_cell22 GND GND n1 W=1e-6 L=1e-6
mpway36_cell22 ML36 gate_way36_cell22 GND ML36 p1 W=2.4e-6 L=1e-6
mnway36_cell23 ML36 gate_way36_cell23 GND GND n1 W=1e-6 L=1e-6
mpway36_cell23 ML36 gate_way36_cell23 GND ML36 p1 W=2.4e-6 L=1e-6
mnway36_cell24 ML36 gate_way36_cell24 GND GND n1 W=1e-6 L=1e-6
mpway36_cell24 ML36 gate_way36_cell24 GND ML36 p1 W=2.4e-6 L=1e-6
mnway36_cell25 ML36 gate_way36_cell25 GND GND n1 W=1e-6 L=1e-6
mpway36_cell25 ML36 gate_way36_cell25 GND ML36 p1 W=2.4e-6 L=1e-6
mnway36_cell26 ML36 gate_way36_cell26 GND GND n1 W=1e-6 L=1e-6
mpway36_cell26 ML36 gate_way36_cell26 GND ML36 p1 W=2.4e-6 L=1e-6
mnway36_cell27 ML36 gate_way36_cell27 GND GND n1 W=1e-6 L=1e-6
mpway36_cell27 ML36 gate_way36_cell27 GND ML36 p1 W=2.4e-6 L=1e-6
mnway36_cell28 ML36 gate_way36_cell28 GND GND n1 W=1e-6 L=1e-6
mpway36_cell28 ML36 gate_way36_cell28 GND ML36 p1 W=2.4e-6 L=1e-6
mnway36_cell29 ML36 gate_way36_cell29 GND GND n1 W=1e-6 L=1e-6
mpway36_cell29 ML36 gate_way36_cell29 GND ML36 p1 W=2.4e-6 L=1e-6
mnway36_cell30 ML36 gate_way36_cell30 GND GND n1 W=1e-6 L=1e-6
mpway36_cell30 ML36 gate_way36_cell30 GND ML36 p1 W=2.4e-6 L=1e-6
mnway36_cell31 ML36 gate_way36_cell31 GND GND n1 W=1e-6 L=1e-6
mpway36_cell31 ML36 gate_way36_cell31 GND ML36 p1 W=2.4e-6 L=1e-6
mnway36_cell32 ML36 gate_way36_cell32 GND GND n1 W=1e-6 L=1e-6
mpway36_cell32 ML36 gate_way36_cell32 GND ML36 p1 W=2.4e-6 L=1e-6
mnway36_cell33 ML36 gate_way36_cell33 GND GND n1 W=1e-6 L=1e-6
mpway36_cell33 ML36 gate_way36_cell33 GND ML36 p1 W=2.4e-6 L=1e-6
mnway36_cell34 ML36 gate_way36_cell34 GND GND n1 W=1e-6 L=1e-6
mpway36_cell34 ML36 gate_way36_cell34 GND ML36 p1 W=2.4e-6 L=1e-6
mnway36_cell35 ML36 gate_way36_cell35 GND GND n1 W=1e-6 L=1e-6
mpway36_cell35 ML36 gate_way36_cell35 GND ML36 p1 W=2.4e-6 L=1e-6
mnway36_cell36 ML36 gate_way36_cell36 GND GND n1 W=1e-6 L=1e-6
mpway36_cell36 ML36 gate_way36_cell36 GND ML36 p1 W=2.4e-6 L=1e-6
mnway36_cell37 ML36 gate_way36_cell37 GND GND n1 W=1e-6 L=1e-6
mpway36_cell37 ML36 gate_way36_cell37 GND ML36 p1 W=2.4e-6 L=1e-6
mnway36_cell38 ML36 gate_way36_cell38 GND GND n1 W=1e-6 L=1e-6
mpway36_cell38 ML36 gate_way36_cell38 GND ML36 p1 W=2.4e-6 L=1e-6
mnway36_cell39 ML36 gate_way36_cell39 GND GND n1 W=1e-6 L=1e-6
mpway36_cell39 ML36 gate_way36_cell39 GND ML36 p1 W=2.4e-6 L=1e-6
mnway36_cell40 ML36 gate_way36_cell40 GND GND n1 W=1e-6 L=1e-6
mpway36_cell40 ML36 gate_way36_cell40 GND ML36 p1 W=2.4e-6 L=1e-6
mnway36_cell41 ML36 gate_way36_cell41 GND GND n1 W=1e-6 L=1e-6
mpway36_cell41 ML36 gate_way36_cell41 GND ML36 p1 W=2.4e-6 L=1e-6
mnway36_cell42 ML36 gate_way36_cell42 GND GND n1 W=1e-6 L=1e-6
mpway36_cell42 ML36 gate_way36_cell42 GND ML36 p1 W=2.4e-6 L=1e-6
mnway36_cell43 ML36 gate_way36_cell43 GND GND n1 W=1e-6 L=1e-6
mpway36_cell43 ML36 gate_way36_cell43 GND ML36 p1 W=2.4e-6 L=1e-6
mnway36_cell44 ML36 gate_way36_cell44 GND GND n1 W=1e-6 L=1e-6
mpway36_cell44 ML36 gate_way36_cell44 GND ML36 p1 W=2.4e-6 L=1e-6
mnway36_cell45 ML36 gate_way36_cell45 GND GND n1 W=1e-6 L=1e-6
mpway36_cell45 ML36 gate_way36_cell45 GND ML36 p1 W=2.4e-6 L=1e-6
mnway36_cell46 ML36 gate_way36_cell46 GND GND n1 W=1e-6 L=1e-6
mpway36_cell46 ML36 gate_way36_cell46 GND ML36 p1 W=2.4e-6 L=1e-6
mnway36_cell47 ML36 gate_way36_cell47 GND GND n1 W=1e-6 L=1e-6
mpway36_cell47 ML36 gate_way36_cell47 GND ML36 p1 W=2.4e-6 L=1e-6
mnway36_cell48 ML36 gate_way36_cell48 GND GND n1 W=1e-6 L=1e-6
mpway36_cell48 ML36 gate_way36_cell48 GND ML36 p1 W=2.4e-6 L=1e-6
mnway36_cell49 ML36 gate_way36_cell49 GND GND n1 W=1e-6 L=1e-6
mpway36_cell49 ML36 gate_way36_cell49 GND ML36 p1 W=2.4e-6 L=1e-6
mnway36_cell50 ML36 gate_way36_cell50 GND GND n1 W=1e-6 L=1e-6
mpway36_cell50 ML36 gate_way36_cell50 GND ML36 p1 W=2.4e-6 L=1e-6
mnway36_cell51 ML36 gate_way36_cell51 GND GND n1 W=1e-6 L=1e-6
mpway36_cell51 ML36 gate_way36_cell51 GND ML36 p1 W=2.4e-6 L=1e-6
mnway36_cell52 ML36 gate_way36_cell52 GND GND n1 W=1e-6 L=1e-6
mpway36_cell52 ML36 gate_way36_cell52 GND ML36 p1 W=2.4e-6 L=1e-6
mnway36_cell53 ML36 gate_way36_cell53 GND GND n1 W=1e-6 L=1e-6
mpway36_cell53 ML36 gate_way36_cell53 GND ML36 p1 W=2.4e-6 L=1e-6
mnway36_cell54 ML36 gate_way36_cell54 GND GND n1 W=1e-6 L=1e-6
mpway36_cell54 ML36 gate_way36_cell54 GND ML36 p1 W=2.4e-6 L=1e-6
mnway36_cell55 ML36 gate_way36_cell55 GND GND n1 W=1e-6 L=1e-6
mpway36_cell55 ML36 gate_way36_cell55 GND ML36 p1 W=2.4e-6 L=1e-6
mnway36_cell56 ML36 gate_way36_cell56 GND GND n1 W=1e-6 L=1e-6
mpway36_cell56 ML36 gate_way36_cell56 GND ML36 p1 W=2.4e-6 L=1e-6
mnway36_cell57 ML36 gate_way36_cell57 GND GND n1 W=1e-6 L=1e-6
mpway36_cell57 ML36 gate_way36_cell57 GND ML36 p1 W=2.4e-6 L=1e-6
mnway36_cell58 ML36 gate_way36_cell58 GND GND n1 W=1e-6 L=1e-6
mpway36_cell58 ML36 gate_way36_cell58 GND ML36 p1 W=2.4e-6 L=1e-6
mnway36_cell59 ML36 gate_way36_cell59 GND GND n1 W=1e-6 L=1e-6
mpway36_cell59 ML36 gate_way36_cell59 GND ML36 p1 W=2.4e-6 L=1e-6
mnway36_cell60 ML36 gate_way36_cell60 GND GND n1 W=1e-6 L=1e-6
mpway36_cell60 ML36 gate_way36_cell60 GND ML36 p1 W=2.4e-6 L=1e-6
mnway36_cell61 ML36 gate_way36_cell61 GND GND n1 W=1e-6 L=1e-6
mpway36_cell61 ML36 gate_way36_cell61 GND ML36 p1 W=2.4e-6 L=1e-6
mnway36_cell62 ML36 gate_way36_cell62 GND GND n1 W=1e-6 L=1e-6
mpway36_cell62 ML36 gate_way36_cell62 GND ML36 p1 W=2.4e-6 L=1e-6
mnway36_cell63 ML36 gate_way36_cell63 GND GND n1 W=1e-6 L=1e-6
mpway36_cell63 ML36 gate_way36_cell63 GND ML36 p1 W=2.4e-6 L=1e-6
mnway36_cell64 ML36 gate_way36_cell64 GND GND n1 W=1e-6 L=1e-6
mpway36_cell64 ML36 gate_way36_cell64 GND ML36 p1 W=2.4e-6 L=1e-6
mnway36_cell65 ML36 gate_way36_cell65 GND GND n1 W=1e-6 L=1e-6
mpway36_cell65 ML36 gate_way36_cell65 GND ML36 p1 W=2.4e-6 L=1e-6
mnway36_cell66 ML36 gate_way36_cell66 GND GND n1 W=1e-6 L=1e-6
mpway36_cell66 ML36 gate_way36_cell66 GND ML36 p1 W=2.4e-6 L=1e-6
mnway36_cell67 ML36 gate_way36_cell67 GND GND n1 W=1e-6 L=1e-6
mpway36_cell67 ML36 gate_way36_cell67 GND ML36 p1 W=2.4e-6 L=1e-6
mnway36_cell68 ML36 gate_way36_cell68 GND GND n1 W=1e-6 L=1e-6
mpway36_cell68 ML36 gate_way36_cell68 GND ML36 p1 W=2.4e-6 L=1e-6
mnway36_cell69 ML36 gate_way36_cell69 GND GND n1 W=1e-6 L=1e-6
mpway36_cell69 ML36 gate_way36_cell69 GND ML36 p1 W=2.4e-6 L=1e-6
mnway36_cell70 ML36 gate_way36_cell70 GND GND n1 W=1e-6 L=1e-6
mpway36_cell70 ML36 gate_way36_cell70 GND ML36 p1 W=2.4e-6 L=1e-6
mnway36_cell71 ML36 gate_way36_cell71 GND GND n1 W=1e-6 L=1e-6
mpway36_cell71 ML36 gate_way36_cell71 GND ML36 p1 W=2.4e-6 L=1e-6
mnway36_cell72 ML36 gate_way36_cell72 GND GND n1 W=1e-6 L=1e-6
mpway36_cell72 ML36 gate_way36_cell72 GND ML36 p1 W=2.4e-6 L=1e-6
mnway36_cell73 ML36 gate_way36_cell73 GND GND n1 W=1e-6 L=1e-6
mpway36_cell73 ML36 gate_way36_cell73 GND ML36 p1 W=2.4e-6 L=1e-6
mnway36_cell74 ML36 gate_way36_cell74 GND GND n1 W=1e-6 L=1e-6
mpway36_cell74 ML36 gate_way36_cell74 GND ML36 p1 W=2.4e-6 L=1e-6
mnway36_cell75 ML36 gate_way36_cell75 GND GND n1 W=1e-6 L=1e-6
mpway36_cell75 ML36 gate_way36_cell75 GND ML36 p1 W=2.4e-6 L=1e-6
mnway36_cell76 ML36 gate_way36_cell76 GND GND n1 W=1e-6 L=1e-6
mpway36_cell76 ML36 gate_way36_cell76 GND ML36 p1 W=2.4e-6 L=1e-6
mnway36_cell77 ML36 gate_way36_cell77 GND GND n1 W=1e-6 L=1e-6
mpway36_cell77 ML36 gate_way36_cell77 GND ML36 p1 W=2.4e-6 L=1e-6
mnway36_cell78 ML36 gate_way36_cell78 GND GND n1 W=1e-6 L=1e-6
mpway36_cell78 ML36 gate_way36_cell78 GND ML36 p1 W=2.4e-6 L=1e-6
mnway36_cell79 ML36 gate_way36_cell79 GND GND n1 W=1e-6 L=1e-6
mpway36_cell79 ML36 gate_way36_cell79 GND ML36 p1 W=2.4e-6 L=1e-6
mnway36_cell80 ML36 gate_way36_cell80 GND GND n1 W=1e-6 L=1e-6
mpway36_cell80 ML36 gate_way36_cell80 GND ML36 p1 W=2.4e-6 L=1e-6
mnway36_cell81 ML36 gate_way36_cell81 GND GND n1 W=1e-6 L=1e-6
mpway36_cell81 ML36 gate_way36_cell81 GND ML36 p1 W=2.4e-6 L=1e-6
mnway36_cell82 ML36 gate_way36_cell82 GND GND n1 W=1e-6 L=1e-6
mpway36_cell82 ML36 gate_way36_cell82 GND ML36 p1 W=2.4e-6 L=1e-6
mnway36_cell83 ML36 gate_way36_cell83 GND GND n1 W=1e-6 L=1e-6
mpway36_cell83 ML36 gate_way36_cell83 GND ML36 p1 W=2.4e-6 L=1e-6
mnway36_cell84 ML36 gate_way36_cell84 GND GND n1 W=1e-6 L=1e-6
mpway36_cell84 ML36 gate_way36_cell84 GND ML36 p1 W=2.4e-6 L=1e-6
mnway36_cell85 ML36 gate_way36_cell85 GND GND n1 W=1e-6 L=1e-6
mpway36_cell85 ML36 gate_way36_cell85 GND ML36 p1 W=2.4e-6 L=1e-6
mnway36_cell86 ML36 gate_way36_cell86 GND GND n1 W=1e-6 L=1e-6
mpway36_cell86 ML36 gate_way36_cell86 GND ML36 p1 W=2.4e-6 L=1e-6
mnway36_cell87 ML36 gate_way36_cell87 GND GND n1 W=1e-6 L=1e-6
mpway36_cell87 ML36 gate_way36_cell87 GND ML36 p1 W=2.4e-6 L=1e-6
mnway36_cell88 ML36 gate_way36_cell88 GND GND n1 W=1e-6 L=1e-6
mpway36_cell88 ML36 gate_way36_cell88 GND ML36 p1 W=2.4e-6 L=1e-6
mnway36_cell89 ML36 gate_way36_cell89 GND GND n1 W=1e-6 L=1e-6
mpway36_cell89 ML36 gate_way36_cell89 GND ML36 p1 W=2.4e-6 L=1e-6
mnway36_cell90 ML36 gate_way36_cell90 GND GND n1 W=1e-6 L=1e-6
mpway36_cell90 ML36 gate_way36_cell90 GND ML36 p1 W=2.4e-6 L=1e-6
mnway36_cell91 ML36 gate_way36_cell91 GND GND n1 W=1e-6 L=1e-6
mpway36_cell91 ML36 gate_way36_cell91 GND ML36 p1 W=2.4e-6 L=1e-6
mnway36_cell92 ML36 gate_way36_cell92 GND GND n1 W=1e-6 L=1e-6
mpway36_cell92 ML36 gate_way36_cell92 GND ML36 p1 W=2.4e-6 L=1e-6
mnway36_cell93 ML36 gate_way36_cell93 GND GND n1 W=1e-6 L=1e-6
mpway36_cell93 ML36 gate_way36_cell93 GND ML36 p1 W=2.4e-6 L=1e-6
mnway36_cell94 ML36 gate_way36_cell94 GND GND n1 W=1e-6 L=1e-6
mpway36_cell94 ML36 gate_way36_cell94 GND ML36 p1 W=2.4e-6 L=1e-6
mnway36_cell95 ML36 gate_way36_cell95 GND GND n1 W=1e-6 L=1e-6
mpway36_cell95 ML36 gate_way36_cell95 GND ML36 p1 W=2.4e-6 L=1e-6
mnway36_cell96 ML36 gate_way36_cell96 GND GND n1 W=1e-6 L=1e-6
mpway36_cell96 ML36 gate_way36_cell96 GND ML36 p1 W=2.4e-6 L=1e-6
mnway36_cell97 ML36 gate_way36_cell97 GND GND n1 W=1e-6 L=1e-6
mpway36_cell97 ML36 gate_way36_cell97 GND ML36 p1 W=2.4e-6 L=1e-6
mnway36_cell98 ML36 gate_way36_cell98 GND GND n1 W=1e-6 L=1e-6
mpway36_cell98 ML36 gate_way36_cell98 GND ML36 p1 W=2.4e-6 L=1e-6
mnway36_cell99 ML36 gate_way36_cell99 GND GND n1 W=1e-6 L=1e-6
mpway36_cell99 ML36 gate_way36_cell99 GND ML36 p1 W=2.4e-6 L=1e-6
mnway37_cell0 ML37 gate_way37_cell0 GND GND n1 W=1e-6 L=1e-6
mpway37_cell0 ML37 gate_way37_cell0 GND ML37 p1 W=2.4e-6 L=1e-6
mnway37_cell1 ML37 gate_way37_cell1 GND GND n1 W=1e-6 L=1e-6
mpway37_cell1 ML37 gate_way37_cell1 GND ML37 p1 W=2.4e-6 L=1e-6
mnway37_cell2 ML37 gate_way37_cell2 GND GND n1 W=1e-6 L=1e-6
mpway37_cell2 ML37 gate_way37_cell2 GND ML37 p1 W=2.4e-6 L=1e-6
mnway37_cell3 ML37 gate_way37_cell3 GND GND n1 W=1e-6 L=1e-6
mpway37_cell3 ML37 gate_way37_cell3 GND ML37 p1 W=2.4e-6 L=1e-6
mnway37_cell4 ML37 gate_way37_cell4 GND GND n1 W=1e-6 L=1e-6
mpway37_cell4 ML37 gate_way37_cell4 GND ML37 p1 W=2.4e-6 L=1e-6
mnway37_cell5 ML37 gate_way37_cell5 GND GND n1 W=1e-6 L=1e-6
mpway37_cell5 ML37 gate_way37_cell5 GND ML37 p1 W=2.4e-6 L=1e-6
mnway37_cell6 ML37 gate_way37_cell6 GND GND n1 W=1e-6 L=1e-6
mpway37_cell6 ML37 gate_way37_cell6 GND ML37 p1 W=2.4e-6 L=1e-6
mnway37_cell7 ML37 gate_way37_cell7 GND GND n1 W=1e-6 L=1e-6
mpway37_cell7 ML37 gate_way37_cell7 GND ML37 p1 W=2.4e-6 L=1e-6
mnway37_cell8 ML37 gate_way37_cell8 GND GND n1 W=1e-6 L=1e-6
mpway37_cell8 ML37 gate_way37_cell8 GND ML37 p1 W=2.4e-6 L=1e-6
mnway37_cell9 ML37 gate_way37_cell9 GND GND n1 W=1e-6 L=1e-6
mpway37_cell9 ML37 gate_way37_cell9 GND ML37 p1 W=2.4e-6 L=1e-6
mnway37_cell10 ML37 gate_way37_cell10 GND GND n1 W=1e-6 L=1e-6
mpway37_cell10 ML37 gate_way37_cell10 GND ML37 p1 W=2.4e-6 L=1e-6
mnway37_cell11 ML37 gate_way37_cell11 GND GND n1 W=1e-6 L=1e-6
mpway37_cell11 ML37 gate_way37_cell11 GND ML37 p1 W=2.4e-6 L=1e-6
mnway37_cell12 ML37 gate_way37_cell12 GND GND n1 W=1e-6 L=1e-6
mpway37_cell12 ML37 gate_way37_cell12 GND ML37 p1 W=2.4e-6 L=1e-6
mnway37_cell13 ML37 gate_way37_cell13 GND GND n1 W=1e-6 L=1e-6
mpway37_cell13 ML37 gate_way37_cell13 GND ML37 p1 W=2.4e-6 L=1e-6
mnway37_cell14 ML37 gate_way37_cell14 GND GND n1 W=1e-6 L=1e-6
mpway37_cell14 ML37 gate_way37_cell14 GND ML37 p1 W=2.4e-6 L=1e-6
mnway37_cell15 ML37 gate_way37_cell15 GND GND n1 W=1e-6 L=1e-6
mpway37_cell15 ML37 gate_way37_cell15 GND ML37 p1 W=2.4e-6 L=1e-6
mnway37_cell16 ML37 gate_way37_cell16 GND GND n1 W=1e-6 L=1e-6
mpway37_cell16 ML37 gate_way37_cell16 GND ML37 p1 W=2.4e-6 L=1e-6
mnway37_cell17 ML37 gate_way37_cell17 GND GND n1 W=1e-6 L=1e-6
mpway37_cell17 ML37 gate_way37_cell17 GND ML37 p1 W=2.4e-6 L=1e-6
mnway37_cell18 ML37 gate_way37_cell18 GND GND n1 W=1e-6 L=1e-6
mpway37_cell18 ML37 gate_way37_cell18 GND ML37 p1 W=2.4e-6 L=1e-6
mnway37_cell19 ML37 gate_way37_cell19 GND GND n1 W=1e-6 L=1e-6
mpway37_cell19 ML37 gate_way37_cell19 GND ML37 p1 W=2.4e-6 L=1e-6
mnway37_cell20 ML37 gate_way37_cell20 GND GND n1 W=1e-6 L=1e-6
mpway37_cell20 ML37 gate_way37_cell20 GND ML37 p1 W=2.4e-6 L=1e-6
mnway37_cell21 ML37 gate_way37_cell21 GND GND n1 W=1e-6 L=1e-6
mpway37_cell21 ML37 gate_way37_cell21 GND ML37 p1 W=2.4e-6 L=1e-6
mnway37_cell22 ML37 gate_way37_cell22 GND GND n1 W=1e-6 L=1e-6
mpway37_cell22 ML37 gate_way37_cell22 GND ML37 p1 W=2.4e-6 L=1e-6
mnway37_cell23 ML37 gate_way37_cell23 GND GND n1 W=1e-6 L=1e-6
mpway37_cell23 ML37 gate_way37_cell23 GND ML37 p1 W=2.4e-6 L=1e-6
mnway37_cell24 ML37 gate_way37_cell24 GND GND n1 W=1e-6 L=1e-6
mpway37_cell24 ML37 gate_way37_cell24 GND ML37 p1 W=2.4e-6 L=1e-6
mnway37_cell25 ML37 gate_way37_cell25 GND GND n1 W=1e-6 L=1e-6
mpway37_cell25 ML37 gate_way37_cell25 GND ML37 p1 W=2.4e-6 L=1e-6
mnway37_cell26 ML37 gate_way37_cell26 GND GND n1 W=1e-6 L=1e-6
mpway37_cell26 ML37 gate_way37_cell26 GND ML37 p1 W=2.4e-6 L=1e-6
mnway37_cell27 ML37 gate_way37_cell27 GND GND n1 W=1e-6 L=1e-6
mpway37_cell27 ML37 gate_way37_cell27 GND ML37 p1 W=2.4e-6 L=1e-6
mnway37_cell28 ML37 gate_way37_cell28 GND GND n1 W=1e-6 L=1e-6
mpway37_cell28 ML37 gate_way37_cell28 GND ML37 p1 W=2.4e-6 L=1e-6
mnway37_cell29 ML37 gate_way37_cell29 GND GND n1 W=1e-6 L=1e-6
mpway37_cell29 ML37 gate_way37_cell29 GND ML37 p1 W=2.4e-6 L=1e-6
mnway37_cell30 ML37 gate_way37_cell30 GND GND n1 W=1e-6 L=1e-6
mpway37_cell30 ML37 gate_way37_cell30 GND ML37 p1 W=2.4e-6 L=1e-6
mnway37_cell31 ML37 gate_way37_cell31 GND GND n1 W=1e-6 L=1e-6
mpway37_cell31 ML37 gate_way37_cell31 GND ML37 p1 W=2.4e-6 L=1e-6
mnway37_cell32 ML37 gate_way37_cell32 GND GND n1 W=1e-6 L=1e-6
mpway37_cell32 ML37 gate_way37_cell32 GND ML37 p1 W=2.4e-6 L=1e-6
mnway37_cell33 ML37 gate_way37_cell33 GND GND n1 W=1e-6 L=1e-6
mpway37_cell33 ML37 gate_way37_cell33 GND ML37 p1 W=2.4e-6 L=1e-6
mnway37_cell34 ML37 gate_way37_cell34 GND GND n1 W=1e-6 L=1e-6
mpway37_cell34 ML37 gate_way37_cell34 GND ML37 p1 W=2.4e-6 L=1e-6
mnway37_cell35 ML37 gate_way37_cell35 GND GND n1 W=1e-6 L=1e-6
mpway37_cell35 ML37 gate_way37_cell35 GND ML37 p1 W=2.4e-6 L=1e-6
mnway37_cell36 ML37 gate_way37_cell36 GND GND n1 W=1e-6 L=1e-6
mpway37_cell36 ML37 gate_way37_cell36 GND ML37 p1 W=2.4e-6 L=1e-6
mnway37_cell37 ML37 gate_way37_cell37 GND GND n1 W=1e-6 L=1e-6
mpway37_cell37 ML37 gate_way37_cell37 GND ML37 p1 W=2.4e-6 L=1e-6
mnway37_cell38 ML37 gate_way37_cell38 GND GND n1 W=1e-6 L=1e-6
mpway37_cell38 ML37 gate_way37_cell38 GND ML37 p1 W=2.4e-6 L=1e-6
mnway37_cell39 ML37 gate_way37_cell39 GND GND n1 W=1e-6 L=1e-6
mpway37_cell39 ML37 gate_way37_cell39 GND ML37 p1 W=2.4e-6 L=1e-6
mnway37_cell40 ML37 gate_way37_cell40 GND GND n1 W=1e-6 L=1e-6
mpway37_cell40 ML37 gate_way37_cell40 GND ML37 p1 W=2.4e-6 L=1e-6
mnway37_cell41 ML37 gate_way37_cell41 GND GND n1 W=1e-6 L=1e-6
mpway37_cell41 ML37 gate_way37_cell41 GND ML37 p1 W=2.4e-6 L=1e-6
mnway37_cell42 ML37 gate_way37_cell42 GND GND n1 W=1e-6 L=1e-6
mpway37_cell42 ML37 gate_way37_cell42 GND ML37 p1 W=2.4e-6 L=1e-6
mnway37_cell43 ML37 gate_way37_cell43 GND GND n1 W=1e-6 L=1e-6
mpway37_cell43 ML37 gate_way37_cell43 GND ML37 p1 W=2.4e-6 L=1e-6
mnway37_cell44 ML37 gate_way37_cell44 GND GND n1 W=1e-6 L=1e-6
mpway37_cell44 ML37 gate_way37_cell44 GND ML37 p1 W=2.4e-6 L=1e-6
mnway37_cell45 ML37 gate_way37_cell45 GND GND n1 W=1e-6 L=1e-6
mpway37_cell45 ML37 gate_way37_cell45 GND ML37 p1 W=2.4e-6 L=1e-6
mnway37_cell46 ML37 gate_way37_cell46 GND GND n1 W=1e-6 L=1e-6
mpway37_cell46 ML37 gate_way37_cell46 GND ML37 p1 W=2.4e-6 L=1e-6
mnway37_cell47 ML37 gate_way37_cell47 GND GND n1 W=1e-6 L=1e-6
mpway37_cell47 ML37 gate_way37_cell47 GND ML37 p1 W=2.4e-6 L=1e-6
mnway37_cell48 ML37 gate_way37_cell48 GND GND n1 W=1e-6 L=1e-6
mpway37_cell48 ML37 gate_way37_cell48 GND ML37 p1 W=2.4e-6 L=1e-6
mnway37_cell49 ML37 gate_way37_cell49 GND GND n1 W=1e-6 L=1e-6
mpway37_cell49 ML37 gate_way37_cell49 GND ML37 p1 W=2.4e-6 L=1e-6
mnway37_cell50 ML37 gate_way37_cell50 GND GND n1 W=1e-6 L=1e-6
mpway37_cell50 ML37 gate_way37_cell50 GND ML37 p1 W=2.4e-6 L=1e-6
mnway37_cell51 ML37 gate_way37_cell51 GND GND n1 W=1e-6 L=1e-6
mpway37_cell51 ML37 gate_way37_cell51 GND ML37 p1 W=2.4e-6 L=1e-6
mnway37_cell52 ML37 gate_way37_cell52 GND GND n1 W=1e-6 L=1e-6
mpway37_cell52 ML37 gate_way37_cell52 GND ML37 p1 W=2.4e-6 L=1e-6
mnway37_cell53 ML37 gate_way37_cell53 GND GND n1 W=1e-6 L=1e-6
mpway37_cell53 ML37 gate_way37_cell53 GND ML37 p1 W=2.4e-6 L=1e-6
mnway37_cell54 ML37 gate_way37_cell54 GND GND n1 W=1e-6 L=1e-6
mpway37_cell54 ML37 gate_way37_cell54 GND ML37 p1 W=2.4e-6 L=1e-6
mnway37_cell55 ML37 gate_way37_cell55 GND GND n1 W=1e-6 L=1e-6
mpway37_cell55 ML37 gate_way37_cell55 GND ML37 p1 W=2.4e-6 L=1e-6
mnway37_cell56 ML37 gate_way37_cell56 GND GND n1 W=1e-6 L=1e-6
mpway37_cell56 ML37 gate_way37_cell56 GND ML37 p1 W=2.4e-6 L=1e-6
mnway37_cell57 ML37 gate_way37_cell57 GND GND n1 W=1e-6 L=1e-6
mpway37_cell57 ML37 gate_way37_cell57 GND ML37 p1 W=2.4e-6 L=1e-6
mnway37_cell58 ML37 gate_way37_cell58 GND GND n1 W=1e-6 L=1e-6
mpway37_cell58 ML37 gate_way37_cell58 GND ML37 p1 W=2.4e-6 L=1e-6
mnway37_cell59 ML37 gate_way37_cell59 GND GND n1 W=1e-6 L=1e-6
mpway37_cell59 ML37 gate_way37_cell59 GND ML37 p1 W=2.4e-6 L=1e-6
mnway37_cell60 ML37 gate_way37_cell60 GND GND n1 W=1e-6 L=1e-6
mpway37_cell60 ML37 gate_way37_cell60 GND ML37 p1 W=2.4e-6 L=1e-6
mnway37_cell61 ML37 gate_way37_cell61 GND GND n1 W=1e-6 L=1e-6
mpway37_cell61 ML37 gate_way37_cell61 GND ML37 p1 W=2.4e-6 L=1e-6
mnway37_cell62 ML37 gate_way37_cell62 GND GND n1 W=1e-6 L=1e-6
mpway37_cell62 ML37 gate_way37_cell62 GND ML37 p1 W=2.4e-6 L=1e-6
mnway37_cell63 ML37 gate_way37_cell63 GND GND n1 W=1e-6 L=1e-6
mpway37_cell63 ML37 gate_way37_cell63 GND ML37 p1 W=2.4e-6 L=1e-6
mnway37_cell64 ML37 gate_way37_cell64 GND GND n1 W=1e-6 L=1e-6
mpway37_cell64 ML37 gate_way37_cell64 GND ML37 p1 W=2.4e-6 L=1e-6
mnway37_cell65 ML37 gate_way37_cell65 GND GND n1 W=1e-6 L=1e-6
mpway37_cell65 ML37 gate_way37_cell65 GND ML37 p1 W=2.4e-6 L=1e-6
mnway37_cell66 ML37 gate_way37_cell66 GND GND n1 W=1e-6 L=1e-6
mpway37_cell66 ML37 gate_way37_cell66 GND ML37 p1 W=2.4e-6 L=1e-6
mnway37_cell67 ML37 gate_way37_cell67 GND GND n1 W=1e-6 L=1e-6
mpway37_cell67 ML37 gate_way37_cell67 GND ML37 p1 W=2.4e-6 L=1e-6
mnway37_cell68 ML37 gate_way37_cell68 GND GND n1 W=1e-6 L=1e-6
mpway37_cell68 ML37 gate_way37_cell68 GND ML37 p1 W=2.4e-6 L=1e-6
mnway37_cell69 ML37 gate_way37_cell69 GND GND n1 W=1e-6 L=1e-6
mpway37_cell69 ML37 gate_way37_cell69 GND ML37 p1 W=2.4e-6 L=1e-6
mnway37_cell70 ML37 gate_way37_cell70 GND GND n1 W=1e-6 L=1e-6
mpway37_cell70 ML37 gate_way37_cell70 GND ML37 p1 W=2.4e-6 L=1e-6
mnway37_cell71 ML37 gate_way37_cell71 GND GND n1 W=1e-6 L=1e-6
mpway37_cell71 ML37 gate_way37_cell71 GND ML37 p1 W=2.4e-6 L=1e-6
mnway37_cell72 ML37 gate_way37_cell72 GND GND n1 W=1e-6 L=1e-6
mpway37_cell72 ML37 gate_way37_cell72 GND ML37 p1 W=2.4e-6 L=1e-6
mnway37_cell73 ML37 gate_way37_cell73 GND GND n1 W=1e-6 L=1e-6
mpway37_cell73 ML37 gate_way37_cell73 GND ML37 p1 W=2.4e-6 L=1e-6
mnway37_cell74 ML37 gate_way37_cell74 GND GND n1 W=1e-6 L=1e-6
mpway37_cell74 ML37 gate_way37_cell74 GND ML37 p1 W=2.4e-6 L=1e-6
mnway37_cell75 ML37 gate_way37_cell75 GND GND n1 W=1e-6 L=1e-6
mpway37_cell75 ML37 gate_way37_cell75 GND ML37 p1 W=2.4e-6 L=1e-6
mnway37_cell76 ML37 gate_way37_cell76 GND GND n1 W=1e-6 L=1e-6
mpway37_cell76 ML37 gate_way37_cell76 GND ML37 p1 W=2.4e-6 L=1e-6
mnway37_cell77 ML37 gate_way37_cell77 GND GND n1 W=1e-6 L=1e-6
mpway37_cell77 ML37 gate_way37_cell77 GND ML37 p1 W=2.4e-6 L=1e-6
mnway37_cell78 ML37 gate_way37_cell78 GND GND n1 W=1e-6 L=1e-6
mpway37_cell78 ML37 gate_way37_cell78 GND ML37 p1 W=2.4e-6 L=1e-6
mnway37_cell79 ML37 gate_way37_cell79 GND GND n1 W=1e-6 L=1e-6
mpway37_cell79 ML37 gate_way37_cell79 GND ML37 p1 W=2.4e-6 L=1e-6
mnway37_cell80 ML37 gate_way37_cell80 GND GND n1 W=1e-6 L=1e-6
mpway37_cell80 ML37 gate_way37_cell80 GND ML37 p1 W=2.4e-6 L=1e-6
mnway37_cell81 ML37 gate_way37_cell81 GND GND n1 W=1e-6 L=1e-6
mpway37_cell81 ML37 gate_way37_cell81 GND ML37 p1 W=2.4e-6 L=1e-6
mnway37_cell82 ML37 gate_way37_cell82 GND GND n1 W=1e-6 L=1e-6
mpway37_cell82 ML37 gate_way37_cell82 GND ML37 p1 W=2.4e-6 L=1e-6
mnway37_cell83 ML37 gate_way37_cell83 GND GND n1 W=1e-6 L=1e-6
mpway37_cell83 ML37 gate_way37_cell83 GND ML37 p1 W=2.4e-6 L=1e-6
mnway37_cell84 ML37 gate_way37_cell84 GND GND n1 W=1e-6 L=1e-6
mpway37_cell84 ML37 gate_way37_cell84 GND ML37 p1 W=2.4e-6 L=1e-6
mnway37_cell85 ML37 gate_way37_cell85 GND GND n1 W=1e-6 L=1e-6
mpway37_cell85 ML37 gate_way37_cell85 GND ML37 p1 W=2.4e-6 L=1e-6
mnway37_cell86 ML37 gate_way37_cell86 GND GND n1 W=1e-6 L=1e-6
mpway37_cell86 ML37 gate_way37_cell86 GND ML37 p1 W=2.4e-6 L=1e-6
mnway37_cell87 ML37 gate_way37_cell87 GND GND n1 W=1e-6 L=1e-6
mpway37_cell87 ML37 gate_way37_cell87 GND ML37 p1 W=2.4e-6 L=1e-6
mnway37_cell88 ML37 gate_way37_cell88 GND GND n1 W=1e-6 L=1e-6
mpway37_cell88 ML37 gate_way37_cell88 GND ML37 p1 W=2.4e-6 L=1e-6
mnway37_cell89 ML37 gate_way37_cell89 GND GND n1 W=1e-6 L=1e-6
mpway37_cell89 ML37 gate_way37_cell89 GND ML37 p1 W=2.4e-6 L=1e-6
mnway37_cell90 ML37 gate_way37_cell90 GND GND n1 W=1e-6 L=1e-6
mpway37_cell90 ML37 gate_way37_cell90 GND ML37 p1 W=2.4e-6 L=1e-6
mnway37_cell91 ML37 gate_way37_cell91 GND GND n1 W=1e-6 L=1e-6
mpway37_cell91 ML37 gate_way37_cell91 GND ML37 p1 W=2.4e-6 L=1e-6
mnway37_cell92 ML37 gate_way37_cell92 GND GND n1 W=1e-6 L=1e-6
mpway37_cell92 ML37 gate_way37_cell92 GND ML37 p1 W=2.4e-6 L=1e-6
mnway37_cell93 ML37 gate_way37_cell93 GND GND n1 W=1e-6 L=1e-6
mpway37_cell93 ML37 gate_way37_cell93 GND ML37 p1 W=2.4e-6 L=1e-6
mnway37_cell94 ML37 gate_way37_cell94 GND GND n1 W=1e-6 L=1e-6
mpway37_cell94 ML37 gate_way37_cell94 GND ML37 p1 W=2.4e-6 L=1e-6
mnway37_cell95 ML37 gate_way37_cell95 GND GND n1 W=1e-6 L=1e-6
mpway37_cell95 ML37 gate_way37_cell95 GND ML37 p1 W=2.4e-6 L=1e-6
mnway37_cell96 ML37 gate_way37_cell96 GND GND n1 W=1e-6 L=1e-6
mpway37_cell96 ML37 gate_way37_cell96 GND ML37 p1 W=2.4e-6 L=1e-6
mnway37_cell97 ML37 gate_way37_cell97 GND GND n1 W=1e-6 L=1e-6
mpway37_cell97 ML37 gate_way37_cell97 GND ML37 p1 W=2.4e-6 L=1e-6
mnway37_cell98 ML37 gate_way37_cell98 GND GND n1 W=1e-6 L=1e-6
mpway37_cell98 ML37 gate_way37_cell98 GND ML37 p1 W=2.4e-6 L=1e-6
mnway37_cell99 ML37 gate_way37_cell99 GND GND n1 W=1e-6 L=1e-6
mpway37_cell99 ML37 gate_way37_cell99 GND ML37 p1 W=2.4e-6 L=1e-6
mnway38_cell0 ML38 gate_way38_cell0 GND GND n1 W=1e-6 L=1e-6
mpway38_cell0 ML38 gate_way38_cell0 GND ML38 p1 W=2.4e-6 L=1e-6
mnway38_cell1 ML38 gate_way38_cell1 GND GND n1 W=1e-6 L=1e-6
mpway38_cell1 ML38 gate_way38_cell1 GND ML38 p1 W=2.4e-6 L=1e-6
mnway38_cell2 ML38 gate_way38_cell2 GND GND n1 W=1e-6 L=1e-6
mpway38_cell2 ML38 gate_way38_cell2 GND ML38 p1 W=2.4e-6 L=1e-6
mnway38_cell3 ML38 gate_way38_cell3 GND GND n1 W=1e-6 L=1e-6
mpway38_cell3 ML38 gate_way38_cell3 GND ML38 p1 W=2.4e-6 L=1e-6
mnway38_cell4 ML38 gate_way38_cell4 GND GND n1 W=1e-6 L=1e-6
mpway38_cell4 ML38 gate_way38_cell4 GND ML38 p1 W=2.4e-6 L=1e-6
mnway38_cell5 ML38 gate_way38_cell5 GND GND n1 W=1e-6 L=1e-6
mpway38_cell5 ML38 gate_way38_cell5 GND ML38 p1 W=2.4e-6 L=1e-6
mnway38_cell6 ML38 gate_way38_cell6 GND GND n1 W=1e-6 L=1e-6
mpway38_cell6 ML38 gate_way38_cell6 GND ML38 p1 W=2.4e-6 L=1e-6
mnway38_cell7 ML38 gate_way38_cell7 GND GND n1 W=1e-6 L=1e-6
mpway38_cell7 ML38 gate_way38_cell7 GND ML38 p1 W=2.4e-6 L=1e-6
mnway38_cell8 ML38 gate_way38_cell8 GND GND n1 W=1e-6 L=1e-6
mpway38_cell8 ML38 gate_way38_cell8 GND ML38 p1 W=2.4e-6 L=1e-6
mnway38_cell9 ML38 gate_way38_cell9 GND GND n1 W=1e-6 L=1e-6
mpway38_cell9 ML38 gate_way38_cell9 GND ML38 p1 W=2.4e-6 L=1e-6
mnway38_cell10 ML38 gate_way38_cell10 GND GND n1 W=1e-6 L=1e-6
mpway38_cell10 ML38 gate_way38_cell10 GND ML38 p1 W=2.4e-6 L=1e-6
mnway38_cell11 ML38 gate_way38_cell11 GND GND n1 W=1e-6 L=1e-6
mpway38_cell11 ML38 gate_way38_cell11 GND ML38 p1 W=2.4e-6 L=1e-6
mnway38_cell12 ML38 gate_way38_cell12 GND GND n1 W=1e-6 L=1e-6
mpway38_cell12 ML38 gate_way38_cell12 GND ML38 p1 W=2.4e-6 L=1e-6
mnway38_cell13 ML38 gate_way38_cell13 GND GND n1 W=1e-6 L=1e-6
mpway38_cell13 ML38 gate_way38_cell13 GND ML38 p1 W=2.4e-6 L=1e-6
mnway38_cell14 ML38 gate_way38_cell14 GND GND n1 W=1e-6 L=1e-6
mpway38_cell14 ML38 gate_way38_cell14 GND ML38 p1 W=2.4e-6 L=1e-6
mnway38_cell15 ML38 gate_way38_cell15 GND GND n1 W=1e-6 L=1e-6
mpway38_cell15 ML38 gate_way38_cell15 GND ML38 p1 W=2.4e-6 L=1e-6
mnway38_cell16 ML38 gate_way38_cell16 GND GND n1 W=1e-6 L=1e-6
mpway38_cell16 ML38 gate_way38_cell16 GND ML38 p1 W=2.4e-6 L=1e-6
mnway38_cell17 ML38 gate_way38_cell17 GND GND n1 W=1e-6 L=1e-6
mpway38_cell17 ML38 gate_way38_cell17 GND ML38 p1 W=2.4e-6 L=1e-6
mnway38_cell18 ML38 gate_way38_cell18 GND GND n1 W=1e-6 L=1e-6
mpway38_cell18 ML38 gate_way38_cell18 GND ML38 p1 W=2.4e-6 L=1e-6
mnway38_cell19 ML38 gate_way38_cell19 GND GND n1 W=1e-6 L=1e-6
mpway38_cell19 ML38 gate_way38_cell19 GND ML38 p1 W=2.4e-6 L=1e-6
mnway38_cell20 ML38 gate_way38_cell20 GND GND n1 W=1e-6 L=1e-6
mpway38_cell20 ML38 gate_way38_cell20 GND ML38 p1 W=2.4e-6 L=1e-6
mnway38_cell21 ML38 gate_way38_cell21 GND GND n1 W=1e-6 L=1e-6
mpway38_cell21 ML38 gate_way38_cell21 GND ML38 p1 W=2.4e-6 L=1e-6
mnway38_cell22 ML38 gate_way38_cell22 GND GND n1 W=1e-6 L=1e-6
mpway38_cell22 ML38 gate_way38_cell22 GND ML38 p1 W=2.4e-6 L=1e-6
mnway38_cell23 ML38 gate_way38_cell23 GND GND n1 W=1e-6 L=1e-6
mpway38_cell23 ML38 gate_way38_cell23 GND ML38 p1 W=2.4e-6 L=1e-6
mnway38_cell24 ML38 gate_way38_cell24 GND GND n1 W=1e-6 L=1e-6
mpway38_cell24 ML38 gate_way38_cell24 GND ML38 p1 W=2.4e-6 L=1e-6
mnway38_cell25 ML38 gate_way38_cell25 GND GND n1 W=1e-6 L=1e-6
mpway38_cell25 ML38 gate_way38_cell25 GND ML38 p1 W=2.4e-6 L=1e-6
mnway38_cell26 ML38 gate_way38_cell26 GND GND n1 W=1e-6 L=1e-6
mpway38_cell26 ML38 gate_way38_cell26 GND ML38 p1 W=2.4e-6 L=1e-6
mnway38_cell27 ML38 gate_way38_cell27 GND GND n1 W=1e-6 L=1e-6
mpway38_cell27 ML38 gate_way38_cell27 GND ML38 p1 W=2.4e-6 L=1e-6
mnway38_cell28 ML38 gate_way38_cell28 GND GND n1 W=1e-6 L=1e-6
mpway38_cell28 ML38 gate_way38_cell28 GND ML38 p1 W=2.4e-6 L=1e-6
mnway38_cell29 ML38 gate_way38_cell29 GND GND n1 W=1e-6 L=1e-6
mpway38_cell29 ML38 gate_way38_cell29 GND ML38 p1 W=2.4e-6 L=1e-6
mnway38_cell30 ML38 gate_way38_cell30 GND GND n1 W=1e-6 L=1e-6
mpway38_cell30 ML38 gate_way38_cell30 GND ML38 p1 W=2.4e-6 L=1e-6
mnway38_cell31 ML38 gate_way38_cell31 GND GND n1 W=1e-6 L=1e-6
mpway38_cell31 ML38 gate_way38_cell31 GND ML38 p1 W=2.4e-6 L=1e-6
mnway38_cell32 ML38 gate_way38_cell32 GND GND n1 W=1e-6 L=1e-6
mpway38_cell32 ML38 gate_way38_cell32 GND ML38 p1 W=2.4e-6 L=1e-6
mnway38_cell33 ML38 gate_way38_cell33 GND GND n1 W=1e-6 L=1e-6
mpway38_cell33 ML38 gate_way38_cell33 GND ML38 p1 W=2.4e-6 L=1e-6
mnway38_cell34 ML38 gate_way38_cell34 GND GND n1 W=1e-6 L=1e-6
mpway38_cell34 ML38 gate_way38_cell34 GND ML38 p1 W=2.4e-6 L=1e-6
mnway38_cell35 ML38 gate_way38_cell35 GND GND n1 W=1e-6 L=1e-6
mpway38_cell35 ML38 gate_way38_cell35 GND ML38 p1 W=2.4e-6 L=1e-6
mnway38_cell36 ML38 gate_way38_cell36 GND GND n1 W=1e-6 L=1e-6
mpway38_cell36 ML38 gate_way38_cell36 GND ML38 p1 W=2.4e-6 L=1e-6
mnway38_cell37 ML38 gate_way38_cell37 GND GND n1 W=1e-6 L=1e-6
mpway38_cell37 ML38 gate_way38_cell37 GND ML38 p1 W=2.4e-6 L=1e-6
mnway38_cell38 ML38 gate_way38_cell38 GND GND n1 W=1e-6 L=1e-6
mpway38_cell38 ML38 gate_way38_cell38 GND ML38 p1 W=2.4e-6 L=1e-6
mnway38_cell39 ML38 gate_way38_cell39 GND GND n1 W=1e-6 L=1e-6
mpway38_cell39 ML38 gate_way38_cell39 GND ML38 p1 W=2.4e-6 L=1e-6
mnway38_cell40 ML38 gate_way38_cell40 GND GND n1 W=1e-6 L=1e-6
mpway38_cell40 ML38 gate_way38_cell40 GND ML38 p1 W=2.4e-6 L=1e-6
mnway38_cell41 ML38 gate_way38_cell41 GND GND n1 W=1e-6 L=1e-6
mpway38_cell41 ML38 gate_way38_cell41 GND ML38 p1 W=2.4e-6 L=1e-6
mnway38_cell42 ML38 gate_way38_cell42 GND GND n1 W=1e-6 L=1e-6
mpway38_cell42 ML38 gate_way38_cell42 GND ML38 p1 W=2.4e-6 L=1e-6
mnway38_cell43 ML38 gate_way38_cell43 GND GND n1 W=1e-6 L=1e-6
mpway38_cell43 ML38 gate_way38_cell43 GND ML38 p1 W=2.4e-6 L=1e-6
mnway38_cell44 ML38 gate_way38_cell44 GND GND n1 W=1e-6 L=1e-6
mpway38_cell44 ML38 gate_way38_cell44 GND ML38 p1 W=2.4e-6 L=1e-6
mnway38_cell45 ML38 gate_way38_cell45 GND GND n1 W=1e-6 L=1e-6
mpway38_cell45 ML38 gate_way38_cell45 GND ML38 p1 W=2.4e-6 L=1e-6
mnway38_cell46 ML38 gate_way38_cell46 GND GND n1 W=1e-6 L=1e-6
mpway38_cell46 ML38 gate_way38_cell46 GND ML38 p1 W=2.4e-6 L=1e-6
mnway38_cell47 ML38 gate_way38_cell47 GND GND n1 W=1e-6 L=1e-6
mpway38_cell47 ML38 gate_way38_cell47 GND ML38 p1 W=2.4e-6 L=1e-6
mnway38_cell48 ML38 gate_way38_cell48 GND GND n1 W=1e-6 L=1e-6
mpway38_cell48 ML38 gate_way38_cell48 GND ML38 p1 W=2.4e-6 L=1e-6
mnway38_cell49 ML38 gate_way38_cell49 GND GND n1 W=1e-6 L=1e-6
mpway38_cell49 ML38 gate_way38_cell49 GND ML38 p1 W=2.4e-6 L=1e-6
mnway38_cell50 ML38 gate_way38_cell50 GND GND n1 W=1e-6 L=1e-6
mpway38_cell50 ML38 gate_way38_cell50 GND ML38 p1 W=2.4e-6 L=1e-6
mnway38_cell51 ML38 gate_way38_cell51 GND GND n1 W=1e-6 L=1e-6
mpway38_cell51 ML38 gate_way38_cell51 GND ML38 p1 W=2.4e-6 L=1e-6
mnway38_cell52 ML38 gate_way38_cell52 GND GND n1 W=1e-6 L=1e-6
mpway38_cell52 ML38 gate_way38_cell52 GND ML38 p1 W=2.4e-6 L=1e-6
mnway38_cell53 ML38 gate_way38_cell53 GND GND n1 W=1e-6 L=1e-6
mpway38_cell53 ML38 gate_way38_cell53 GND ML38 p1 W=2.4e-6 L=1e-6
mnway38_cell54 ML38 gate_way38_cell54 GND GND n1 W=1e-6 L=1e-6
mpway38_cell54 ML38 gate_way38_cell54 GND ML38 p1 W=2.4e-6 L=1e-6
mnway38_cell55 ML38 gate_way38_cell55 GND GND n1 W=1e-6 L=1e-6
mpway38_cell55 ML38 gate_way38_cell55 GND ML38 p1 W=2.4e-6 L=1e-6
mnway38_cell56 ML38 gate_way38_cell56 GND GND n1 W=1e-6 L=1e-6
mpway38_cell56 ML38 gate_way38_cell56 GND ML38 p1 W=2.4e-6 L=1e-6
mnway38_cell57 ML38 gate_way38_cell57 GND GND n1 W=1e-6 L=1e-6
mpway38_cell57 ML38 gate_way38_cell57 GND ML38 p1 W=2.4e-6 L=1e-6
mnway38_cell58 ML38 gate_way38_cell58 GND GND n1 W=1e-6 L=1e-6
mpway38_cell58 ML38 gate_way38_cell58 GND ML38 p1 W=2.4e-6 L=1e-6
mnway38_cell59 ML38 gate_way38_cell59 GND GND n1 W=1e-6 L=1e-6
mpway38_cell59 ML38 gate_way38_cell59 GND ML38 p1 W=2.4e-6 L=1e-6
mnway38_cell60 ML38 gate_way38_cell60 GND GND n1 W=1e-6 L=1e-6
mpway38_cell60 ML38 gate_way38_cell60 GND ML38 p1 W=2.4e-6 L=1e-6
mnway38_cell61 ML38 gate_way38_cell61 GND GND n1 W=1e-6 L=1e-6
mpway38_cell61 ML38 gate_way38_cell61 GND ML38 p1 W=2.4e-6 L=1e-6
mnway38_cell62 ML38 gate_way38_cell62 GND GND n1 W=1e-6 L=1e-6
mpway38_cell62 ML38 gate_way38_cell62 GND ML38 p1 W=2.4e-6 L=1e-6
mnway38_cell63 ML38 gate_way38_cell63 GND GND n1 W=1e-6 L=1e-6
mpway38_cell63 ML38 gate_way38_cell63 GND ML38 p1 W=2.4e-6 L=1e-6
mnway38_cell64 ML38 gate_way38_cell64 GND GND n1 W=1e-6 L=1e-6
mpway38_cell64 ML38 gate_way38_cell64 GND ML38 p1 W=2.4e-6 L=1e-6
mnway38_cell65 ML38 gate_way38_cell65 GND GND n1 W=1e-6 L=1e-6
mpway38_cell65 ML38 gate_way38_cell65 GND ML38 p1 W=2.4e-6 L=1e-6
mnway38_cell66 ML38 gate_way38_cell66 GND GND n1 W=1e-6 L=1e-6
mpway38_cell66 ML38 gate_way38_cell66 GND ML38 p1 W=2.4e-6 L=1e-6
mnway38_cell67 ML38 gate_way38_cell67 GND GND n1 W=1e-6 L=1e-6
mpway38_cell67 ML38 gate_way38_cell67 GND ML38 p1 W=2.4e-6 L=1e-6
mnway38_cell68 ML38 gate_way38_cell68 GND GND n1 W=1e-6 L=1e-6
mpway38_cell68 ML38 gate_way38_cell68 GND ML38 p1 W=2.4e-6 L=1e-6
mnway38_cell69 ML38 gate_way38_cell69 GND GND n1 W=1e-6 L=1e-6
mpway38_cell69 ML38 gate_way38_cell69 GND ML38 p1 W=2.4e-6 L=1e-6
mnway38_cell70 ML38 gate_way38_cell70 GND GND n1 W=1e-6 L=1e-6
mpway38_cell70 ML38 gate_way38_cell70 GND ML38 p1 W=2.4e-6 L=1e-6
mnway38_cell71 ML38 gate_way38_cell71 GND GND n1 W=1e-6 L=1e-6
mpway38_cell71 ML38 gate_way38_cell71 GND ML38 p1 W=2.4e-6 L=1e-6
mnway38_cell72 ML38 gate_way38_cell72 GND GND n1 W=1e-6 L=1e-6
mpway38_cell72 ML38 gate_way38_cell72 GND ML38 p1 W=2.4e-6 L=1e-6
mnway38_cell73 ML38 gate_way38_cell73 GND GND n1 W=1e-6 L=1e-6
mpway38_cell73 ML38 gate_way38_cell73 GND ML38 p1 W=2.4e-6 L=1e-6
mnway38_cell74 ML38 gate_way38_cell74 GND GND n1 W=1e-6 L=1e-6
mpway38_cell74 ML38 gate_way38_cell74 GND ML38 p1 W=2.4e-6 L=1e-6
mnway38_cell75 ML38 gate_way38_cell75 GND GND n1 W=1e-6 L=1e-6
mpway38_cell75 ML38 gate_way38_cell75 GND ML38 p1 W=2.4e-6 L=1e-6
mnway38_cell76 ML38 gate_way38_cell76 GND GND n1 W=1e-6 L=1e-6
mpway38_cell76 ML38 gate_way38_cell76 GND ML38 p1 W=2.4e-6 L=1e-6
mnway38_cell77 ML38 gate_way38_cell77 GND GND n1 W=1e-6 L=1e-6
mpway38_cell77 ML38 gate_way38_cell77 GND ML38 p1 W=2.4e-6 L=1e-6
mnway38_cell78 ML38 gate_way38_cell78 GND GND n1 W=1e-6 L=1e-6
mpway38_cell78 ML38 gate_way38_cell78 GND ML38 p1 W=2.4e-6 L=1e-6
mnway38_cell79 ML38 gate_way38_cell79 GND GND n1 W=1e-6 L=1e-6
mpway38_cell79 ML38 gate_way38_cell79 GND ML38 p1 W=2.4e-6 L=1e-6
mnway38_cell80 ML38 gate_way38_cell80 GND GND n1 W=1e-6 L=1e-6
mpway38_cell80 ML38 gate_way38_cell80 GND ML38 p1 W=2.4e-6 L=1e-6
mnway38_cell81 ML38 gate_way38_cell81 GND GND n1 W=1e-6 L=1e-6
mpway38_cell81 ML38 gate_way38_cell81 GND ML38 p1 W=2.4e-6 L=1e-6
mnway38_cell82 ML38 gate_way38_cell82 GND GND n1 W=1e-6 L=1e-6
mpway38_cell82 ML38 gate_way38_cell82 GND ML38 p1 W=2.4e-6 L=1e-6
mnway38_cell83 ML38 gate_way38_cell83 GND GND n1 W=1e-6 L=1e-6
mpway38_cell83 ML38 gate_way38_cell83 GND ML38 p1 W=2.4e-6 L=1e-6
mnway38_cell84 ML38 gate_way38_cell84 GND GND n1 W=1e-6 L=1e-6
mpway38_cell84 ML38 gate_way38_cell84 GND ML38 p1 W=2.4e-6 L=1e-6
mnway38_cell85 ML38 gate_way38_cell85 GND GND n1 W=1e-6 L=1e-6
mpway38_cell85 ML38 gate_way38_cell85 GND ML38 p1 W=2.4e-6 L=1e-6
mnway38_cell86 ML38 gate_way38_cell86 GND GND n1 W=1e-6 L=1e-6
mpway38_cell86 ML38 gate_way38_cell86 GND ML38 p1 W=2.4e-6 L=1e-6
mnway38_cell87 ML38 gate_way38_cell87 GND GND n1 W=1e-6 L=1e-6
mpway38_cell87 ML38 gate_way38_cell87 GND ML38 p1 W=2.4e-6 L=1e-6
mnway38_cell88 ML38 gate_way38_cell88 GND GND n1 W=1e-6 L=1e-6
mpway38_cell88 ML38 gate_way38_cell88 GND ML38 p1 W=2.4e-6 L=1e-6
mnway38_cell89 ML38 gate_way38_cell89 GND GND n1 W=1e-6 L=1e-6
mpway38_cell89 ML38 gate_way38_cell89 GND ML38 p1 W=2.4e-6 L=1e-6
mnway38_cell90 ML38 gate_way38_cell90 GND GND n1 W=1e-6 L=1e-6
mpway38_cell90 ML38 gate_way38_cell90 GND ML38 p1 W=2.4e-6 L=1e-6
mnway38_cell91 ML38 gate_way38_cell91 GND GND n1 W=1e-6 L=1e-6
mpway38_cell91 ML38 gate_way38_cell91 GND ML38 p1 W=2.4e-6 L=1e-6
mnway38_cell92 ML38 gate_way38_cell92 GND GND n1 W=1e-6 L=1e-6
mpway38_cell92 ML38 gate_way38_cell92 GND ML38 p1 W=2.4e-6 L=1e-6
mnway38_cell93 ML38 gate_way38_cell93 GND GND n1 W=1e-6 L=1e-6
mpway38_cell93 ML38 gate_way38_cell93 GND ML38 p1 W=2.4e-6 L=1e-6
mnway38_cell94 ML38 gate_way38_cell94 GND GND n1 W=1e-6 L=1e-6
mpway38_cell94 ML38 gate_way38_cell94 GND ML38 p1 W=2.4e-6 L=1e-6
mnway38_cell95 ML38 gate_way38_cell95 GND GND n1 W=1e-6 L=1e-6
mpway38_cell95 ML38 gate_way38_cell95 GND ML38 p1 W=2.4e-6 L=1e-6
mnway38_cell96 ML38 gate_way38_cell96 GND GND n1 W=1e-6 L=1e-6
mpway38_cell96 ML38 gate_way38_cell96 GND ML38 p1 W=2.4e-6 L=1e-6
mnway38_cell97 ML38 gate_way38_cell97 GND GND n1 W=1e-6 L=1e-6
mpway38_cell97 ML38 gate_way38_cell97 GND ML38 p1 W=2.4e-6 L=1e-6
mnway38_cell98 ML38 gate_way38_cell98 GND GND n1 W=1e-6 L=1e-6
mpway38_cell98 ML38 gate_way38_cell98 GND ML38 p1 W=2.4e-6 L=1e-6
mnway38_cell99 ML38 gate_way38_cell99 GND GND n1 W=1e-6 L=1e-6
mpway38_cell99 ML38 gate_way38_cell99 GND ML38 p1 W=2.4e-6 L=1e-6
mnway39_cell0 ML39 gate_way39_cell0 GND GND n1 W=1e-6 L=1e-6
mpway39_cell0 ML39 gate_way39_cell0 GND ML39 p1 W=2.4e-6 L=1e-6
mnway39_cell1 ML39 gate_way39_cell1 GND GND n1 W=1e-6 L=1e-6
mpway39_cell1 ML39 gate_way39_cell1 GND ML39 p1 W=2.4e-6 L=1e-6
mnway39_cell2 ML39 gate_way39_cell2 GND GND n1 W=1e-6 L=1e-6
mpway39_cell2 ML39 gate_way39_cell2 GND ML39 p1 W=2.4e-6 L=1e-6
mnway39_cell3 ML39 gate_way39_cell3 GND GND n1 W=1e-6 L=1e-6
mpway39_cell3 ML39 gate_way39_cell3 GND ML39 p1 W=2.4e-6 L=1e-6
mnway39_cell4 ML39 gate_way39_cell4 GND GND n1 W=1e-6 L=1e-6
mpway39_cell4 ML39 gate_way39_cell4 GND ML39 p1 W=2.4e-6 L=1e-6
mnway39_cell5 ML39 gate_way39_cell5 GND GND n1 W=1e-6 L=1e-6
mpway39_cell5 ML39 gate_way39_cell5 GND ML39 p1 W=2.4e-6 L=1e-6
mnway39_cell6 ML39 gate_way39_cell6 GND GND n1 W=1e-6 L=1e-6
mpway39_cell6 ML39 gate_way39_cell6 GND ML39 p1 W=2.4e-6 L=1e-6
mnway39_cell7 ML39 gate_way39_cell7 GND GND n1 W=1e-6 L=1e-6
mpway39_cell7 ML39 gate_way39_cell7 GND ML39 p1 W=2.4e-6 L=1e-6
mnway39_cell8 ML39 gate_way39_cell8 GND GND n1 W=1e-6 L=1e-6
mpway39_cell8 ML39 gate_way39_cell8 GND ML39 p1 W=2.4e-6 L=1e-6
mnway39_cell9 ML39 gate_way39_cell9 GND GND n1 W=1e-6 L=1e-6
mpway39_cell9 ML39 gate_way39_cell9 GND ML39 p1 W=2.4e-6 L=1e-6
mnway39_cell10 ML39 gate_way39_cell10 GND GND n1 W=1e-6 L=1e-6
mpway39_cell10 ML39 gate_way39_cell10 GND ML39 p1 W=2.4e-6 L=1e-6
mnway39_cell11 ML39 gate_way39_cell11 GND GND n1 W=1e-6 L=1e-6
mpway39_cell11 ML39 gate_way39_cell11 GND ML39 p1 W=2.4e-6 L=1e-6
mnway39_cell12 ML39 gate_way39_cell12 GND GND n1 W=1e-6 L=1e-6
mpway39_cell12 ML39 gate_way39_cell12 GND ML39 p1 W=2.4e-6 L=1e-6
mnway39_cell13 ML39 gate_way39_cell13 GND GND n1 W=1e-6 L=1e-6
mpway39_cell13 ML39 gate_way39_cell13 GND ML39 p1 W=2.4e-6 L=1e-6
mnway39_cell14 ML39 gate_way39_cell14 GND GND n1 W=1e-6 L=1e-6
mpway39_cell14 ML39 gate_way39_cell14 GND ML39 p1 W=2.4e-6 L=1e-6
mnway39_cell15 ML39 gate_way39_cell15 GND GND n1 W=1e-6 L=1e-6
mpway39_cell15 ML39 gate_way39_cell15 GND ML39 p1 W=2.4e-6 L=1e-6
mnway39_cell16 ML39 gate_way39_cell16 GND GND n1 W=1e-6 L=1e-6
mpway39_cell16 ML39 gate_way39_cell16 GND ML39 p1 W=2.4e-6 L=1e-6
mnway39_cell17 ML39 gate_way39_cell17 GND GND n1 W=1e-6 L=1e-6
mpway39_cell17 ML39 gate_way39_cell17 GND ML39 p1 W=2.4e-6 L=1e-6
mnway39_cell18 ML39 gate_way39_cell18 GND GND n1 W=1e-6 L=1e-6
mpway39_cell18 ML39 gate_way39_cell18 GND ML39 p1 W=2.4e-6 L=1e-6
mnway39_cell19 ML39 gate_way39_cell19 GND GND n1 W=1e-6 L=1e-6
mpway39_cell19 ML39 gate_way39_cell19 GND ML39 p1 W=2.4e-6 L=1e-6
mnway39_cell20 ML39 gate_way39_cell20 GND GND n1 W=1e-6 L=1e-6
mpway39_cell20 ML39 gate_way39_cell20 GND ML39 p1 W=2.4e-6 L=1e-6
mnway39_cell21 ML39 gate_way39_cell21 GND GND n1 W=1e-6 L=1e-6
mpway39_cell21 ML39 gate_way39_cell21 GND ML39 p1 W=2.4e-6 L=1e-6
mnway39_cell22 ML39 gate_way39_cell22 GND GND n1 W=1e-6 L=1e-6
mpway39_cell22 ML39 gate_way39_cell22 GND ML39 p1 W=2.4e-6 L=1e-6
mnway39_cell23 ML39 gate_way39_cell23 GND GND n1 W=1e-6 L=1e-6
mpway39_cell23 ML39 gate_way39_cell23 GND ML39 p1 W=2.4e-6 L=1e-6
mnway39_cell24 ML39 gate_way39_cell24 GND GND n1 W=1e-6 L=1e-6
mpway39_cell24 ML39 gate_way39_cell24 GND ML39 p1 W=2.4e-6 L=1e-6
mnway39_cell25 ML39 gate_way39_cell25 GND GND n1 W=1e-6 L=1e-6
mpway39_cell25 ML39 gate_way39_cell25 GND ML39 p1 W=2.4e-6 L=1e-6
mnway39_cell26 ML39 gate_way39_cell26 GND GND n1 W=1e-6 L=1e-6
mpway39_cell26 ML39 gate_way39_cell26 GND ML39 p1 W=2.4e-6 L=1e-6
mnway39_cell27 ML39 gate_way39_cell27 GND GND n1 W=1e-6 L=1e-6
mpway39_cell27 ML39 gate_way39_cell27 GND ML39 p1 W=2.4e-6 L=1e-6
mnway39_cell28 ML39 gate_way39_cell28 GND GND n1 W=1e-6 L=1e-6
mpway39_cell28 ML39 gate_way39_cell28 GND ML39 p1 W=2.4e-6 L=1e-6
mnway39_cell29 ML39 gate_way39_cell29 GND GND n1 W=1e-6 L=1e-6
mpway39_cell29 ML39 gate_way39_cell29 GND ML39 p1 W=2.4e-6 L=1e-6
mnway39_cell30 ML39 gate_way39_cell30 GND GND n1 W=1e-6 L=1e-6
mpway39_cell30 ML39 gate_way39_cell30 GND ML39 p1 W=2.4e-6 L=1e-6
mnway39_cell31 ML39 gate_way39_cell31 GND GND n1 W=1e-6 L=1e-6
mpway39_cell31 ML39 gate_way39_cell31 GND ML39 p1 W=2.4e-6 L=1e-6
mnway39_cell32 ML39 gate_way39_cell32 GND GND n1 W=1e-6 L=1e-6
mpway39_cell32 ML39 gate_way39_cell32 GND ML39 p1 W=2.4e-6 L=1e-6
mnway39_cell33 ML39 gate_way39_cell33 GND GND n1 W=1e-6 L=1e-6
mpway39_cell33 ML39 gate_way39_cell33 GND ML39 p1 W=2.4e-6 L=1e-6
mnway39_cell34 ML39 gate_way39_cell34 GND GND n1 W=1e-6 L=1e-6
mpway39_cell34 ML39 gate_way39_cell34 GND ML39 p1 W=2.4e-6 L=1e-6
mnway39_cell35 ML39 gate_way39_cell35 GND GND n1 W=1e-6 L=1e-6
mpway39_cell35 ML39 gate_way39_cell35 GND ML39 p1 W=2.4e-6 L=1e-6
mnway39_cell36 ML39 gate_way39_cell36 GND GND n1 W=1e-6 L=1e-6
mpway39_cell36 ML39 gate_way39_cell36 GND ML39 p1 W=2.4e-6 L=1e-6
mnway39_cell37 ML39 gate_way39_cell37 GND GND n1 W=1e-6 L=1e-6
mpway39_cell37 ML39 gate_way39_cell37 GND ML39 p1 W=2.4e-6 L=1e-6
mnway39_cell38 ML39 gate_way39_cell38 GND GND n1 W=1e-6 L=1e-6
mpway39_cell38 ML39 gate_way39_cell38 GND ML39 p1 W=2.4e-6 L=1e-6
mnway39_cell39 ML39 gate_way39_cell39 GND GND n1 W=1e-6 L=1e-6
mpway39_cell39 ML39 gate_way39_cell39 GND ML39 p1 W=2.4e-6 L=1e-6
mnway39_cell40 ML39 gate_way39_cell40 GND GND n1 W=1e-6 L=1e-6
mpway39_cell40 ML39 gate_way39_cell40 GND ML39 p1 W=2.4e-6 L=1e-6
mnway39_cell41 ML39 gate_way39_cell41 GND GND n1 W=1e-6 L=1e-6
mpway39_cell41 ML39 gate_way39_cell41 GND ML39 p1 W=2.4e-6 L=1e-6
mnway39_cell42 ML39 gate_way39_cell42 GND GND n1 W=1e-6 L=1e-6
mpway39_cell42 ML39 gate_way39_cell42 GND ML39 p1 W=2.4e-6 L=1e-6
mnway39_cell43 ML39 gate_way39_cell43 GND GND n1 W=1e-6 L=1e-6
mpway39_cell43 ML39 gate_way39_cell43 GND ML39 p1 W=2.4e-6 L=1e-6
mnway39_cell44 ML39 gate_way39_cell44 GND GND n1 W=1e-6 L=1e-6
mpway39_cell44 ML39 gate_way39_cell44 GND ML39 p1 W=2.4e-6 L=1e-6
mnway39_cell45 ML39 gate_way39_cell45 GND GND n1 W=1e-6 L=1e-6
mpway39_cell45 ML39 gate_way39_cell45 GND ML39 p1 W=2.4e-6 L=1e-6
mnway39_cell46 ML39 gate_way39_cell46 GND GND n1 W=1e-6 L=1e-6
mpway39_cell46 ML39 gate_way39_cell46 GND ML39 p1 W=2.4e-6 L=1e-6
mnway39_cell47 ML39 gate_way39_cell47 GND GND n1 W=1e-6 L=1e-6
mpway39_cell47 ML39 gate_way39_cell47 GND ML39 p1 W=2.4e-6 L=1e-6
mnway39_cell48 ML39 gate_way39_cell48 GND GND n1 W=1e-6 L=1e-6
mpway39_cell48 ML39 gate_way39_cell48 GND ML39 p1 W=2.4e-6 L=1e-6
mnway39_cell49 ML39 gate_way39_cell49 GND GND n1 W=1e-6 L=1e-6
mpway39_cell49 ML39 gate_way39_cell49 GND ML39 p1 W=2.4e-6 L=1e-6
mnway39_cell50 ML39 gate_way39_cell50 GND GND n1 W=1e-6 L=1e-6
mpway39_cell50 ML39 gate_way39_cell50 GND ML39 p1 W=2.4e-6 L=1e-6
mnway39_cell51 ML39 gate_way39_cell51 GND GND n1 W=1e-6 L=1e-6
mpway39_cell51 ML39 gate_way39_cell51 GND ML39 p1 W=2.4e-6 L=1e-6
mnway39_cell52 ML39 gate_way39_cell52 GND GND n1 W=1e-6 L=1e-6
mpway39_cell52 ML39 gate_way39_cell52 GND ML39 p1 W=2.4e-6 L=1e-6
mnway39_cell53 ML39 gate_way39_cell53 GND GND n1 W=1e-6 L=1e-6
mpway39_cell53 ML39 gate_way39_cell53 GND ML39 p1 W=2.4e-6 L=1e-6
mnway39_cell54 ML39 gate_way39_cell54 GND GND n1 W=1e-6 L=1e-6
mpway39_cell54 ML39 gate_way39_cell54 GND ML39 p1 W=2.4e-6 L=1e-6
mnway39_cell55 ML39 gate_way39_cell55 GND GND n1 W=1e-6 L=1e-6
mpway39_cell55 ML39 gate_way39_cell55 GND ML39 p1 W=2.4e-6 L=1e-6
mnway39_cell56 ML39 gate_way39_cell56 GND GND n1 W=1e-6 L=1e-6
mpway39_cell56 ML39 gate_way39_cell56 GND ML39 p1 W=2.4e-6 L=1e-6
mnway39_cell57 ML39 gate_way39_cell57 GND GND n1 W=1e-6 L=1e-6
mpway39_cell57 ML39 gate_way39_cell57 GND ML39 p1 W=2.4e-6 L=1e-6
mnway39_cell58 ML39 gate_way39_cell58 GND GND n1 W=1e-6 L=1e-6
mpway39_cell58 ML39 gate_way39_cell58 GND ML39 p1 W=2.4e-6 L=1e-6
mnway39_cell59 ML39 gate_way39_cell59 GND GND n1 W=1e-6 L=1e-6
mpway39_cell59 ML39 gate_way39_cell59 GND ML39 p1 W=2.4e-6 L=1e-6
mnway39_cell60 ML39 gate_way39_cell60 GND GND n1 W=1e-6 L=1e-6
mpway39_cell60 ML39 gate_way39_cell60 GND ML39 p1 W=2.4e-6 L=1e-6
mnway39_cell61 ML39 gate_way39_cell61 GND GND n1 W=1e-6 L=1e-6
mpway39_cell61 ML39 gate_way39_cell61 GND ML39 p1 W=2.4e-6 L=1e-6
mnway39_cell62 ML39 gate_way39_cell62 GND GND n1 W=1e-6 L=1e-6
mpway39_cell62 ML39 gate_way39_cell62 GND ML39 p1 W=2.4e-6 L=1e-6
mnway39_cell63 ML39 gate_way39_cell63 GND GND n1 W=1e-6 L=1e-6
mpway39_cell63 ML39 gate_way39_cell63 GND ML39 p1 W=2.4e-6 L=1e-6
mnway39_cell64 ML39 gate_way39_cell64 GND GND n1 W=1e-6 L=1e-6
mpway39_cell64 ML39 gate_way39_cell64 GND ML39 p1 W=2.4e-6 L=1e-6
mnway39_cell65 ML39 gate_way39_cell65 GND GND n1 W=1e-6 L=1e-6
mpway39_cell65 ML39 gate_way39_cell65 GND ML39 p1 W=2.4e-6 L=1e-6
mnway39_cell66 ML39 gate_way39_cell66 GND GND n1 W=1e-6 L=1e-6
mpway39_cell66 ML39 gate_way39_cell66 GND ML39 p1 W=2.4e-6 L=1e-6
mnway39_cell67 ML39 gate_way39_cell67 GND GND n1 W=1e-6 L=1e-6
mpway39_cell67 ML39 gate_way39_cell67 GND ML39 p1 W=2.4e-6 L=1e-6
mnway39_cell68 ML39 gate_way39_cell68 GND GND n1 W=1e-6 L=1e-6
mpway39_cell68 ML39 gate_way39_cell68 GND ML39 p1 W=2.4e-6 L=1e-6
mnway39_cell69 ML39 gate_way39_cell69 GND GND n1 W=1e-6 L=1e-6
mpway39_cell69 ML39 gate_way39_cell69 GND ML39 p1 W=2.4e-6 L=1e-6
mnway39_cell70 ML39 gate_way39_cell70 GND GND n1 W=1e-6 L=1e-6
mpway39_cell70 ML39 gate_way39_cell70 GND ML39 p1 W=2.4e-6 L=1e-6
mnway39_cell71 ML39 gate_way39_cell71 GND GND n1 W=1e-6 L=1e-6
mpway39_cell71 ML39 gate_way39_cell71 GND ML39 p1 W=2.4e-6 L=1e-6
mnway39_cell72 ML39 gate_way39_cell72 GND GND n1 W=1e-6 L=1e-6
mpway39_cell72 ML39 gate_way39_cell72 GND ML39 p1 W=2.4e-6 L=1e-6
mnway39_cell73 ML39 gate_way39_cell73 GND GND n1 W=1e-6 L=1e-6
mpway39_cell73 ML39 gate_way39_cell73 GND ML39 p1 W=2.4e-6 L=1e-6
mnway39_cell74 ML39 gate_way39_cell74 GND GND n1 W=1e-6 L=1e-6
mpway39_cell74 ML39 gate_way39_cell74 GND ML39 p1 W=2.4e-6 L=1e-6
mnway39_cell75 ML39 gate_way39_cell75 GND GND n1 W=1e-6 L=1e-6
mpway39_cell75 ML39 gate_way39_cell75 GND ML39 p1 W=2.4e-6 L=1e-6
mnway39_cell76 ML39 gate_way39_cell76 GND GND n1 W=1e-6 L=1e-6
mpway39_cell76 ML39 gate_way39_cell76 GND ML39 p1 W=2.4e-6 L=1e-6
mnway39_cell77 ML39 gate_way39_cell77 GND GND n1 W=1e-6 L=1e-6
mpway39_cell77 ML39 gate_way39_cell77 GND ML39 p1 W=2.4e-6 L=1e-6
mnway39_cell78 ML39 gate_way39_cell78 GND GND n1 W=1e-6 L=1e-6
mpway39_cell78 ML39 gate_way39_cell78 GND ML39 p1 W=2.4e-6 L=1e-6
mnway39_cell79 ML39 gate_way39_cell79 GND GND n1 W=1e-6 L=1e-6
mpway39_cell79 ML39 gate_way39_cell79 GND ML39 p1 W=2.4e-6 L=1e-6
mnway39_cell80 ML39 gate_way39_cell80 GND GND n1 W=1e-6 L=1e-6
mpway39_cell80 ML39 gate_way39_cell80 GND ML39 p1 W=2.4e-6 L=1e-6
mnway39_cell81 ML39 gate_way39_cell81 GND GND n1 W=1e-6 L=1e-6
mpway39_cell81 ML39 gate_way39_cell81 GND ML39 p1 W=2.4e-6 L=1e-6
mnway39_cell82 ML39 gate_way39_cell82 GND GND n1 W=1e-6 L=1e-6
mpway39_cell82 ML39 gate_way39_cell82 GND ML39 p1 W=2.4e-6 L=1e-6
mnway39_cell83 ML39 gate_way39_cell83 GND GND n1 W=1e-6 L=1e-6
mpway39_cell83 ML39 gate_way39_cell83 GND ML39 p1 W=2.4e-6 L=1e-6
mnway39_cell84 ML39 gate_way39_cell84 GND GND n1 W=1e-6 L=1e-6
mpway39_cell84 ML39 gate_way39_cell84 GND ML39 p1 W=2.4e-6 L=1e-6
mnway39_cell85 ML39 gate_way39_cell85 GND GND n1 W=1e-6 L=1e-6
mpway39_cell85 ML39 gate_way39_cell85 GND ML39 p1 W=2.4e-6 L=1e-6
mnway39_cell86 ML39 gate_way39_cell86 GND GND n1 W=1e-6 L=1e-6
mpway39_cell86 ML39 gate_way39_cell86 GND ML39 p1 W=2.4e-6 L=1e-6
mnway39_cell87 ML39 gate_way39_cell87 GND GND n1 W=1e-6 L=1e-6
mpway39_cell87 ML39 gate_way39_cell87 GND ML39 p1 W=2.4e-6 L=1e-6
mnway39_cell88 ML39 gate_way39_cell88 GND GND n1 W=1e-6 L=1e-6
mpway39_cell88 ML39 gate_way39_cell88 GND ML39 p1 W=2.4e-6 L=1e-6
mnway39_cell89 ML39 gate_way39_cell89 GND GND n1 W=1e-6 L=1e-6
mpway39_cell89 ML39 gate_way39_cell89 GND ML39 p1 W=2.4e-6 L=1e-6
mnway39_cell90 ML39 gate_way39_cell90 GND GND n1 W=1e-6 L=1e-6
mpway39_cell90 ML39 gate_way39_cell90 GND ML39 p1 W=2.4e-6 L=1e-6
mnway39_cell91 ML39 gate_way39_cell91 GND GND n1 W=1e-6 L=1e-6
mpway39_cell91 ML39 gate_way39_cell91 GND ML39 p1 W=2.4e-6 L=1e-6
mnway39_cell92 ML39 gate_way39_cell92 GND GND n1 W=1e-6 L=1e-6
mpway39_cell92 ML39 gate_way39_cell92 GND ML39 p1 W=2.4e-6 L=1e-6
mnway39_cell93 ML39 gate_way39_cell93 GND GND n1 W=1e-6 L=1e-6
mpway39_cell93 ML39 gate_way39_cell93 GND ML39 p1 W=2.4e-6 L=1e-6
mnway39_cell94 ML39 gate_way39_cell94 GND GND n1 W=1e-6 L=1e-6
mpway39_cell94 ML39 gate_way39_cell94 GND ML39 p1 W=2.4e-6 L=1e-6
mnway39_cell95 ML39 gate_way39_cell95 GND GND n1 W=1e-6 L=1e-6
mpway39_cell95 ML39 gate_way39_cell95 GND ML39 p1 W=2.4e-6 L=1e-6
mnway39_cell96 ML39 gate_way39_cell96 GND GND n1 W=1e-6 L=1e-6
mpway39_cell96 ML39 gate_way39_cell96 GND ML39 p1 W=2.4e-6 L=1e-6
mnway39_cell97 ML39 gate_way39_cell97 GND GND n1 W=1e-6 L=1e-6
mpway39_cell97 ML39 gate_way39_cell97 GND ML39 p1 W=2.4e-6 L=1e-6
mnway39_cell98 ML39 gate_way39_cell98 GND GND n1 W=1e-6 L=1e-6
mpway39_cell98 ML39 gate_way39_cell98 GND ML39 p1 W=2.4e-6 L=1e-6
mnway39_cell99 ML39 gate_way39_cell99 GND GND n1 W=1e-6 L=1e-6
mpway39_cell99 ML39 gate_way39_cell99 GND ML39 p1 W=2.4e-6 L=1e-6
mnway40_cell0 ML40 gate_way40_cell0 GND GND n1 W=1e-6 L=1e-6
mpway40_cell0 ML40 gate_way40_cell0 GND ML40 p1 W=2.4e-6 L=1e-6
mnway40_cell1 ML40 gate_way40_cell1 GND GND n1 W=1e-6 L=1e-6
mpway40_cell1 ML40 gate_way40_cell1 GND ML40 p1 W=2.4e-6 L=1e-6
mnway40_cell2 ML40 gate_way40_cell2 GND GND n1 W=1e-6 L=1e-6
mpway40_cell2 ML40 gate_way40_cell2 GND ML40 p1 W=2.4e-6 L=1e-6
mnway40_cell3 ML40 gate_way40_cell3 GND GND n1 W=1e-6 L=1e-6
mpway40_cell3 ML40 gate_way40_cell3 GND ML40 p1 W=2.4e-6 L=1e-6
mnway40_cell4 ML40 gate_way40_cell4 GND GND n1 W=1e-6 L=1e-6
mpway40_cell4 ML40 gate_way40_cell4 GND ML40 p1 W=2.4e-6 L=1e-6
mnway40_cell5 ML40 gate_way40_cell5 GND GND n1 W=1e-6 L=1e-6
mpway40_cell5 ML40 gate_way40_cell5 GND ML40 p1 W=2.4e-6 L=1e-6
mnway40_cell6 ML40 gate_way40_cell6 GND GND n1 W=1e-6 L=1e-6
mpway40_cell6 ML40 gate_way40_cell6 GND ML40 p1 W=2.4e-6 L=1e-6
mnway40_cell7 ML40 gate_way40_cell7 GND GND n1 W=1e-6 L=1e-6
mpway40_cell7 ML40 gate_way40_cell7 GND ML40 p1 W=2.4e-6 L=1e-6
mnway40_cell8 ML40 gate_way40_cell8 GND GND n1 W=1e-6 L=1e-6
mpway40_cell8 ML40 gate_way40_cell8 GND ML40 p1 W=2.4e-6 L=1e-6
mnway40_cell9 ML40 gate_way40_cell9 GND GND n1 W=1e-6 L=1e-6
mpway40_cell9 ML40 gate_way40_cell9 GND ML40 p1 W=2.4e-6 L=1e-6
mnway40_cell10 ML40 gate_way40_cell10 GND GND n1 W=1e-6 L=1e-6
mpway40_cell10 ML40 gate_way40_cell10 GND ML40 p1 W=2.4e-6 L=1e-6
mnway40_cell11 ML40 gate_way40_cell11 GND GND n1 W=1e-6 L=1e-6
mpway40_cell11 ML40 gate_way40_cell11 GND ML40 p1 W=2.4e-6 L=1e-6
mnway40_cell12 ML40 gate_way40_cell12 GND GND n1 W=1e-6 L=1e-6
mpway40_cell12 ML40 gate_way40_cell12 GND ML40 p1 W=2.4e-6 L=1e-6
mnway40_cell13 ML40 gate_way40_cell13 GND GND n1 W=1e-6 L=1e-6
mpway40_cell13 ML40 gate_way40_cell13 GND ML40 p1 W=2.4e-6 L=1e-6
mnway40_cell14 ML40 gate_way40_cell14 GND GND n1 W=1e-6 L=1e-6
mpway40_cell14 ML40 gate_way40_cell14 GND ML40 p1 W=2.4e-6 L=1e-6
mnway40_cell15 ML40 gate_way40_cell15 GND GND n1 W=1e-6 L=1e-6
mpway40_cell15 ML40 gate_way40_cell15 GND ML40 p1 W=2.4e-6 L=1e-6
mnway40_cell16 ML40 gate_way40_cell16 GND GND n1 W=1e-6 L=1e-6
mpway40_cell16 ML40 gate_way40_cell16 GND ML40 p1 W=2.4e-6 L=1e-6
mnway40_cell17 ML40 gate_way40_cell17 GND GND n1 W=1e-6 L=1e-6
mpway40_cell17 ML40 gate_way40_cell17 GND ML40 p1 W=2.4e-6 L=1e-6
mnway40_cell18 ML40 gate_way40_cell18 GND GND n1 W=1e-6 L=1e-6
mpway40_cell18 ML40 gate_way40_cell18 GND ML40 p1 W=2.4e-6 L=1e-6
mnway40_cell19 ML40 gate_way40_cell19 GND GND n1 W=1e-6 L=1e-6
mpway40_cell19 ML40 gate_way40_cell19 GND ML40 p1 W=2.4e-6 L=1e-6
mnway40_cell20 ML40 gate_way40_cell20 GND GND n1 W=1e-6 L=1e-6
mpway40_cell20 ML40 gate_way40_cell20 GND ML40 p1 W=2.4e-6 L=1e-6
mnway40_cell21 ML40 gate_way40_cell21 GND GND n1 W=1e-6 L=1e-6
mpway40_cell21 ML40 gate_way40_cell21 GND ML40 p1 W=2.4e-6 L=1e-6
mnway40_cell22 ML40 gate_way40_cell22 GND GND n1 W=1e-6 L=1e-6
mpway40_cell22 ML40 gate_way40_cell22 GND ML40 p1 W=2.4e-6 L=1e-6
mnway40_cell23 ML40 gate_way40_cell23 GND GND n1 W=1e-6 L=1e-6
mpway40_cell23 ML40 gate_way40_cell23 GND ML40 p1 W=2.4e-6 L=1e-6
mnway40_cell24 ML40 gate_way40_cell24 GND GND n1 W=1e-6 L=1e-6
mpway40_cell24 ML40 gate_way40_cell24 GND ML40 p1 W=2.4e-6 L=1e-6
mnway40_cell25 ML40 gate_way40_cell25 GND GND n1 W=1e-6 L=1e-6
mpway40_cell25 ML40 gate_way40_cell25 GND ML40 p1 W=2.4e-6 L=1e-6
mnway40_cell26 ML40 gate_way40_cell26 GND GND n1 W=1e-6 L=1e-6
mpway40_cell26 ML40 gate_way40_cell26 GND ML40 p1 W=2.4e-6 L=1e-6
mnway40_cell27 ML40 gate_way40_cell27 GND GND n1 W=1e-6 L=1e-6
mpway40_cell27 ML40 gate_way40_cell27 GND ML40 p1 W=2.4e-6 L=1e-6
mnway40_cell28 ML40 gate_way40_cell28 GND GND n1 W=1e-6 L=1e-6
mpway40_cell28 ML40 gate_way40_cell28 GND ML40 p1 W=2.4e-6 L=1e-6
mnway40_cell29 ML40 gate_way40_cell29 GND GND n1 W=1e-6 L=1e-6
mpway40_cell29 ML40 gate_way40_cell29 GND ML40 p1 W=2.4e-6 L=1e-6
mnway40_cell30 ML40 gate_way40_cell30 GND GND n1 W=1e-6 L=1e-6
mpway40_cell30 ML40 gate_way40_cell30 GND ML40 p1 W=2.4e-6 L=1e-6
mnway40_cell31 ML40 gate_way40_cell31 GND GND n1 W=1e-6 L=1e-6
mpway40_cell31 ML40 gate_way40_cell31 GND ML40 p1 W=2.4e-6 L=1e-6
mnway40_cell32 ML40 gate_way40_cell32 GND GND n1 W=1e-6 L=1e-6
mpway40_cell32 ML40 gate_way40_cell32 GND ML40 p1 W=2.4e-6 L=1e-6
mnway40_cell33 ML40 gate_way40_cell33 GND GND n1 W=1e-6 L=1e-6
mpway40_cell33 ML40 gate_way40_cell33 GND ML40 p1 W=2.4e-6 L=1e-6
mnway40_cell34 ML40 gate_way40_cell34 GND GND n1 W=1e-6 L=1e-6
mpway40_cell34 ML40 gate_way40_cell34 GND ML40 p1 W=2.4e-6 L=1e-6
mnway40_cell35 ML40 gate_way40_cell35 GND GND n1 W=1e-6 L=1e-6
mpway40_cell35 ML40 gate_way40_cell35 GND ML40 p1 W=2.4e-6 L=1e-6
mnway40_cell36 ML40 gate_way40_cell36 GND GND n1 W=1e-6 L=1e-6
mpway40_cell36 ML40 gate_way40_cell36 GND ML40 p1 W=2.4e-6 L=1e-6
mnway40_cell37 ML40 gate_way40_cell37 GND GND n1 W=1e-6 L=1e-6
mpway40_cell37 ML40 gate_way40_cell37 GND ML40 p1 W=2.4e-6 L=1e-6
mnway40_cell38 ML40 gate_way40_cell38 GND GND n1 W=1e-6 L=1e-6
mpway40_cell38 ML40 gate_way40_cell38 GND ML40 p1 W=2.4e-6 L=1e-6
mnway40_cell39 ML40 gate_way40_cell39 GND GND n1 W=1e-6 L=1e-6
mpway40_cell39 ML40 gate_way40_cell39 GND ML40 p1 W=2.4e-6 L=1e-6
mnway40_cell40 ML40 gate_way40_cell40 GND GND n1 W=1e-6 L=1e-6
mpway40_cell40 ML40 gate_way40_cell40 GND ML40 p1 W=2.4e-6 L=1e-6
mnway40_cell41 ML40 gate_way40_cell41 GND GND n1 W=1e-6 L=1e-6
mpway40_cell41 ML40 gate_way40_cell41 GND ML40 p1 W=2.4e-6 L=1e-6
mnway40_cell42 ML40 gate_way40_cell42 GND GND n1 W=1e-6 L=1e-6
mpway40_cell42 ML40 gate_way40_cell42 GND ML40 p1 W=2.4e-6 L=1e-6
mnway40_cell43 ML40 gate_way40_cell43 GND GND n1 W=1e-6 L=1e-6
mpway40_cell43 ML40 gate_way40_cell43 GND ML40 p1 W=2.4e-6 L=1e-6
mnway40_cell44 ML40 gate_way40_cell44 GND GND n1 W=1e-6 L=1e-6
mpway40_cell44 ML40 gate_way40_cell44 GND ML40 p1 W=2.4e-6 L=1e-6
mnway40_cell45 ML40 gate_way40_cell45 GND GND n1 W=1e-6 L=1e-6
mpway40_cell45 ML40 gate_way40_cell45 GND ML40 p1 W=2.4e-6 L=1e-6
mnway40_cell46 ML40 gate_way40_cell46 GND GND n1 W=1e-6 L=1e-6
mpway40_cell46 ML40 gate_way40_cell46 GND ML40 p1 W=2.4e-6 L=1e-6
mnway40_cell47 ML40 gate_way40_cell47 GND GND n1 W=1e-6 L=1e-6
mpway40_cell47 ML40 gate_way40_cell47 GND ML40 p1 W=2.4e-6 L=1e-6
mnway40_cell48 ML40 gate_way40_cell48 GND GND n1 W=1e-6 L=1e-6
mpway40_cell48 ML40 gate_way40_cell48 GND ML40 p1 W=2.4e-6 L=1e-6
mnway40_cell49 ML40 gate_way40_cell49 GND GND n1 W=1e-6 L=1e-6
mpway40_cell49 ML40 gate_way40_cell49 GND ML40 p1 W=2.4e-6 L=1e-6
mnway40_cell50 ML40 gate_way40_cell50 GND GND n1 W=1e-6 L=1e-6
mpway40_cell50 ML40 gate_way40_cell50 GND ML40 p1 W=2.4e-6 L=1e-6
mnway40_cell51 ML40 gate_way40_cell51 GND GND n1 W=1e-6 L=1e-6
mpway40_cell51 ML40 gate_way40_cell51 GND ML40 p1 W=2.4e-6 L=1e-6
mnway40_cell52 ML40 gate_way40_cell52 GND GND n1 W=1e-6 L=1e-6
mpway40_cell52 ML40 gate_way40_cell52 GND ML40 p1 W=2.4e-6 L=1e-6
mnway40_cell53 ML40 gate_way40_cell53 GND GND n1 W=1e-6 L=1e-6
mpway40_cell53 ML40 gate_way40_cell53 GND ML40 p1 W=2.4e-6 L=1e-6
mnway40_cell54 ML40 gate_way40_cell54 GND GND n1 W=1e-6 L=1e-6
mpway40_cell54 ML40 gate_way40_cell54 GND ML40 p1 W=2.4e-6 L=1e-6
mnway40_cell55 ML40 gate_way40_cell55 GND GND n1 W=1e-6 L=1e-6
mpway40_cell55 ML40 gate_way40_cell55 GND ML40 p1 W=2.4e-6 L=1e-6
mnway40_cell56 ML40 gate_way40_cell56 GND GND n1 W=1e-6 L=1e-6
mpway40_cell56 ML40 gate_way40_cell56 GND ML40 p1 W=2.4e-6 L=1e-6
mnway40_cell57 ML40 gate_way40_cell57 GND GND n1 W=1e-6 L=1e-6
mpway40_cell57 ML40 gate_way40_cell57 GND ML40 p1 W=2.4e-6 L=1e-6
mnway40_cell58 ML40 gate_way40_cell58 GND GND n1 W=1e-6 L=1e-6
mpway40_cell58 ML40 gate_way40_cell58 GND ML40 p1 W=2.4e-6 L=1e-6
mnway40_cell59 ML40 gate_way40_cell59 GND GND n1 W=1e-6 L=1e-6
mpway40_cell59 ML40 gate_way40_cell59 GND ML40 p1 W=2.4e-6 L=1e-6
mnway40_cell60 ML40 gate_way40_cell60 GND GND n1 W=1e-6 L=1e-6
mpway40_cell60 ML40 gate_way40_cell60 GND ML40 p1 W=2.4e-6 L=1e-6
mnway40_cell61 ML40 gate_way40_cell61 GND GND n1 W=1e-6 L=1e-6
mpway40_cell61 ML40 gate_way40_cell61 GND ML40 p1 W=2.4e-6 L=1e-6
mnway40_cell62 ML40 gate_way40_cell62 GND GND n1 W=1e-6 L=1e-6
mpway40_cell62 ML40 gate_way40_cell62 GND ML40 p1 W=2.4e-6 L=1e-6
mnway40_cell63 ML40 gate_way40_cell63 GND GND n1 W=1e-6 L=1e-6
mpway40_cell63 ML40 gate_way40_cell63 GND ML40 p1 W=2.4e-6 L=1e-6
mnway40_cell64 ML40 gate_way40_cell64 GND GND n1 W=1e-6 L=1e-6
mpway40_cell64 ML40 gate_way40_cell64 GND ML40 p1 W=2.4e-6 L=1e-6
mnway40_cell65 ML40 gate_way40_cell65 GND GND n1 W=1e-6 L=1e-6
mpway40_cell65 ML40 gate_way40_cell65 GND ML40 p1 W=2.4e-6 L=1e-6
mnway40_cell66 ML40 gate_way40_cell66 GND GND n1 W=1e-6 L=1e-6
mpway40_cell66 ML40 gate_way40_cell66 GND ML40 p1 W=2.4e-6 L=1e-6
mnway40_cell67 ML40 gate_way40_cell67 GND GND n1 W=1e-6 L=1e-6
mpway40_cell67 ML40 gate_way40_cell67 GND ML40 p1 W=2.4e-6 L=1e-6
mnway40_cell68 ML40 gate_way40_cell68 GND GND n1 W=1e-6 L=1e-6
mpway40_cell68 ML40 gate_way40_cell68 GND ML40 p1 W=2.4e-6 L=1e-6
mnway40_cell69 ML40 gate_way40_cell69 GND GND n1 W=1e-6 L=1e-6
mpway40_cell69 ML40 gate_way40_cell69 GND ML40 p1 W=2.4e-6 L=1e-6
mnway40_cell70 ML40 gate_way40_cell70 GND GND n1 W=1e-6 L=1e-6
mpway40_cell70 ML40 gate_way40_cell70 GND ML40 p1 W=2.4e-6 L=1e-6
mnway40_cell71 ML40 gate_way40_cell71 GND GND n1 W=1e-6 L=1e-6
mpway40_cell71 ML40 gate_way40_cell71 GND ML40 p1 W=2.4e-6 L=1e-6
mnway40_cell72 ML40 gate_way40_cell72 GND GND n1 W=1e-6 L=1e-6
mpway40_cell72 ML40 gate_way40_cell72 GND ML40 p1 W=2.4e-6 L=1e-6
mnway40_cell73 ML40 gate_way40_cell73 GND GND n1 W=1e-6 L=1e-6
mpway40_cell73 ML40 gate_way40_cell73 GND ML40 p1 W=2.4e-6 L=1e-6
mnway40_cell74 ML40 gate_way40_cell74 GND GND n1 W=1e-6 L=1e-6
mpway40_cell74 ML40 gate_way40_cell74 GND ML40 p1 W=2.4e-6 L=1e-6
mnway40_cell75 ML40 gate_way40_cell75 GND GND n1 W=1e-6 L=1e-6
mpway40_cell75 ML40 gate_way40_cell75 GND ML40 p1 W=2.4e-6 L=1e-6
mnway40_cell76 ML40 gate_way40_cell76 GND GND n1 W=1e-6 L=1e-6
mpway40_cell76 ML40 gate_way40_cell76 GND ML40 p1 W=2.4e-6 L=1e-6
mnway40_cell77 ML40 gate_way40_cell77 GND GND n1 W=1e-6 L=1e-6
mpway40_cell77 ML40 gate_way40_cell77 GND ML40 p1 W=2.4e-6 L=1e-6
mnway40_cell78 ML40 gate_way40_cell78 GND GND n1 W=1e-6 L=1e-6
mpway40_cell78 ML40 gate_way40_cell78 GND ML40 p1 W=2.4e-6 L=1e-6
mnway40_cell79 ML40 gate_way40_cell79 GND GND n1 W=1e-6 L=1e-6
mpway40_cell79 ML40 gate_way40_cell79 GND ML40 p1 W=2.4e-6 L=1e-6
mnway40_cell80 ML40 gate_way40_cell80 GND GND n1 W=1e-6 L=1e-6
mpway40_cell80 ML40 gate_way40_cell80 GND ML40 p1 W=2.4e-6 L=1e-6
mnway40_cell81 ML40 gate_way40_cell81 GND GND n1 W=1e-6 L=1e-6
mpway40_cell81 ML40 gate_way40_cell81 GND ML40 p1 W=2.4e-6 L=1e-6
mnway40_cell82 ML40 gate_way40_cell82 GND GND n1 W=1e-6 L=1e-6
mpway40_cell82 ML40 gate_way40_cell82 GND ML40 p1 W=2.4e-6 L=1e-6
mnway40_cell83 ML40 gate_way40_cell83 GND GND n1 W=1e-6 L=1e-6
mpway40_cell83 ML40 gate_way40_cell83 GND ML40 p1 W=2.4e-6 L=1e-6
mnway40_cell84 ML40 gate_way40_cell84 GND GND n1 W=1e-6 L=1e-6
mpway40_cell84 ML40 gate_way40_cell84 GND ML40 p1 W=2.4e-6 L=1e-6
mnway40_cell85 ML40 gate_way40_cell85 GND GND n1 W=1e-6 L=1e-6
mpway40_cell85 ML40 gate_way40_cell85 GND ML40 p1 W=2.4e-6 L=1e-6
mnway40_cell86 ML40 gate_way40_cell86 GND GND n1 W=1e-6 L=1e-6
mpway40_cell86 ML40 gate_way40_cell86 GND ML40 p1 W=2.4e-6 L=1e-6
mnway40_cell87 ML40 gate_way40_cell87 GND GND n1 W=1e-6 L=1e-6
mpway40_cell87 ML40 gate_way40_cell87 GND ML40 p1 W=2.4e-6 L=1e-6
mnway40_cell88 ML40 gate_way40_cell88 GND GND n1 W=1e-6 L=1e-6
mpway40_cell88 ML40 gate_way40_cell88 GND ML40 p1 W=2.4e-6 L=1e-6
mnway40_cell89 ML40 gate_way40_cell89 GND GND n1 W=1e-6 L=1e-6
mpway40_cell89 ML40 gate_way40_cell89 GND ML40 p1 W=2.4e-6 L=1e-6
mnway40_cell90 ML40 gate_way40_cell90 GND GND n1 W=1e-6 L=1e-6
mpway40_cell90 ML40 gate_way40_cell90 GND ML40 p1 W=2.4e-6 L=1e-6
mnway40_cell91 ML40 gate_way40_cell91 GND GND n1 W=1e-6 L=1e-6
mpway40_cell91 ML40 gate_way40_cell91 GND ML40 p1 W=2.4e-6 L=1e-6
mnway40_cell92 ML40 gate_way40_cell92 GND GND n1 W=1e-6 L=1e-6
mpway40_cell92 ML40 gate_way40_cell92 GND ML40 p1 W=2.4e-6 L=1e-6
mnway40_cell93 ML40 gate_way40_cell93 GND GND n1 W=1e-6 L=1e-6
mpway40_cell93 ML40 gate_way40_cell93 GND ML40 p1 W=2.4e-6 L=1e-6
mnway40_cell94 ML40 gate_way40_cell94 GND GND n1 W=1e-6 L=1e-6
mpway40_cell94 ML40 gate_way40_cell94 GND ML40 p1 W=2.4e-6 L=1e-6
mnway40_cell95 ML40 gate_way40_cell95 GND GND n1 W=1e-6 L=1e-6
mpway40_cell95 ML40 gate_way40_cell95 GND ML40 p1 W=2.4e-6 L=1e-6
mnway40_cell96 ML40 gate_way40_cell96 GND GND n1 W=1e-6 L=1e-6
mpway40_cell96 ML40 gate_way40_cell96 GND ML40 p1 W=2.4e-6 L=1e-6
mnway40_cell97 ML40 gate_way40_cell97 GND GND n1 W=1e-6 L=1e-6
mpway40_cell97 ML40 gate_way40_cell97 GND ML40 p1 W=2.4e-6 L=1e-6
mnway40_cell98 ML40 gate_way40_cell98 GND GND n1 W=1e-6 L=1e-6
mpway40_cell98 ML40 gate_way40_cell98 GND ML40 p1 W=2.4e-6 L=1e-6
mnway40_cell99 ML40 gate_way40_cell99 GND GND n1 W=1e-6 L=1e-6
mpway40_cell99 ML40 gate_way40_cell99 GND ML40 p1 W=2.4e-6 L=1e-6
mnway41_cell0 ML41 gate_way41_cell0 GND GND n1 W=1e-6 L=1e-6
mpway41_cell0 ML41 gate_way41_cell0 GND ML41 p1 W=2.4e-6 L=1e-6
mnway41_cell1 ML41 gate_way41_cell1 GND GND n1 W=1e-6 L=1e-6
mpway41_cell1 ML41 gate_way41_cell1 GND ML41 p1 W=2.4e-6 L=1e-6
mnway41_cell2 ML41 gate_way41_cell2 GND GND n1 W=1e-6 L=1e-6
mpway41_cell2 ML41 gate_way41_cell2 GND ML41 p1 W=2.4e-6 L=1e-6
mnway41_cell3 ML41 gate_way41_cell3 GND GND n1 W=1e-6 L=1e-6
mpway41_cell3 ML41 gate_way41_cell3 GND ML41 p1 W=2.4e-6 L=1e-6
mnway41_cell4 ML41 gate_way41_cell4 GND GND n1 W=1e-6 L=1e-6
mpway41_cell4 ML41 gate_way41_cell4 GND ML41 p1 W=2.4e-6 L=1e-6
mnway41_cell5 ML41 gate_way41_cell5 GND GND n1 W=1e-6 L=1e-6
mpway41_cell5 ML41 gate_way41_cell5 GND ML41 p1 W=2.4e-6 L=1e-6
mnway41_cell6 ML41 gate_way41_cell6 GND GND n1 W=1e-6 L=1e-6
mpway41_cell6 ML41 gate_way41_cell6 GND ML41 p1 W=2.4e-6 L=1e-6
mnway41_cell7 ML41 gate_way41_cell7 GND GND n1 W=1e-6 L=1e-6
mpway41_cell7 ML41 gate_way41_cell7 GND ML41 p1 W=2.4e-6 L=1e-6
mnway41_cell8 ML41 gate_way41_cell8 GND GND n1 W=1e-6 L=1e-6
mpway41_cell8 ML41 gate_way41_cell8 GND ML41 p1 W=2.4e-6 L=1e-6
mnway41_cell9 ML41 gate_way41_cell9 GND GND n1 W=1e-6 L=1e-6
mpway41_cell9 ML41 gate_way41_cell9 GND ML41 p1 W=2.4e-6 L=1e-6
mnway41_cell10 ML41 gate_way41_cell10 GND GND n1 W=1e-6 L=1e-6
mpway41_cell10 ML41 gate_way41_cell10 GND ML41 p1 W=2.4e-6 L=1e-6
mnway41_cell11 ML41 gate_way41_cell11 GND GND n1 W=1e-6 L=1e-6
mpway41_cell11 ML41 gate_way41_cell11 GND ML41 p1 W=2.4e-6 L=1e-6
mnway41_cell12 ML41 gate_way41_cell12 GND GND n1 W=1e-6 L=1e-6
mpway41_cell12 ML41 gate_way41_cell12 GND ML41 p1 W=2.4e-6 L=1e-6
mnway41_cell13 ML41 gate_way41_cell13 GND GND n1 W=1e-6 L=1e-6
mpway41_cell13 ML41 gate_way41_cell13 GND ML41 p1 W=2.4e-6 L=1e-6
mnway41_cell14 ML41 gate_way41_cell14 GND GND n1 W=1e-6 L=1e-6
mpway41_cell14 ML41 gate_way41_cell14 GND ML41 p1 W=2.4e-6 L=1e-6
mnway41_cell15 ML41 gate_way41_cell15 GND GND n1 W=1e-6 L=1e-6
mpway41_cell15 ML41 gate_way41_cell15 GND ML41 p1 W=2.4e-6 L=1e-6
mnway41_cell16 ML41 gate_way41_cell16 GND GND n1 W=1e-6 L=1e-6
mpway41_cell16 ML41 gate_way41_cell16 GND ML41 p1 W=2.4e-6 L=1e-6
mnway41_cell17 ML41 gate_way41_cell17 GND GND n1 W=1e-6 L=1e-6
mpway41_cell17 ML41 gate_way41_cell17 GND ML41 p1 W=2.4e-6 L=1e-6
mnway41_cell18 ML41 gate_way41_cell18 GND GND n1 W=1e-6 L=1e-6
mpway41_cell18 ML41 gate_way41_cell18 GND ML41 p1 W=2.4e-6 L=1e-6
mnway41_cell19 ML41 gate_way41_cell19 GND GND n1 W=1e-6 L=1e-6
mpway41_cell19 ML41 gate_way41_cell19 GND ML41 p1 W=2.4e-6 L=1e-6
mnway41_cell20 ML41 gate_way41_cell20 GND GND n1 W=1e-6 L=1e-6
mpway41_cell20 ML41 gate_way41_cell20 GND ML41 p1 W=2.4e-6 L=1e-6
mnway41_cell21 ML41 gate_way41_cell21 GND GND n1 W=1e-6 L=1e-6
mpway41_cell21 ML41 gate_way41_cell21 GND ML41 p1 W=2.4e-6 L=1e-6
mnway41_cell22 ML41 gate_way41_cell22 GND GND n1 W=1e-6 L=1e-6
mpway41_cell22 ML41 gate_way41_cell22 GND ML41 p1 W=2.4e-6 L=1e-6
mnway41_cell23 ML41 gate_way41_cell23 GND GND n1 W=1e-6 L=1e-6
mpway41_cell23 ML41 gate_way41_cell23 GND ML41 p1 W=2.4e-6 L=1e-6
mnway41_cell24 ML41 gate_way41_cell24 GND GND n1 W=1e-6 L=1e-6
mpway41_cell24 ML41 gate_way41_cell24 GND ML41 p1 W=2.4e-6 L=1e-6
mnway41_cell25 ML41 gate_way41_cell25 GND GND n1 W=1e-6 L=1e-6
mpway41_cell25 ML41 gate_way41_cell25 GND ML41 p1 W=2.4e-6 L=1e-6
mnway41_cell26 ML41 gate_way41_cell26 GND GND n1 W=1e-6 L=1e-6
mpway41_cell26 ML41 gate_way41_cell26 GND ML41 p1 W=2.4e-6 L=1e-6
mnway41_cell27 ML41 gate_way41_cell27 GND GND n1 W=1e-6 L=1e-6
mpway41_cell27 ML41 gate_way41_cell27 GND ML41 p1 W=2.4e-6 L=1e-6
mnway41_cell28 ML41 gate_way41_cell28 GND GND n1 W=1e-6 L=1e-6
mpway41_cell28 ML41 gate_way41_cell28 GND ML41 p1 W=2.4e-6 L=1e-6
mnway41_cell29 ML41 gate_way41_cell29 GND GND n1 W=1e-6 L=1e-6
mpway41_cell29 ML41 gate_way41_cell29 GND ML41 p1 W=2.4e-6 L=1e-6
mnway41_cell30 ML41 gate_way41_cell30 GND GND n1 W=1e-6 L=1e-6
mpway41_cell30 ML41 gate_way41_cell30 GND ML41 p1 W=2.4e-6 L=1e-6
mnway41_cell31 ML41 gate_way41_cell31 GND GND n1 W=1e-6 L=1e-6
mpway41_cell31 ML41 gate_way41_cell31 GND ML41 p1 W=2.4e-6 L=1e-6
mnway41_cell32 ML41 gate_way41_cell32 GND GND n1 W=1e-6 L=1e-6
mpway41_cell32 ML41 gate_way41_cell32 GND ML41 p1 W=2.4e-6 L=1e-6
mnway41_cell33 ML41 gate_way41_cell33 GND GND n1 W=1e-6 L=1e-6
mpway41_cell33 ML41 gate_way41_cell33 GND ML41 p1 W=2.4e-6 L=1e-6
mnway41_cell34 ML41 gate_way41_cell34 GND GND n1 W=1e-6 L=1e-6
mpway41_cell34 ML41 gate_way41_cell34 GND ML41 p1 W=2.4e-6 L=1e-6
mnway41_cell35 ML41 gate_way41_cell35 GND GND n1 W=1e-6 L=1e-6
mpway41_cell35 ML41 gate_way41_cell35 GND ML41 p1 W=2.4e-6 L=1e-6
mnway41_cell36 ML41 gate_way41_cell36 GND GND n1 W=1e-6 L=1e-6
mpway41_cell36 ML41 gate_way41_cell36 GND ML41 p1 W=2.4e-6 L=1e-6
mnway41_cell37 ML41 gate_way41_cell37 GND GND n1 W=1e-6 L=1e-6
mpway41_cell37 ML41 gate_way41_cell37 GND ML41 p1 W=2.4e-6 L=1e-6
mnway41_cell38 ML41 gate_way41_cell38 GND GND n1 W=1e-6 L=1e-6
mpway41_cell38 ML41 gate_way41_cell38 GND ML41 p1 W=2.4e-6 L=1e-6
mnway41_cell39 ML41 gate_way41_cell39 GND GND n1 W=1e-6 L=1e-6
mpway41_cell39 ML41 gate_way41_cell39 GND ML41 p1 W=2.4e-6 L=1e-6
mnway41_cell40 ML41 gate_way41_cell40 GND GND n1 W=1e-6 L=1e-6
mpway41_cell40 ML41 gate_way41_cell40 GND ML41 p1 W=2.4e-6 L=1e-6
mnway41_cell41 ML41 gate_way41_cell41 GND GND n1 W=1e-6 L=1e-6
mpway41_cell41 ML41 gate_way41_cell41 GND ML41 p1 W=2.4e-6 L=1e-6
mnway41_cell42 ML41 gate_way41_cell42 GND GND n1 W=1e-6 L=1e-6
mpway41_cell42 ML41 gate_way41_cell42 GND ML41 p1 W=2.4e-6 L=1e-6
mnway41_cell43 ML41 gate_way41_cell43 GND GND n1 W=1e-6 L=1e-6
mpway41_cell43 ML41 gate_way41_cell43 GND ML41 p1 W=2.4e-6 L=1e-6
mnway41_cell44 ML41 gate_way41_cell44 GND GND n1 W=1e-6 L=1e-6
mpway41_cell44 ML41 gate_way41_cell44 GND ML41 p1 W=2.4e-6 L=1e-6
mnway41_cell45 ML41 gate_way41_cell45 GND GND n1 W=1e-6 L=1e-6
mpway41_cell45 ML41 gate_way41_cell45 GND ML41 p1 W=2.4e-6 L=1e-6
mnway41_cell46 ML41 gate_way41_cell46 GND GND n1 W=1e-6 L=1e-6
mpway41_cell46 ML41 gate_way41_cell46 GND ML41 p1 W=2.4e-6 L=1e-6
mnway41_cell47 ML41 gate_way41_cell47 GND GND n1 W=1e-6 L=1e-6
mpway41_cell47 ML41 gate_way41_cell47 GND ML41 p1 W=2.4e-6 L=1e-6
mnway41_cell48 ML41 gate_way41_cell48 GND GND n1 W=1e-6 L=1e-6
mpway41_cell48 ML41 gate_way41_cell48 GND ML41 p1 W=2.4e-6 L=1e-6
mnway41_cell49 ML41 gate_way41_cell49 GND GND n1 W=1e-6 L=1e-6
mpway41_cell49 ML41 gate_way41_cell49 GND ML41 p1 W=2.4e-6 L=1e-6
mnway41_cell50 ML41 gate_way41_cell50 GND GND n1 W=1e-6 L=1e-6
mpway41_cell50 ML41 gate_way41_cell50 GND ML41 p1 W=2.4e-6 L=1e-6
mnway41_cell51 ML41 gate_way41_cell51 GND GND n1 W=1e-6 L=1e-6
mpway41_cell51 ML41 gate_way41_cell51 GND ML41 p1 W=2.4e-6 L=1e-6
mnway41_cell52 ML41 gate_way41_cell52 GND GND n1 W=1e-6 L=1e-6
mpway41_cell52 ML41 gate_way41_cell52 GND ML41 p1 W=2.4e-6 L=1e-6
mnway41_cell53 ML41 gate_way41_cell53 GND GND n1 W=1e-6 L=1e-6
mpway41_cell53 ML41 gate_way41_cell53 GND ML41 p1 W=2.4e-6 L=1e-6
mnway41_cell54 ML41 gate_way41_cell54 GND GND n1 W=1e-6 L=1e-6
mpway41_cell54 ML41 gate_way41_cell54 GND ML41 p1 W=2.4e-6 L=1e-6
mnway41_cell55 ML41 gate_way41_cell55 GND GND n1 W=1e-6 L=1e-6
mpway41_cell55 ML41 gate_way41_cell55 GND ML41 p1 W=2.4e-6 L=1e-6
mnway41_cell56 ML41 gate_way41_cell56 GND GND n1 W=1e-6 L=1e-6
mpway41_cell56 ML41 gate_way41_cell56 GND ML41 p1 W=2.4e-6 L=1e-6
mnway41_cell57 ML41 gate_way41_cell57 GND GND n1 W=1e-6 L=1e-6
mpway41_cell57 ML41 gate_way41_cell57 GND ML41 p1 W=2.4e-6 L=1e-6
mnway41_cell58 ML41 gate_way41_cell58 GND GND n1 W=1e-6 L=1e-6
mpway41_cell58 ML41 gate_way41_cell58 GND ML41 p1 W=2.4e-6 L=1e-6
mnway41_cell59 ML41 gate_way41_cell59 GND GND n1 W=1e-6 L=1e-6
mpway41_cell59 ML41 gate_way41_cell59 GND ML41 p1 W=2.4e-6 L=1e-6
mnway41_cell60 ML41 gate_way41_cell60 GND GND n1 W=1e-6 L=1e-6
mpway41_cell60 ML41 gate_way41_cell60 GND ML41 p1 W=2.4e-6 L=1e-6
mnway41_cell61 ML41 gate_way41_cell61 GND GND n1 W=1e-6 L=1e-6
mpway41_cell61 ML41 gate_way41_cell61 GND ML41 p1 W=2.4e-6 L=1e-6
mnway41_cell62 ML41 gate_way41_cell62 GND GND n1 W=1e-6 L=1e-6
mpway41_cell62 ML41 gate_way41_cell62 GND ML41 p1 W=2.4e-6 L=1e-6
mnway41_cell63 ML41 gate_way41_cell63 GND GND n1 W=1e-6 L=1e-6
mpway41_cell63 ML41 gate_way41_cell63 GND ML41 p1 W=2.4e-6 L=1e-6
mnway41_cell64 ML41 gate_way41_cell64 GND GND n1 W=1e-6 L=1e-6
mpway41_cell64 ML41 gate_way41_cell64 GND ML41 p1 W=2.4e-6 L=1e-6
mnway41_cell65 ML41 gate_way41_cell65 GND GND n1 W=1e-6 L=1e-6
mpway41_cell65 ML41 gate_way41_cell65 GND ML41 p1 W=2.4e-6 L=1e-6
mnway41_cell66 ML41 gate_way41_cell66 GND GND n1 W=1e-6 L=1e-6
mpway41_cell66 ML41 gate_way41_cell66 GND ML41 p1 W=2.4e-6 L=1e-6
mnway41_cell67 ML41 gate_way41_cell67 GND GND n1 W=1e-6 L=1e-6
mpway41_cell67 ML41 gate_way41_cell67 GND ML41 p1 W=2.4e-6 L=1e-6
mnway41_cell68 ML41 gate_way41_cell68 GND GND n1 W=1e-6 L=1e-6
mpway41_cell68 ML41 gate_way41_cell68 GND ML41 p1 W=2.4e-6 L=1e-6
mnway41_cell69 ML41 gate_way41_cell69 GND GND n1 W=1e-6 L=1e-6
mpway41_cell69 ML41 gate_way41_cell69 GND ML41 p1 W=2.4e-6 L=1e-6
mnway41_cell70 ML41 gate_way41_cell70 GND GND n1 W=1e-6 L=1e-6
mpway41_cell70 ML41 gate_way41_cell70 GND ML41 p1 W=2.4e-6 L=1e-6
mnway41_cell71 ML41 gate_way41_cell71 GND GND n1 W=1e-6 L=1e-6
mpway41_cell71 ML41 gate_way41_cell71 GND ML41 p1 W=2.4e-6 L=1e-6
mnway41_cell72 ML41 gate_way41_cell72 GND GND n1 W=1e-6 L=1e-6
mpway41_cell72 ML41 gate_way41_cell72 GND ML41 p1 W=2.4e-6 L=1e-6
mnway41_cell73 ML41 gate_way41_cell73 GND GND n1 W=1e-6 L=1e-6
mpway41_cell73 ML41 gate_way41_cell73 GND ML41 p1 W=2.4e-6 L=1e-6
mnway41_cell74 ML41 gate_way41_cell74 GND GND n1 W=1e-6 L=1e-6
mpway41_cell74 ML41 gate_way41_cell74 GND ML41 p1 W=2.4e-6 L=1e-6
mnway41_cell75 ML41 gate_way41_cell75 GND GND n1 W=1e-6 L=1e-6
mpway41_cell75 ML41 gate_way41_cell75 GND ML41 p1 W=2.4e-6 L=1e-6
mnway41_cell76 ML41 gate_way41_cell76 GND GND n1 W=1e-6 L=1e-6
mpway41_cell76 ML41 gate_way41_cell76 GND ML41 p1 W=2.4e-6 L=1e-6
mnway41_cell77 ML41 gate_way41_cell77 GND GND n1 W=1e-6 L=1e-6
mpway41_cell77 ML41 gate_way41_cell77 GND ML41 p1 W=2.4e-6 L=1e-6
mnway41_cell78 ML41 gate_way41_cell78 GND GND n1 W=1e-6 L=1e-6
mpway41_cell78 ML41 gate_way41_cell78 GND ML41 p1 W=2.4e-6 L=1e-6
mnway41_cell79 ML41 gate_way41_cell79 GND GND n1 W=1e-6 L=1e-6
mpway41_cell79 ML41 gate_way41_cell79 GND ML41 p1 W=2.4e-6 L=1e-6
mnway41_cell80 ML41 gate_way41_cell80 GND GND n1 W=1e-6 L=1e-6
mpway41_cell80 ML41 gate_way41_cell80 GND ML41 p1 W=2.4e-6 L=1e-6
mnway41_cell81 ML41 gate_way41_cell81 GND GND n1 W=1e-6 L=1e-6
mpway41_cell81 ML41 gate_way41_cell81 GND ML41 p1 W=2.4e-6 L=1e-6
mnway41_cell82 ML41 gate_way41_cell82 GND GND n1 W=1e-6 L=1e-6
mpway41_cell82 ML41 gate_way41_cell82 GND ML41 p1 W=2.4e-6 L=1e-6
mnway41_cell83 ML41 gate_way41_cell83 GND GND n1 W=1e-6 L=1e-6
mpway41_cell83 ML41 gate_way41_cell83 GND ML41 p1 W=2.4e-6 L=1e-6
mnway41_cell84 ML41 gate_way41_cell84 GND GND n1 W=1e-6 L=1e-6
mpway41_cell84 ML41 gate_way41_cell84 GND ML41 p1 W=2.4e-6 L=1e-6
mnway41_cell85 ML41 gate_way41_cell85 GND GND n1 W=1e-6 L=1e-6
mpway41_cell85 ML41 gate_way41_cell85 GND ML41 p1 W=2.4e-6 L=1e-6
mnway41_cell86 ML41 gate_way41_cell86 GND GND n1 W=1e-6 L=1e-6
mpway41_cell86 ML41 gate_way41_cell86 GND ML41 p1 W=2.4e-6 L=1e-6
mnway41_cell87 ML41 gate_way41_cell87 GND GND n1 W=1e-6 L=1e-6
mpway41_cell87 ML41 gate_way41_cell87 GND ML41 p1 W=2.4e-6 L=1e-6
mnway41_cell88 ML41 gate_way41_cell88 GND GND n1 W=1e-6 L=1e-6
mpway41_cell88 ML41 gate_way41_cell88 GND ML41 p1 W=2.4e-6 L=1e-6
mnway41_cell89 ML41 gate_way41_cell89 GND GND n1 W=1e-6 L=1e-6
mpway41_cell89 ML41 gate_way41_cell89 GND ML41 p1 W=2.4e-6 L=1e-6
mnway41_cell90 ML41 gate_way41_cell90 GND GND n1 W=1e-6 L=1e-6
mpway41_cell90 ML41 gate_way41_cell90 GND ML41 p1 W=2.4e-6 L=1e-6
mnway41_cell91 ML41 gate_way41_cell91 GND GND n1 W=1e-6 L=1e-6
mpway41_cell91 ML41 gate_way41_cell91 GND ML41 p1 W=2.4e-6 L=1e-6
mnway41_cell92 ML41 gate_way41_cell92 GND GND n1 W=1e-6 L=1e-6
mpway41_cell92 ML41 gate_way41_cell92 GND ML41 p1 W=2.4e-6 L=1e-6
mnway41_cell93 ML41 gate_way41_cell93 GND GND n1 W=1e-6 L=1e-6
mpway41_cell93 ML41 gate_way41_cell93 GND ML41 p1 W=2.4e-6 L=1e-6
mnway41_cell94 ML41 gate_way41_cell94 GND GND n1 W=1e-6 L=1e-6
mpway41_cell94 ML41 gate_way41_cell94 GND ML41 p1 W=2.4e-6 L=1e-6
mnway41_cell95 ML41 gate_way41_cell95 GND GND n1 W=1e-6 L=1e-6
mpway41_cell95 ML41 gate_way41_cell95 GND ML41 p1 W=2.4e-6 L=1e-6
mnway41_cell96 ML41 gate_way41_cell96 GND GND n1 W=1e-6 L=1e-6
mpway41_cell96 ML41 gate_way41_cell96 GND ML41 p1 W=2.4e-6 L=1e-6
mnway41_cell97 ML41 gate_way41_cell97 GND GND n1 W=1e-6 L=1e-6
mpway41_cell97 ML41 gate_way41_cell97 GND ML41 p1 W=2.4e-6 L=1e-6
mnway41_cell98 ML41 gate_way41_cell98 GND GND n1 W=1e-6 L=1e-6
mpway41_cell98 ML41 gate_way41_cell98 GND ML41 p1 W=2.4e-6 L=1e-6
mnway41_cell99 ML41 gate_way41_cell99 GND GND n1 W=1e-6 L=1e-6
mpway41_cell99 ML41 gate_way41_cell99 GND ML41 p1 W=2.4e-6 L=1e-6
mnway42_cell0 ML42 gate_way42_cell0 GND GND n1 W=1e-6 L=1e-6
mpway42_cell0 ML42 gate_way42_cell0 GND ML42 p1 W=2.4e-6 L=1e-6
mnway42_cell1 ML42 gate_way42_cell1 GND GND n1 W=1e-6 L=1e-6
mpway42_cell1 ML42 gate_way42_cell1 GND ML42 p1 W=2.4e-6 L=1e-6
mnway42_cell2 ML42 gate_way42_cell2 GND GND n1 W=1e-6 L=1e-6
mpway42_cell2 ML42 gate_way42_cell2 GND ML42 p1 W=2.4e-6 L=1e-6
mnway42_cell3 ML42 gate_way42_cell3 GND GND n1 W=1e-6 L=1e-6
mpway42_cell3 ML42 gate_way42_cell3 GND ML42 p1 W=2.4e-6 L=1e-6
mnway42_cell4 ML42 gate_way42_cell4 GND GND n1 W=1e-6 L=1e-6
mpway42_cell4 ML42 gate_way42_cell4 GND ML42 p1 W=2.4e-6 L=1e-6
mnway42_cell5 ML42 gate_way42_cell5 GND GND n1 W=1e-6 L=1e-6
mpway42_cell5 ML42 gate_way42_cell5 GND ML42 p1 W=2.4e-6 L=1e-6
mnway42_cell6 ML42 gate_way42_cell6 GND GND n1 W=1e-6 L=1e-6
mpway42_cell6 ML42 gate_way42_cell6 GND ML42 p1 W=2.4e-6 L=1e-6
mnway42_cell7 ML42 gate_way42_cell7 GND GND n1 W=1e-6 L=1e-6
mpway42_cell7 ML42 gate_way42_cell7 GND ML42 p1 W=2.4e-6 L=1e-6
mnway42_cell8 ML42 gate_way42_cell8 GND GND n1 W=1e-6 L=1e-6
mpway42_cell8 ML42 gate_way42_cell8 GND ML42 p1 W=2.4e-6 L=1e-6
mnway42_cell9 ML42 gate_way42_cell9 GND GND n1 W=1e-6 L=1e-6
mpway42_cell9 ML42 gate_way42_cell9 GND ML42 p1 W=2.4e-6 L=1e-6
mnway42_cell10 ML42 gate_way42_cell10 GND GND n1 W=1e-6 L=1e-6
mpway42_cell10 ML42 gate_way42_cell10 GND ML42 p1 W=2.4e-6 L=1e-6
mnway42_cell11 ML42 gate_way42_cell11 GND GND n1 W=1e-6 L=1e-6
mpway42_cell11 ML42 gate_way42_cell11 GND ML42 p1 W=2.4e-6 L=1e-6
mnway42_cell12 ML42 gate_way42_cell12 GND GND n1 W=1e-6 L=1e-6
mpway42_cell12 ML42 gate_way42_cell12 GND ML42 p1 W=2.4e-6 L=1e-6
mnway42_cell13 ML42 gate_way42_cell13 GND GND n1 W=1e-6 L=1e-6
mpway42_cell13 ML42 gate_way42_cell13 GND ML42 p1 W=2.4e-6 L=1e-6
mnway42_cell14 ML42 gate_way42_cell14 GND GND n1 W=1e-6 L=1e-6
mpway42_cell14 ML42 gate_way42_cell14 GND ML42 p1 W=2.4e-6 L=1e-6
mnway42_cell15 ML42 gate_way42_cell15 GND GND n1 W=1e-6 L=1e-6
mpway42_cell15 ML42 gate_way42_cell15 GND ML42 p1 W=2.4e-6 L=1e-6
mnway42_cell16 ML42 gate_way42_cell16 GND GND n1 W=1e-6 L=1e-6
mpway42_cell16 ML42 gate_way42_cell16 GND ML42 p1 W=2.4e-6 L=1e-6
mnway42_cell17 ML42 gate_way42_cell17 GND GND n1 W=1e-6 L=1e-6
mpway42_cell17 ML42 gate_way42_cell17 GND ML42 p1 W=2.4e-6 L=1e-6
mnway42_cell18 ML42 gate_way42_cell18 GND GND n1 W=1e-6 L=1e-6
mpway42_cell18 ML42 gate_way42_cell18 GND ML42 p1 W=2.4e-6 L=1e-6
mnway42_cell19 ML42 gate_way42_cell19 GND GND n1 W=1e-6 L=1e-6
mpway42_cell19 ML42 gate_way42_cell19 GND ML42 p1 W=2.4e-6 L=1e-6
mnway42_cell20 ML42 gate_way42_cell20 GND GND n1 W=1e-6 L=1e-6
mpway42_cell20 ML42 gate_way42_cell20 GND ML42 p1 W=2.4e-6 L=1e-6
mnway42_cell21 ML42 gate_way42_cell21 GND GND n1 W=1e-6 L=1e-6
mpway42_cell21 ML42 gate_way42_cell21 GND ML42 p1 W=2.4e-6 L=1e-6
mnway42_cell22 ML42 gate_way42_cell22 GND GND n1 W=1e-6 L=1e-6
mpway42_cell22 ML42 gate_way42_cell22 GND ML42 p1 W=2.4e-6 L=1e-6
mnway42_cell23 ML42 gate_way42_cell23 GND GND n1 W=1e-6 L=1e-6
mpway42_cell23 ML42 gate_way42_cell23 GND ML42 p1 W=2.4e-6 L=1e-6
mnway42_cell24 ML42 gate_way42_cell24 GND GND n1 W=1e-6 L=1e-6
mpway42_cell24 ML42 gate_way42_cell24 GND ML42 p1 W=2.4e-6 L=1e-6
mnway42_cell25 ML42 gate_way42_cell25 GND GND n1 W=1e-6 L=1e-6
mpway42_cell25 ML42 gate_way42_cell25 GND ML42 p1 W=2.4e-6 L=1e-6
mnway42_cell26 ML42 gate_way42_cell26 GND GND n1 W=1e-6 L=1e-6
mpway42_cell26 ML42 gate_way42_cell26 GND ML42 p1 W=2.4e-6 L=1e-6
mnway42_cell27 ML42 gate_way42_cell27 GND GND n1 W=1e-6 L=1e-6
mpway42_cell27 ML42 gate_way42_cell27 GND ML42 p1 W=2.4e-6 L=1e-6
mnway42_cell28 ML42 gate_way42_cell28 GND GND n1 W=1e-6 L=1e-6
mpway42_cell28 ML42 gate_way42_cell28 GND ML42 p1 W=2.4e-6 L=1e-6
mnway42_cell29 ML42 gate_way42_cell29 GND GND n1 W=1e-6 L=1e-6
mpway42_cell29 ML42 gate_way42_cell29 GND ML42 p1 W=2.4e-6 L=1e-6
mnway42_cell30 ML42 gate_way42_cell30 GND GND n1 W=1e-6 L=1e-6
mpway42_cell30 ML42 gate_way42_cell30 GND ML42 p1 W=2.4e-6 L=1e-6
mnway42_cell31 ML42 gate_way42_cell31 GND GND n1 W=1e-6 L=1e-6
mpway42_cell31 ML42 gate_way42_cell31 GND ML42 p1 W=2.4e-6 L=1e-6
mnway42_cell32 ML42 gate_way42_cell32 GND GND n1 W=1e-6 L=1e-6
mpway42_cell32 ML42 gate_way42_cell32 GND ML42 p1 W=2.4e-6 L=1e-6
mnway42_cell33 ML42 gate_way42_cell33 GND GND n1 W=1e-6 L=1e-6
mpway42_cell33 ML42 gate_way42_cell33 GND ML42 p1 W=2.4e-6 L=1e-6
mnway42_cell34 ML42 gate_way42_cell34 GND GND n1 W=1e-6 L=1e-6
mpway42_cell34 ML42 gate_way42_cell34 GND ML42 p1 W=2.4e-6 L=1e-6
mnway42_cell35 ML42 gate_way42_cell35 GND GND n1 W=1e-6 L=1e-6
mpway42_cell35 ML42 gate_way42_cell35 GND ML42 p1 W=2.4e-6 L=1e-6
mnway42_cell36 ML42 gate_way42_cell36 GND GND n1 W=1e-6 L=1e-6
mpway42_cell36 ML42 gate_way42_cell36 GND ML42 p1 W=2.4e-6 L=1e-6
mnway42_cell37 ML42 gate_way42_cell37 GND GND n1 W=1e-6 L=1e-6
mpway42_cell37 ML42 gate_way42_cell37 GND ML42 p1 W=2.4e-6 L=1e-6
mnway42_cell38 ML42 gate_way42_cell38 GND GND n1 W=1e-6 L=1e-6
mpway42_cell38 ML42 gate_way42_cell38 GND ML42 p1 W=2.4e-6 L=1e-6
mnway42_cell39 ML42 gate_way42_cell39 GND GND n1 W=1e-6 L=1e-6
mpway42_cell39 ML42 gate_way42_cell39 GND ML42 p1 W=2.4e-6 L=1e-6
mnway42_cell40 ML42 gate_way42_cell40 GND GND n1 W=1e-6 L=1e-6
mpway42_cell40 ML42 gate_way42_cell40 GND ML42 p1 W=2.4e-6 L=1e-6
mnway42_cell41 ML42 gate_way42_cell41 GND GND n1 W=1e-6 L=1e-6
mpway42_cell41 ML42 gate_way42_cell41 GND ML42 p1 W=2.4e-6 L=1e-6
mnway42_cell42 ML42 gate_way42_cell42 GND GND n1 W=1e-6 L=1e-6
mpway42_cell42 ML42 gate_way42_cell42 GND ML42 p1 W=2.4e-6 L=1e-6
mnway42_cell43 ML42 gate_way42_cell43 GND GND n1 W=1e-6 L=1e-6
mpway42_cell43 ML42 gate_way42_cell43 GND ML42 p1 W=2.4e-6 L=1e-6
mnway42_cell44 ML42 gate_way42_cell44 GND GND n1 W=1e-6 L=1e-6
mpway42_cell44 ML42 gate_way42_cell44 GND ML42 p1 W=2.4e-6 L=1e-6
mnway42_cell45 ML42 gate_way42_cell45 GND GND n1 W=1e-6 L=1e-6
mpway42_cell45 ML42 gate_way42_cell45 GND ML42 p1 W=2.4e-6 L=1e-6
mnway42_cell46 ML42 gate_way42_cell46 GND GND n1 W=1e-6 L=1e-6
mpway42_cell46 ML42 gate_way42_cell46 GND ML42 p1 W=2.4e-6 L=1e-6
mnway42_cell47 ML42 gate_way42_cell47 GND GND n1 W=1e-6 L=1e-6
mpway42_cell47 ML42 gate_way42_cell47 GND ML42 p1 W=2.4e-6 L=1e-6
mnway42_cell48 ML42 gate_way42_cell48 GND GND n1 W=1e-6 L=1e-6
mpway42_cell48 ML42 gate_way42_cell48 GND ML42 p1 W=2.4e-6 L=1e-6
mnway42_cell49 ML42 gate_way42_cell49 GND GND n1 W=1e-6 L=1e-6
mpway42_cell49 ML42 gate_way42_cell49 GND ML42 p1 W=2.4e-6 L=1e-6
mnway42_cell50 ML42 gate_way42_cell50 GND GND n1 W=1e-6 L=1e-6
mpway42_cell50 ML42 gate_way42_cell50 GND ML42 p1 W=2.4e-6 L=1e-6
mnway42_cell51 ML42 gate_way42_cell51 GND GND n1 W=1e-6 L=1e-6
mpway42_cell51 ML42 gate_way42_cell51 GND ML42 p1 W=2.4e-6 L=1e-6
mnway42_cell52 ML42 gate_way42_cell52 GND GND n1 W=1e-6 L=1e-6
mpway42_cell52 ML42 gate_way42_cell52 GND ML42 p1 W=2.4e-6 L=1e-6
mnway42_cell53 ML42 gate_way42_cell53 GND GND n1 W=1e-6 L=1e-6
mpway42_cell53 ML42 gate_way42_cell53 GND ML42 p1 W=2.4e-6 L=1e-6
mnway42_cell54 ML42 gate_way42_cell54 GND GND n1 W=1e-6 L=1e-6
mpway42_cell54 ML42 gate_way42_cell54 GND ML42 p1 W=2.4e-6 L=1e-6
mnway42_cell55 ML42 gate_way42_cell55 GND GND n1 W=1e-6 L=1e-6
mpway42_cell55 ML42 gate_way42_cell55 GND ML42 p1 W=2.4e-6 L=1e-6
mnway42_cell56 ML42 gate_way42_cell56 GND GND n1 W=1e-6 L=1e-6
mpway42_cell56 ML42 gate_way42_cell56 GND ML42 p1 W=2.4e-6 L=1e-6
mnway42_cell57 ML42 gate_way42_cell57 GND GND n1 W=1e-6 L=1e-6
mpway42_cell57 ML42 gate_way42_cell57 GND ML42 p1 W=2.4e-6 L=1e-6
mnway42_cell58 ML42 gate_way42_cell58 GND GND n1 W=1e-6 L=1e-6
mpway42_cell58 ML42 gate_way42_cell58 GND ML42 p1 W=2.4e-6 L=1e-6
mnway42_cell59 ML42 gate_way42_cell59 GND GND n1 W=1e-6 L=1e-6
mpway42_cell59 ML42 gate_way42_cell59 GND ML42 p1 W=2.4e-6 L=1e-6
mnway42_cell60 ML42 gate_way42_cell60 GND GND n1 W=1e-6 L=1e-6
mpway42_cell60 ML42 gate_way42_cell60 GND ML42 p1 W=2.4e-6 L=1e-6
mnway42_cell61 ML42 gate_way42_cell61 GND GND n1 W=1e-6 L=1e-6
mpway42_cell61 ML42 gate_way42_cell61 GND ML42 p1 W=2.4e-6 L=1e-6
mnway42_cell62 ML42 gate_way42_cell62 GND GND n1 W=1e-6 L=1e-6
mpway42_cell62 ML42 gate_way42_cell62 GND ML42 p1 W=2.4e-6 L=1e-6
mnway42_cell63 ML42 gate_way42_cell63 GND GND n1 W=1e-6 L=1e-6
mpway42_cell63 ML42 gate_way42_cell63 GND ML42 p1 W=2.4e-6 L=1e-6
mnway42_cell64 ML42 gate_way42_cell64 GND GND n1 W=1e-6 L=1e-6
mpway42_cell64 ML42 gate_way42_cell64 GND ML42 p1 W=2.4e-6 L=1e-6
mnway42_cell65 ML42 gate_way42_cell65 GND GND n1 W=1e-6 L=1e-6
mpway42_cell65 ML42 gate_way42_cell65 GND ML42 p1 W=2.4e-6 L=1e-6
mnway42_cell66 ML42 gate_way42_cell66 GND GND n1 W=1e-6 L=1e-6
mpway42_cell66 ML42 gate_way42_cell66 GND ML42 p1 W=2.4e-6 L=1e-6
mnway42_cell67 ML42 gate_way42_cell67 GND GND n1 W=1e-6 L=1e-6
mpway42_cell67 ML42 gate_way42_cell67 GND ML42 p1 W=2.4e-6 L=1e-6
mnway42_cell68 ML42 gate_way42_cell68 GND GND n1 W=1e-6 L=1e-6
mpway42_cell68 ML42 gate_way42_cell68 GND ML42 p1 W=2.4e-6 L=1e-6
mnway42_cell69 ML42 gate_way42_cell69 GND GND n1 W=1e-6 L=1e-6
mpway42_cell69 ML42 gate_way42_cell69 GND ML42 p1 W=2.4e-6 L=1e-6
mnway42_cell70 ML42 gate_way42_cell70 GND GND n1 W=1e-6 L=1e-6
mpway42_cell70 ML42 gate_way42_cell70 GND ML42 p1 W=2.4e-6 L=1e-6
mnway42_cell71 ML42 gate_way42_cell71 GND GND n1 W=1e-6 L=1e-6
mpway42_cell71 ML42 gate_way42_cell71 GND ML42 p1 W=2.4e-6 L=1e-6
mnway42_cell72 ML42 gate_way42_cell72 GND GND n1 W=1e-6 L=1e-6
mpway42_cell72 ML42 gate_way42_cell72 GND ML42 p1 W=2.4e-6 L=1e-6
mnway42_cell73 ML42 gate_way42_cell73 GND GND n1 W=1e-6 L=1e-6
mpway42_cell73 ML42 gate_way42_cell73 GND ML42 p1 W=2.4e-6 L=1e-6
mnway42_cell74 ML42 gate_way42_cell74 GND GND n1 W=1e-6 L=1e-6
mpway42_cell74 ML42 gate_way42_cell74 GND ML42 p1 W=2.4e-6 L=1e-6
mnway42_cell75 ML42 gate_way42_cell75 GND GND n1 W=1e-6 L=1e-6
mpway42_cell75 ML42 gate_way42_cell75 GND ML42 p1 W=2.4e-6 L=1e-6
mnway42_cell76 ML42 gate_way42_cell76 GND GND n1 W=1e-6 L=1e-6
mpway42_cell76 ML42 gate_way42_cell76 GND ML42 p1 W=2.4e-6 L=1e-6
mnway42_cell77 ML42 gate_way42_cell77 GND GND n1 W=1e-6 L=1e-6
mpway42_cell77 ML42 gate_way42_cell77 GND ML42 p1 W=2.4e-6 L=1e-6
mnway42_cell78 ML42 gate_way42_cell78 GND GND n1 W=1e-6 L=1e-6
mpway42_cell78 ML42 gate_way42_cell78 GND ML42 p1 W=2.4e-6 L=1e-6
mnway42_cell79 ML42 gate_way42_cell79 GND GND n1 W=1e-6 L=1e-6
mpway42_cell79 ML42 gate_way42_cell79 GND ML42 p1 W=2.4e-6 L=1e-6
mnway42_cell80 ML42 gate_way42_cell80 GND GND n1 W=1e-6 L=1e-6
mpway42_cell80 ML42 gate_way42_cell80 GND ML42 p1 W=2.4e-6 L=1e-6
mnway42_cell81 ML42 gate_way42_cell81 GND GND n1 W=1e-6 L=1e-6
mpway42_cell81 ML42 gate_way42_cell81 GND ML42 p1 W=2.4e-6 L=1e-6
mnway42_cell82 ML42 gate_way42_cell82 GND GND n1 W=1e-6 L=1e-6
mpway42_cell82 ML42 gate_way42_cell82 GND ML42 p1 W=2.4e-6 L=1e-6
mnway42_cell83 ML42 gate_way42_cell83 GND GND n1 W=1e-6 L=1e-6
mpway42_cell83 ML42 gate_way42_cell83 GND ML42 p1 W=2.4e-6 L=1e-6
mnway42_cell84 ML42 gate_way42_cell84 GND GND n1 W=1e-6 L=1e-6
mpway42_cell84 ML42 gate_way42_cell84 GND ML42 p1 W=2.4e-6 L=1e-6
mnway42_cell85 ML42 gate_way42_cell85 GND GND n1 W=1e-6 L=1e-6
mpway42_cell85 ML42 gate_way42_cell85 GND ML42 p1 W=2.4e-6 L=1e-6
mnway42_cell86 ML42 gate_way42_cell86 GND GND n1 W=1e-6 L=1e-6
mpway42_cell86 ML42 gate_way42_cell86 GND ML42 p1 W=2.4e-6 L=1e-6
mnway42_cell87 ML42 gate_way42_cell87 GND GND n1 W=1e-6 L=1e-6
mpway42_cell87 ML42 gate_way42_cell87 GND ML42 p1 W=2.4e-6 L=1e-6
mnway42_cell88 ML42 gate_way42_cell88 GND GND n1 W=1e-6 L=1e-6
mpway42_cell88 ML42 gate_way42_cell88 GND ML42 p1 W=2.4e-6 L=1e-6
mnway42_cell89 ML42 gate_way42_cell89 GND GND n1 W=1e-6 L=1e-6
mpway42_cell89 ML42 gate_way42_cell89 GND ML42 p1 W=2.4e-6 L=1e-6
mnway42_cell90 ML42 gate_way42_cell90 GND GND n1 W=1e-6 L=1e-6
mpway42_cell90 ML42 gate_way42_cell90 GND ML42 p1 W=2.4e-6 L=1e-6
mnway42_cell91 ML42 gate_way42_cell91 GND GND n1 W=1e-6 L=1e-6
mpway42_cell91 ML42 gate_way42_cell91 GND ML42 p1 W=2.4e-6 L=1e-6
mnway42_cell92 ML42 gate_way42_cell92 GND GND n1 W=1e-6 L=1e-6
mpway42_cell92 ML42 gate_way42_cell92 GND ML42 p1 W=2.4e-6 L=1e-6
mnway42_cell93 ML42 gate_way42_cell93 GND GND n1 W=1e-6 L=1e-6
mpway42_cell93 ML42 gate_way42_cell93 GND ML42 p1 W=2.4e-6 L=1e-6
mnway42_cell94 ML42 gate_way42_cell94 GND GND n1 W=1e-6 L=1e-6
mpway42_cell94 ML42 gate_way42_cell94 GND ML42 p1 W=2.4e-6 L=1e-6
mnway42_cell95 ML42 gate_way42_cell95 GND GND n1 W=1e-6 L=1e-6
mpway42_cell95 ML42 gate_way42_cell95 GND ML42 p1 W=2.4e-6 L=1e-6
mnway42_cell96 ML42 gate_way42_cell96 GND GND n1 W=1e-6 L=1e-6
mpway42_cell96 ML42 gate_way42_cell96 GND ML42 p1 W=2.4e-6 L=1e-6
mnway42_cell97 ML42 gate_way42_cell97 GND GND n1 W=1e-6 L=1e-6
mpway42_cell97 ML42 gate_way42_cell97 GND ML42 p1 W=2.4e-6 L=1e-6
mnway42_cell98 ML42 gate_way42_cell98 GND GND n1 W=1e-6 L=1e-6
mpway42_cell98 ML42 gate_way42_cell98 GND ML42 p1 W=2.4e-6 L=1e-6
mnway42_cell99 ML42 gate_way42_cell99 GND GND n1 W=1e-6 L=1e-6
mpway42_cell99 ML42 gate_way42_cell99 GND ML42 p1 W=2.4e-6 L=1e-6
mnway43_cell0 ML43 gate_way43_cell0 GND GND n1 W=1e-6 L=1e-6
mpway43_cell0 ML43 gate_way43_cell0 GND ML43 p1 W=2.4e-6 L=1e-6
mnway43_cell1 ML43 gate_way43_cell1 GND GND n1 W=1e-6 L=1e-6
mpway43_cell1 ML43 gate_way43_cell1 GND ML43 p1 W=2.4e-6 L=1e-6
mnway43_cell2 ML43 gate_way43_cell2 GND GND n1 W=1e-6 L=1e-6
mpway43_cell2 ML43 gate_way43_cell2 GND ML43 p1 W=2.4e-6 L=1e-6
mnway43_cell3 ML43 gate_way43_cell3 GND GND n1 W=1e-6 L=1e-6
mpway43_cell3 ML43 gate_way43_cell3 GND ML43 p1 W=2.4e-6 L=1e-6
mnway43_cell4 ML43 gate_way43_cell4 GND GND n1 W=1e-6 L=1e-6
mpway43_cell4 ML43 gate_way43_cell4 GND ML43 p1 W=2.4e-6 L=1e-6
mnway43_cell5 ML43 gate_way43_cell5 GND GND n1 W=1e-6 L=1e-6
mpway43_cell5 ML43 gate_way43_cell5 GND ML43 p1 W=2.4e-6 L=1e-6
mnway43_cell6 ML43 gate_way43_cell6 GND GND n1 W=1e-6 L=1e-6
mpway43_cell6 ML43 gate_way43_cell6 GND ML43 p1 W=2.4e-6 L=1e-6
mnway43_cell7 ML43 gate_way43_cell7 GND GND n1 W=1e-6 L=1e-6
mpway43_cell7 ML43 gate_way43_cell7 GND ML43 p1 W=2.4e-6 L=1e-6
mnway43_cell8 ML43 gate_way43_cell8 GND GND n1 W=1e-6 L=1e-6
mpway43_cell8 ML43 gate_way43_cell8 GND ML43 p1 W=2.4e-6 L=1e-6
mnway43_cell9 ML43 gate_way43_cell9 GND GND n1 W=1e-6 L=1e-6
mpway43_cell9 ML43 gate_way43_cell9 GND ML43 p1 W=2.4e-6 L=1e-6
mnway43_cell10 ML43 gate_way43_cell10 GND GND n1 W=1e-6 L=1e-6
mpway43_cell10 ML43 gate_way43_cell10 GND ML43 p1 W=2.4e-6 L=1e-6
mnway43_cell11 ML43 gate_way43_cell11 GND GND n1 W=1e-6 L=1e-6
mpway43_cell11 ML43 gate_way43_cell11 GND ML43 p1 W=2.4e-6 L=1e-6
mnway43_cell12 ML43 gate_way43_cell12 GND GND n1 W=1e-6 L=1e-6
mpway43_cell12 ML43 gate_way43_cell12 GND ML43 p1 W=2.4e-6 L=1e-6
mnway43_cell13 ML43 gate_way43_cell13 GND GND n1 W=1e-6 L=1e-6
mpway43_cell13 ML43 gate_way43_cell13 GND ML43 p1 W=2.4e-6 L=1e-6
mnway43_cell14 ML43 gate_way43_cell14 GND GND n1 W=1e-6 L=1e-6
mpway43_cell14 ML43 gate_way43_cell14 GND ML43 p1 W=2.4e-6 L=1e-6
mnway43_cell15 ML43 gate_way43_cell15 GND GND n1 W=1e-6 L=1e-6
mpway43_cell15 ML43 gate_way43_cell15 GND ML43 p1 W=2.4e-6 L=1e-6
mnway43_cell16 ML43 gate_way43_cell16 GND GND n1 W=1e-6 L=1e-6
mpway43_cell16 ML43 gate_way43_cell16 GND ML43 p1 W=2.4e-6 L=1e-6
mnway43_cell17 ML43 gate_way43_cell17 GND GND n1 W=1e-6 L=1e-6
mpway43_cell17 ML43 gate_way43_cell17 GND ML43 p1 W=2.4e-6 L=1e-6
mnway43_cell18 ML43 gate_way43_cell18 GND GND n1 W=1e-6 L=1e-6
mpway43_cell18 ML43 gate_way43_cell18 GND ML43 p1 W=2.4e-6 L=1e-6
mnway43_cell19 ML43 gate_way43_cell19 GND GND n1 W=1e-6 L=1e-6
mpway43_cell19 ML43 gate_way43_cell19 GND ML43 p1 W=2.4e-6 L=1e-6
mnway43_cell20 ML43 gate_way43_cell20 GND GND n1 W=1e-6 L=1e-6
mpway43_cell20 ML43 gate_way43_cell20 GND ML43 p1 W=2.4e-6 L=1e-6
mnway43_cell21 ML43 gate_way43_cell21 GND GND n1 W=1e-6 L=1e-6
mpway43_cell21 ML43 gate_way43_cell21 GND ML43 p1 W=2.4e-6 L=1e-6
mnway43_cell22 ML43 gate_way43_cell22 GND GND n1 W=1e-6 L=1e-6
mpway43_cell22 ML43 gate_way43_cell22 GND ML43 p1 W=2.4e-6 L=1e-6
mnway43_cell23 ML43 gate_way43_cell23 GND GND n1 W=1e-6 L=1e-6
mpway43_cell23 ML43 gate_way43_cell23 GND ML43 p1 W=2.4e-6 L=1e-6
mnway43_cell24 ML43 gate_way43_cell24 GND GND n1 W=1e-6 L=1e-6
mpway43_cell24 ML43 gate_way43_cell24 GND ML43 p1 W=2.4e-6 L=1e-6
mnway43_cell25 ML43 gate_way43_cell25 GND GND n1 W=1e-6 L=1e-6
mpway43_cell25 ML43 gate_way43_cell25 GND ML43 p1 W=2.4e-6 L=1e-6
mnway43_cell26 ML43 gate_way43_cell26 GND GND n1 W=1e-6 L=1e-6
mpway43_cell26 ML43 gate_way43_cell26 GND ML43 p1 W=2.4e-6 L=1e-6
mnway43_cell27 ML43 gate_way43_cell27 GND GND n1 W=1e-6 L=1e-6
mpway43_cell27 ML43 gate_way43_cell27 GND ML43 p1 W=2.4e-6 L=1e-6
mnway43_cell28 ML43 gate_way43_cell28 GND GND n1 W=1e-6 L=1e-6
mpway43_cell28 ML43 gate_way43_cell28 GND ML43 p1 W=2.4e-6 L=1e-6
mnway43_cell29 ML43 gate_way43_cell29 GND GND n1 W=1e-6 L=1e-6
mpway43_cell29 ML43 gate_way43_cell29 GND ML43 p1 W=2.4e-6 L=1e-6
mnway43_cell30 ML43 gate_way43_cell30 GND GND n1 W=1e-6 L=1e-6
mpway43_cell30 ML43 gate_way43_cell30 GND ML43 p1 W=2.4e-6 L=1e-6
mnway43_cell31 ML43 gate_way43_cell31 GND GND n1 W=1e-6 L=1e-6
mpway43_cell31 ML43 gate_way43_cell31 GND ML43 p1 W=2.4e-6 L=1e-6
mnway43_cell32 ML43 gate_way43_cell32 GND GND n1 W=1e-6 L=1e-6
mpway43_cell32 ML43 gate_way43_cell32 GND ML43 p1 W=2.4e-6 L=1e-6
mnway43_cell33 ML43 gate_way43_cell33 GND GND n1 W=1e-6 L=1e-6
mpway43_cell33 ML43 gate_way43_cell33 GND ML43 p1 W=2.4e-6 L=1e-6
mnway43_cell34 ML43 gate_way43_cell34 GND GND n1 W=1e-6 L=1e-6
mpway43_cell34 ML43 gate_way43_cell34 GND ML43 p1 W=2.4e-6 L=1e-6
mnway43_cell35 ML43 gate_way43_cell35 GND GND n1 W=1e-6 L=1e-6
mpway43_cell35 ML43 gate_way43_cell35 GND ML43 p1 W=2.4e-6 L=1e-6
mnway43_cell36 ML43 gate_way43_cell36 GND GND n1 W=1e-6 L=1e-6
mpway43_cell36 ML43 gate_way43_cell36 GND ML43 p1 W=2.4e-6 L=1e-6
mnway43_cell37 ML43 gate_way43_cell37 GND GND n1 W=1e-6 L=1e-6
mpway43_cell37 ML43 gate_way43_cell37 GND ML43 p1 W=2.4e-6 L=1e-6
mnway43_cell38 ML43 gate_way43_cell38 GND GND n1 W=1e-6 L=1e-6
mpway43_cell38 ML43 gate_way43_cell38 GND ML43 p1 W=2.4e-6 L=1e-6
mnway43_cell39 ML43 gate_way43_cell39 GND GND n1 W=1e-6 L=1e-6
mpway43_cell39 ML43 gate_way43_cell39 GND ML43 p1 W=2.4e-6 L=1e-6
mnway43_cell40 ML43 gate_way43_cell40 GND GND n1 W=1e-6 L=1e-6
mpway43_cell40 ML43 gate_way43_cell40 GND ML43 p1 W=2.4e-6 L=1e-6
mnway43_cell41 ML43 gate_way43_cell41 GND GND n1 W=1e-6 L=1e-6
mpway43_cell41 ML43 gate_way43_cell41 GND ML43 p1 W=2.4e-6 L=1e-6
mnway43_cell42 ML43 gate_way43_cell42 GND GND n1 W=1e-6 L=1e-6
mpway43_cell42 ML43 gate_way43_cell42 GND ML43 p1 W=2.4e-6 L=1e-6
mnway43_cell43 ML43 gate_way43_cell43 GND GND n1 W=1e-6 L=1e-6
mpway43_cell43 ML43 gate_way43_cell43 GND ML43 p1 W=2.4e-6 L=1e-6
mnway43_cell44 ML43 gate_way43_cell44 GND GND n1 W=1e-6 L=1e-6
mpway43_cell44 ML43 gate_way43_cell44 GND ML43 p1 W=2.4e-6 L=1e-6
mnway43_cell45 ML43 gate_way43_cell45 GND GND n1 W=1e-6 L=1e-6
mpway43_cell45 ML43 gate_way43_cell45 GND ML43 p1 W=2.4e-6 L=1e-6
mnway43_cell46 ML43 gate_way43_cell46 GND GND n1 W=1e-6 L=1e-6
mpway43_cell46 ML43 gate_way43_cell46 GND ML43 p1 W=2.4e-6 L=1e-6
mnway43_cell47 ML43 gate_way43_cell47 GND GND n1 W=1e-6 L=1e-6
mpway43_cell47 ML43 gate_way43_cell47 GND ML43 p1 W=2.4e-6 L=1e-6
mnway43_cell48 ML43 gate_way43_cell48 GND GND n1 W=1e-6 L=1e-6
mpway43_cell48 ML43 gate_way43_cell48 GND ML43 p1 W=2.4e-6 L=1e-6
mnway43_cell49 ML43 gate_way43_cell49 GND GND n1 W=1e-6 L=1e-6
mpway43_cell49 ML43 gate_way43_cell49 GND ML43 p1 W=2.4e-6 L=1e-6
mnway43_cell50 ML43 gate_way43_cell50 GND GND n1 W=1e-6 L=1e-6
mpway43_cell50 ML43 gate_way43_cell50 GND ML43 p1 W=2.4e-6 L=1e-6
mnway43_cell51 ML43 gate_way43_cell51 GND GND n1 W=1e-6 L=1e-6
mpway43_cell51 ML43 gate_way43_cell51 GND ML43 p1 W=2.4e-6 L=1e-6
mnway43_cell52 ML43 gate_way43_cell52 GND GND n1 W=1e-6 L=1e-6
mpway43_cell52 ML43 gate_way43_cell52 GND ML43 p1 W=2.4e-6 L=1e-6
mnway43_cell53 ML43 gate_way43_cell53 GND GND n1 W=1e-6 L=1e-6
mpway43_cell53 ML43 gate_way43_cell53 GND ML43 p1 W=2.4e-6 L=1e-6
mnway43_cell54 ML43 gate_way43_cell54 GND GND n1 W=1e-6 L=1e-6
mpway43_cell54 ML43 gate_way43_cell54 GND ML43 p1 W=2.4e-6 L=1e-6
mnway43_cell55 ML43 gate_way43_cell55 GND GND n1 W=1e-6 L=1e-6
mpway43_cell55 ML43 gate_way43_cell55 GND ML43 p1 W=2.4e-6 L=1e-6
mnway43_cell56 ML43 gate_way43_cell56 GND GND n1 W=1e-6 L=1e-6
mpway43_cell56 ML43 gate_way43_cell56 GND ML43 p1 W=2.4e-6 L=1e-6
mnway43_cell57 ML43 gate_way43_cell57 GND GND n1 W=1e-6 L=1e-6
mpway43_cell57 ML43 gate_way43_cell57 GND ML43 p1 W=2.4e-6 L=1e-6
mnway43_cell58 ML43 gate_way43_cell58 GND GND n1 W=1e-6 L=1e-6
mpway43_cell58 ML43 gate_way43_cell58 GND ML43 p1 W=2.4e-6 L=1e-6
mnway43_cell59 ML43 gate_way43_cell59 GND GND n1 W=1e-6 L=1e-6
mpway43_cell59 ML43 gate_way43_cell59 GND ML43 p1 W=2.4e-6 L=1e-6
mnway43_cell60 ML43 gate_way43_cell60 GND GND n1 W=1e-6 L=1e-6
mpway43_cell60 ML43 gate_way43_cell60 GND ML43 p1 W=2.4e-6 L=1e-6
mnway43_cell61 ML43 gate_way43_cell61 GND GND n1 W=1e-6 L=1e-6
mpway43_cell61 ML43 gate_way43_cell61 GND ML43 p1 W=2.4e-6 L=1e-6
mnway43_cell62 ML43 gate_way43_cell62 GND GND n1 W=1e-6 L=1e-6
mpway43_cell62 ML43 gate_way43_cell62 GND ML43 p1 W=2.4e-6 L=1e-6
mnway43_cell63 ML43 gate_way43_cell63 GND GND n1 W=1e-6 L=1e-6
mpway43_cell63 ML43 gate_way43_cell63 GND ML43 p1 W=2.4e-6 L=1e-6
mnway43_cell64 ML43 gate_way43_cell64 GND GND n1 W=1e-6 L=1e-6
mpway43_cell64 ML43 gate_way43_cell64 GND ML43 p1 W=2.4e-6 L=1e-6
mnway43_cell65 ML43 gate_way43_cell65 GND GND n1 W=1e-6 L=1e-6
mpway43_cell65 ML43 gate_way43_cell65 GND ML43 p1 W=2.4e-6 L=1e-6
mnway43_cell66 ML43 gate_way43_cell66 GND GND n1 W=1e-6 L=1e-6
mpway43_cell66 ML43 gate_way43_cell66 GND ML43 p1 W=2.4e-6 L=1e-6
mnway43_cell67 ML43 gate_way43_cell67 GND GND n1 W=1e-6 L=1e-6
mpway43_cell67 ML43 gate_way43_cell67 GND ML43 p1 W=2.4e-6 L=1e-6
mnway43_cell68 ML43 gate_way43_cell68 GND GND n1 W=1e-6 L=1e-6
mpway43_cell68 ML43 gate_way43_cell68 GND ML43 p1 W=2.4e-6 L=1e-6
mnway43_cell69 ML43 gate_way43_cell69 GND GND n1 W=1e-6 L=1e-6
mpway43_cell69 ML43 gate_way43_cell69 GND ML43 p1 W=2.4e-6 L=1e-6
mnway43_cell70 ML43 gate_way43_cell70 GND GND n1 W=1e-6 L=1e-6
mpway43_cell70 ML43 gate_way43_cell70 GND ML43 p1 W=2.4e-6 L=1e-6
mnway43_cell71 ML43 gate_way43_cell71 GND GND n1 W=1e-6 L=1e-6
mpway43_cell71 ML43 gate_way43_cell71 GND ML43 p1 W=2.4e-6 L=1e-6
mnway43_cell72 ML43 gate_way43_cell72 GND GND n1 W=1e-6 L=1e-6
mpway43_cell72 ML43 gate_way43_cell72 GND ML43 p1 W=2.4e-6 L=1e-6
mnway43_cell73 ML43 gate_way43_cell73 GND GND n1 W=1e-6 L=1e-6
mpway43_cell73 ML43 gate_way43_cell73 GND ML43 p1 W=2.4e-6 L=1e-6
mnway43_cell74 ML43 gate_way43_cell74 GND GND n1 W=1e-6 L=1e-6
mpway43_cell74 ML43 gate_way43_cell74 GND ML43 p1 W=2.4e-6 L=1e-6
mnway43_cell75 ML43 gate_way43_cell75 GND GND n1 W=1e-6 L=1e-6
mpway43_cell75 ML43 gate_way43_cell75 GND ML43 p1 W=2.4e-6 L=1e-6
mnway43_cell76 ML43 gate_way43_cell76 GND GND n1 W=1e-6 L=1e-6
mpway43_cell76 ML43 gate_way43_cell76 GND ML43 p1 W=2.4e-6 L=1e-6
mnway43_cell77 ML43 gate_way43_cell77 GND GND n1 W=1e-6 L=1e-6
mpway43_cell77 ML43 gate_way43_cell77 GND ML43 p1 W=2.4e-6 L=1e-6
mnway43_cell78 ML43 gate_way43_cell78 GND GND n1 W=1e-6 L=1e-6
mpway43_cell78 ML43 gate_way43_cell78 GND ML43 p1 W=2.4e-6 L=1e-6
mnway43_cell79 ML43 gate_way43_cell79 GND GND n1 W=1e-6 L=1e-6
mpway43_cell79 ML43 gate_way43_cell79 GND ML43 p1 W=2.4e-6 L=1e-6
mnway43_cell80 ML43 gate_way43_cell80 GND GND n1 W=1e-6 L=1e-6
mpway43_cell80 ML43 gate_way43_cell80 GND ML43 p1 W=2.4e-6 L=1e-6
mnway43_cell81 ML43 gate_way43_cell81 GND GND n1 W=1e-6 L=1e-6
mpway43_cell81 ML43 gate_way43_cell81 GND ML43 p1 W=2.4e-6 L=1e-6
mnway43_cell82 ML43 gate_way43_cell82 GND GND n1 W=1e-6 L=1e-6
mpway43_cell82 ML43 gate_way43_cell82 GND ML43 p1 W=2.4e-6 L=1e-6
mnway43_cell83 ML43 gate_way43_cell83 GND GND n1 W=1e-6 L=1e-6
mpway43_cell83 ML43 gate_way43_cell83 GND ML43 p1 W=2.4e-6 L=1e-6
mnway43_cell84 ML43 gate_way43_cell84 GND GND n1 W=1e-6 L=1e-6
mpway43_cell84 ML43 gate_way43_cell84 GND ML43 p1 W=2.4e-6 L=1e-6
mnway43_cell85 ML43 gate_way43_cell85 GND GND n1 W=1e-6 L=1e-6
mpway43_cell85 ML43 gate_way43_cell85 GND ML43 p1 W=2.4e-6 L=1e-6
mnway43_cell86 ML43 gate_way43_cell86 GND GND n1 W=1e-6 L=1e-6
mpway43_cell86 ML43 gate_way43_cell86 GND ML43 p1 W=2.4e-6 L=1e-6
mnway43_cell87 ML43 gate_way43_cell87 GND GND n1 W=1e-6 L=1e-6
mpway43_cell87 ML43 gate_way43_cell87 GND ML43 p1 W=2.4e-6 L=1e-6
mnway43_cell88 ML43 gate_way43_cell88 GND GND n1 W=1e-6 L=1e-6
mpway43_cell88 ML43 gate_way43_cell88 GND ML43 p1 W=2.4e-6 L=1e-6
mnway43_cell89 ML43 gate_way43_cell89 GND GND n1 W=1e-6 L=1e-6
mpway43_cell89 ML43 gate_way43_cell89 GND ML43 p1 W=2.4e-6 L=1e-6
mnway43_cell90 ML43 gate_way43_cell90 GND GND n1 W=1e-6 L=1e-6
mpway43_cell90 ML43 gate_way43_cell90 GND ML43 p1 W=2.4e-6 L=1e-6
mnway43_cell91 ML43 gate_way43_cell91 GND GND n1 W=1e-6 L=1e-6
mpway43_cell91 ML43 gate_way43_cell91 GND ML43 p1 W=2.4e-6 L=1e-6
mnway43_cell92 ML43 gate_way43_cell92 GND GND n1 W=1e-6 L=1e-6
mpway43_cell92 ML43 gate_way43_cell92 GND ML43 p1 W=2.4e-6 L=1e-6
mnway43_cell93 ML43 gate_way43_cell93 GND GND n1 W=1e-6 L=1e-6
mpway43_cell93 ML43 gate_way43_cell93 GND ML43 p1 W=2.4e-6 L=1e-6
mnway43_cell94 ML43 gate_way43_cell94 GND GND n1 W=1e-6 L=1e-6
mpway43_cell94 ML43 gate_way43_cell94 GND ML43 p1 W=2.4e-6 L=1e-6
mnway43_cell95 ML43 gate_way43_cell95 GND GND n1 W=1e-6 L=1e-6
mpway43_cell95 ML43 gate_way43_cell95 GND ML43 p1 W=2.4e-6 L=1e-6
mnway43_cell96 ML43 gate_way43_cell96 GND GND n1 W=1e-6 L=1e-6
mpway43_cell96 ML43 gate_way43_cell96 GND ML43 p1 W=2.4e-6 L=1e-6
mnway43_cell97 ML43 gate_way43_cell97 GND GND n1 W=1e-6 L=1e-6
mpway43_cell97 ML43 gate_way43_cell97 GND ML43 p1 W=2.4e-6 L=1e-6
mnway43_cell98 ML43 gate_way43_cell98 GND GND n1 W=1e-6 L=1e-6
mpway43_cell98 ML43 gate_way43_cell98 GND ML43 p1 W=2.4e-6 L=1e-6
mnway43_cell99 ML43 gate_way43_cell99 GND GND n1 W=1e-6 L=1e-6
mpway43_cell99 ML43 gate_way43_cell99 GND ML43 p1 W=2.4e-6 L=1e-6
mnway44_cell0 ML44 gate_way44_cell0 GND GND n1 W=1e-6 L=1e-6
mpway44_cell0 ML44 gate_way44_cell0 GND ML44 p1 W=2.4e-6 L=1e-6
mnway44_cell1 ML44 gate_way44_cell1 GND GND n1 W=1e-6 L=1e-6
mpway44_cell1 ML44 gate_way44_cell1 GND ML44 p1 W=2.4e-6 L=1e-6
mnway44_cell2 ML44 gate_way44_cell2 GND GND n1 W=1e-6 L=1e-6
mpway44_cell2 ML44 gate_way44_cell2 GND ML44 p1 W=2.4e-6 L=1e-6
mnway44_cell3 ML44 gate_way44_cell3 GND GND n1 W=1e-6 L=1e-6
mpway44_cell3 ML44 gate_way44_cell3 GND ML44 p1 W=2.4e-6 L=1e-6
mnway44_cell4 ML44 gate_way44_cell4 GND GND n1 W=1e-6 L=1e-6
mpway44_cell4 ML44 gate_way44_cell4 GND ML44 p1 W=2.4e-6 L=1e-6
mnway44_cell5 ML44 gate_way44_cell5 GND GND n1 W=1e-6 L=1e-6
mpway44_cell5 ML44 gate_way44_cell5 GND ML44 p1 W=2.4e-6 L=1e-6
mnway44_cell6 ML44 gate_way44_cell6 GND GND n1 W=1e-6 L=1e-6
mpway44_cell6 ML44 gate_way44_cell6 GND ML44 p1 W=2.4e-6 L=1e-6
mnway44_cell7 ML44 gate_way44_cell7 GND GND n1 W=1e-6 L=1e-6
mpway44_cell7 ML44 gate_way44_cell7 GND ML44 p1 W=2.4e-6 L=1e-6
mnway44_cell8 ML44 gate_way44_cell8 GND GND n1 W=1e-6 L=1e-6
mpway44_cell8 ML44 gate_way44_cell8 GND ML44 p1 W=2.4e-6 L=1e-6
mnway44_cell9 ML44 gate_way44_cell9 GND GND n1 W=1e-6 L=1e-6
mpway44_cell9 ML44 gate_way44_cell9 GND ML44 p1 W=2.4e-6 L=1e-6
mnway44_cell10 ML44 gate_way44_cell10 GND GND n1 W=1e-6 L=1e-6
mpway44_cell10 ML44 gate_way44_cell10 GND ML44 p1 W=2.4e-6 L=1e-6
mnway44_cell11 ML44 gate_way44_cell11 GND GND n1 W=1e-6 L=1e-6
mpway44_cell11 ML44 gate_way44_cell11 GND ML44 p1 W=2.4e-6 L=1e-6
mnway44_cell12 ML44 gate_way44_cell12 GND GND n1 W=1e-6 L=1e-6
mpway44_cell12 ML44 gate_way44_cell12 GND ML44 p1 W=2.4e-6 L=1e-6
mnway44_cell13 ML44 gate_way44_cell13 GND GND n1 W=1e-6 L=1e-6
mpway44_cell13 ML44 gate_way44_cell13 GND ML44 p1 W=2.4e-6 L=1e-6
mnway44_cell14 ML44 gate_way44_cell14 GND GND n1 W=1e-6 L=1e-6
mpway44_cell14 ML44 gate_way44_cell14 GND ML44 p1 W=2.4e-6 L=1e-6
mnway44_cell15 ML44 gate_way44_cell15 GND GND n1 W=1e-6 L=1e-6
mpway44_cell15 ML44 gate_way44_cell15 GND ML44 p1 W=2.4e-6 L=1e-6
mnway44_cell16 ML44 gate_way44_cell16 GND GND n1 W=1e-6 L=1e-6
mpway44_cell16 ML44 gate_way44_cell16 GND ML44 p1 W=2.4e-6 L=1e-6
mnway44_cell17 ML44 gate_way44_cell17 GND GND n1 W=1e-6 L=1e-6
mpway44_cell17 ML44 gate_way44_cell17 GND ML44 p1 W=2.4e-6 L=1e-6
mnway44_cell18 ML44 gate_way44_cell18 GND GND n1 W=1e-6 L=1e-6
mpway44_cell18 ML44 gate_way44_cell18 GND ML44 p1 W=2.4e-6 L=1e-6
mnway44_cell19 ML44 gate_way44_cell19 GND GND n1 W=1e-6 L=1e-6
mpway44_cell19 ML44 gate_way44_cell19 GND ML44 p1 W=2.4e-6 L=1e-6
mnway44_cell20 ML44 gate_way44_cell20 GND GND n1 W=1e-6 L=1e-6
mpway44_cell20 ML44 gate_way44_cell20 GND ML44 p1 W=2.4e-6 L=1e-6
mnway44_cell21 ML44 gate_way44_cell21 GND GND n1 W=1e-6 L=1e-6
mpway44_cell21 ML44 gate_way44_cell21 GND ML44 p1 W=2.4e-6 L=1e-6
mnway44_cell22 ML44 gate_way44_cell22 GND GND n1 W=1e-6 L=1e-6
mpway44_cell22 ML44 gate_way44_cell22 GND ML44 p1 W=2.4e-6 L=1e-6
mnway44_cell23 ML44 gate_way44_cell23 GND GND n1 W=1e-6 L=1e-6
mpway44_cell23 ML44 gate_way44_cell23 GND ML44 p1 W=2.4e-6 L=1e-6
mnway44_cell24 ML44 gate_way44_cell24 GND GND n1 W=1e-6 L=1e-6
mpway44_cell24 ML44 gate_way44_cell24 GND ML44 p1 W=2.4e-6 L=1e-6
mnway44_cell25 ML44 gate_way44_cell25 GND GND n1 W=1e-6 L=1e-6
mpway44_cell25 ML44 gate_way44_cell25 GND ML44 p1 W=2.4e-6 L=1e-6
mnway44_cell26 ML44 gate_way44_cell26 GND GND n1 W=1e-6 L=1e-6
mpway44_cell26 ML44 gate_way44_cell26 GND ML44 p1 W=2.4e-6 L=1e-6
mnway44_cell27 ML44 gate_way44_cell27 GND GND n1 W=1e-6 L=1e-6
mpway44_cell27 ML44 gate_way44_cell27 GND ML44 p1 W=2.4e-6 L=1e-6
mnway44_cell28 ML44 gate_way44_cell28 GND GND n1 W=1e-6 L=1e-6
mpway44_cell28 ML44 gate_way44_cell28 GND ML44 p1 W=2.4e-6 L=1e-6
mnway44_cell29 ML44 gate_way44_cell29 GND GND n1 W=1e-6 L=1e-6
mpway44_cell29 ML44 gate_way44_cell29 GND ML44 p1 W=2.4e-6 L=1e-6
mnway44_cell30 ML44 gate_way44_cell30 GND GND n1 W=1e-6 L=1e-6
mpway44_cell30 ML44 gate_way44_cell30 GND ML44 p1 W=2.4e-6 L=1e-6
mnway44_cell31 ML44 gate_way44_cell31 GND GND n1 W=1e-6 L=1e-6
mpway44_cell31 ML44 gate_way44_cell31 GND ML44 p1 W=2.4e-6 L=1e-6
mnway44_cell32 ML44 gate_way44_cell32 GND GND n1 W=1e-6 L=1e-6
mpway44_cell32 ML44 gate_way44_cell32 GND ML44 p1 W=2.4e-6 L=1e-6
mnway44_cell33 ML44 gate_way44_cell33 GND GND n1 W=1e-6 L=1e-6
mpway44_cell33 ML44 gate_way44_cell33 GND ML44 p1 W=2.4e-6 L=1e-6
mnway44_cell34 ML44 gate_way44_cell34 GND GND n1 W=1e-6 L=1e-6
mpway44_cell34 ML44 gate_way44_cell34 GND ML44 p1 W=2.4e-6 L=1e-6
mnway44_cell35 ML44 gate_way44_cell35 GND GND n1 W=1e-6 L=1e-6
mpway44_cell35 ML44 gate_way44_cell35 GND ML44 p1 W=2.4e-6 L=1e-6
mnway44_cell36 ML44 gate_way44_cell36 GND GND n1 W=1e-6 L=1e-6
mpway44_cell36 ML44 gate_way44_cell36 GND ML44 p1 W=2.4e-6 L=1e-6
mnway44_cell37 ML44 gate_way44_cell37 GND GND n1 W=1e-6 L=1e-6
mpway44_cell37 ML44 gate_way44_cell37 GND ML44 p1 W=2.4e-6 L=1e-6
mnway44_cell38 ML44 gate_way44_cell38 GND GND n1 W=1e-6 L=1e-6
mpway44_cell38 ML44 gate_way44_cell38 GND ML44 p1 W=2.4e-6 L=1e-6
mnway44_cell39 ML44 gate_way44_cell39 GND GND n1 W=1e-6 L=1e-6
mpway44_cell39 ML44 gate_way44_cell39 GND ML44 p1 W=2.4e-6 L=1e-6
mnway44_cell40 ML44 gate_way44_cell40 GND GND n1 W=1e-6 L=1e-6
mpway44_cell40 ML44 gate_way44_cell40 GND ML44 p1 W=2.4e-6 L=1e-6
mnway44_cell41 ML44 gate_way44_cell41 GND GND n1 W=1e-6 L=1e-6
mpway44_cell41 ML44 gate_way44_cell41 GND ML44 p1 W=2.4e-6 L=1e-6
mnway44_cell42 ML44 gate_way44_cell42 GND GND n1 W=1e-6 L=1e-6
mpway44_cell42 ML44 gate_way44_cell42 GND ML44 p1 W=2.4e-6 L=1e-6
mnway44_cell43 ML44 gate_way44_cell43 GND GND n1 W=1e-6 L=1e-6
mpway44_cell43 ML44 gate_way44_cell43 GND ML44 p1 W=2.4e-6 L=1e-6
mnway44_cell44 ML44 gate_way44_cell44 GND GND n1 W=1e-6 L=1e-6
mpway44_cell44 ML44 gate_way44_cell44 GND ML44 p1 W=2.4e-6 L=1e-6
mnway44_cell45 ML44 gate_way44_cell45 GND GND n1 W=1e-6 L=1e-6
mpway44_cell45 ML44 gate_way44_cell45 GND ML44 p1 W=2.4e-6 L=1e-6
mnway44_cell46 ML44 gate_way44_cell46 GND GND n1 W=1e-6 L=1e-6
mpway44_cell46 ML44 gate_way44_cell46 GND ML44 p1 W=2.4e-6 L=1e-6
mnway44_cell47 ML44 gate_way44_cell47 GND GND n1 W=1e-6 L=1e-6
mpway44_cell47 ML44 gate_way44_cell47 GND ML44 p1 W=2.4e-6 L=1e-6
mnway44_cell48 ML44 gate_way44_cell48 GND GND n1 W=1e-6 L=1e-6
mpway44_cell48 ML44 gate_way44_cell48 GND ML44 p1 W=2.4e-6 L=1e-6
mnway44_cell49 ML44 gate_way44_cell49 GND GND n1 W=1e-6 L=1e-6
mpway44_cell49 ML44 gate_way44_cell49 GND ML44 p1 W=2.4e-6 L=1e-6
mnway44_cell50 ML44 gate_way44_cell50 GND GND n1 W=1e-6 L=1e-6
mpway44_cell50 ML44 gate_way44_cell50 GND ML44 p1 W=2.4e-6 L=1e-6
mnway44_cell51 ML44 gate_way44_cell51 GND GND n1 W=1e-6 L=1e-6
mpway44_cell51 ML44 gate_way44_cell51 GND ML44 p1 W=2.4e-6 L=1e-6
mnway44_cell52 ML44 gate_way44_cell52 GND GND n1 W=1e-6 L=1e-6
mpway44_cell52 ML44 gate_way44_cell52 GND ML44 p1 W=2.4e-6 L=1e-6
mnway44_cell53 ML44 gate_way44_cell53 GND GND n1 W=1e-6 L=1e-6
mpway44_cell53 ML44 gate_way44_cell53 GND ML44 p1 W=2.4e-6 L=1e-6
mnway44_cell54 ML44 gate_way44_cell54 GND GND n1 W=1e-6 L=1e-6
mpway44_cell54 ML44 gate_way44_cell54 GND ML44 p1 W=2.4e-6 L=1e-6
mnway44_cell55 ML44 gate_way44_cell55 GND GND n1 W=1e-6 L=1e-6
mpway44_cell55 ML44 gate_way44_cell55 GND ML44 p1 W=2.4e-6 L=1e-6
mnway44_cell56 ML44 gate_way44_cell56 GND GND n1 W=1e-6 L=1e-6
mpway44_cell56 ML44 gate_way44_cell56 GND ML44 p1 W=2.4e-6 L=1e-6
mnway44_cell57 ML44 gate_way44_cell57 GND GND n1 W=1e-6 L=1e-6
mpway44_cell57 ML44 gate_way44_cell57 GND ML44 p1 W=2.4e-6 L=1e-6
mnway44_cell58 ML44 gate_way44_cell58 GND GND n1 W=1e-6 L=1e-6
mpway44_cell58 ML44 gate_way44_cell58 GND ML44 p1 W=2.4e-6 L=1e-6
mnway44_cell59 ML44 gate_way44_cell59 GND GND n1 W=1e-6 L=1e-6
mpway44_cell59 ML44 gate_way44_cell59 GND ML44 p1 W=2.4e-6 L=1e-6
mnway44_cell60 ML44 gate_way44_cell60 GND GND n1 W=1e-6 L=1e-6
mpway44_cell60 ML44 gate_way44_cell60 GND ML44 p1 W=2.4e-6 L=1e-6
mnway44_cell61 ML44 gate_way44_cell61 GND GND n1 W=1e-6 L=1e-6
mpway44_cell61 ML44 gate_way44_cell61 GND ML44 p1 W=2.4e-6 L=1e-6
mnway44_cell62 ML44 gate_way44_cell62 GND GND n1 W=1e-6 L=1e-6
mpway44_cell62 ML44 gate_way44_cell62 GND ML44 p1 W=2.4e-6 L=1e-6
mnway44_cell63 ML44 gate_way44_cell63 GND GND n1 W=1e-6 L=1e-6
mpway44_cell63 ML44 gate_way44_cell63 GND ML44 p1 W=2.4e-6 L=1e-6
mnway44_cell64 ML44 gate_way44_cell64 GND GND n1 W=1e-6 L=1e-6
mpway44_cell64 ML44 gate_way44_cell64 GND ML44 p1 W=2.4e-6 L=1e-6
mnway44_cell65 ML44 gate_way44_cell65 GND GND n1 W=1e-6 L=1e-6
mpway44_cell65 ML44 gate_way44_cell65 GND ML44 p1 W=2.4e-6 L=1e-6
mnway44_cell66 ML44 gate_way44_cell66 GND GND n1 W=1e-6 L=1e-6
mpway44_cell66 ML44 gate_way44_cell66 GND ML44 p1 W=2.4e-6 L=1e-6
mnway44_cell67 ML44 gate_way44_cell67 GND GND n1 W=1e-6 L=1e-6
mpway44_cell67 ML44 gate_way44_cell67 GND ML44 p1 W=2.4e-6 L=1e-6
mnway44_cell68 ML44 gate_way44_cell68 GND GND n1 W=1e-6 L=1e-6
mpway44_cell68 ML44 gate_way44_cell68 GND ML44 p1 W=2.4e-6 L=1e-6
mnway44_cell69 ML44 gate_way44_cell69 GND GND n1 W=1e-6 L=1e-6
mpway44_cell69 ML44 gate_way44_cell69 GND ML44 p1 W=2.4e-6 L=1e-6
mnway44_cell70 ML44 gate_way44_cell70 GND GND n1 W=1e-6 L=1e-6
mpway44_cell70 ML44 gate_way44_cell70 GND ML44 p1 W=2.4e-6 L=1e-6
mnway44_cell71 ML44 gate_way44_cell71 GND GND n1 W=1e-6 L=1e-6
mpway44_cell71 ML44 gate_way44_cell71 GND ML44 p1 W=2.4e-6 L=1e-6
mnway44_cell72 ML44 gate_way44_cell72 GND GND n1 W=1e-6 L=1e-6
mpway44_cell72 ML44 gate_way44_cell72 GND ML44 p1 W=2.4e-6 L=1e-6
mnway44_cell73 ML44 gate_way44_cell73 GND GND n1 W=1e-6 L=1e-6
mpway44_cell73 ML44 gate_way44_cell73 GND ML44 p1 W=2.4e-6 L=1e-6
mnway44_cell74 ML44 gate_way44_cell74 GND GND n1 W=1e-6 L=1e-6
mpway44_cell74 ML44 gate_way44_cell74 GND ML44 p1 W=2.4e-6 L=1e-6
mnway44_cell75 ML44 gate_way44_cell75 GND GND n1 W=1e-6 L=1e-6
mpway44_cell75 ML44 gate_way44_cell75 GND ML44 p1 W=2.4e-6 L=1e-6
mnway44_cell76 ML44 gate_way44_cell76 GND GND n1 W=1e-6 L=1e-6
mpway44_cell76 ML44 gate_way44_cell76 GND ML44 p1 W=2.4e-6 L=1e-6
mnway44_cell77 ML44 gate_way44_cell77 GND GND n1 W=1e-6 L=1e-6
mpway44_cell77 ML44 gate_way44_cell77 GND ML44 p1 W=2.4e-6 L=1e-6
mnway44_cell78 ML44 gate_way44_cell78 GND GND n1 W=1e-6 L=1e-6
mpway44_cell78 ML44 gate_way44_cell78 GND ML44 p1 W=2.4e-6 L=1e-6
mnway44_cell79 ML44 gate_way44_cell79 GND GND n1 W=1e-6 L=1e-6
mpway44_cell79 ML44 gate_way44_cell79 GND ML44 p1 W=2.4e-6 L=1e-6
mnway44_cell80 ML44 gate_way44_cell80 GND GND n1 W=1e-6 L=1e-6
mpway44_cell80 ML44 gate_way44_cell80 GND ML44 p1 W=2.4e-6 L=1e-6
mnway44_cell81 ML44 gate_way44_cell81 GND GND n1 W=1e-6 L=1e-6
mpway44_cell81 ML44 gate_way44_cell81 GND ML44 p1 W=2.4e-6 L=1e-6
mnway44_cell82 ML44 gate_way44_cell82 GND GND n1 W=1e-6 L=1e-6
mpway44_cell82 ML44 gate_way44_cell82 GND ML44 p1 W=2.4e-6 L=1e-6
mnway44_cell83 ML44 gate_way44_cell83 GND GND n1 W=1e-6 L=1e-6
mpway44_cell83 ML44 gate_way44_cell83 GND ML44 p1 W=2.4e-6 L=1e-6
mnway44_cell84 ML44 gate_way44_cell84 GND GND n1 W=1e-6 L=1e-6
mpway44_cell84 ML44 gate_way44_cell84 GND ML44 p1 W=2.4e-6 L=1e-6
mnway44_cell85 ML44 gate_way44_cell85 GND GND n1 W=1e-6 L=1e-6
mpway44_cell85 ML44 gate_way44_cell85 GND ML44 p1 W=2.4e-6 L=1e-6
mnway44_cell86 ML44 gate_way44_cell86 GND GND n1 W=1e-6 L=1e-6
mpway44_cell86 ML44 gate_way44_cell86 GND ML44 p1 W=2.4e-6 L=1e-6
mnway44_cell87 ML44 gate_way44_cell87 GND GND n1 W=1e-6 L=1e-6
mpway44_cell87 ML44 gate_way44_cell87 GND ML44 p1 W=2.4e-6 L=1e-6
mnway44_cell88 ML44 gate_way44_cell88 GND GND n1 W=1e-6 L=1e-6
mpway44_cell88 ML44 gate_way44_cell88 GND ML44 p1 W=2.4e-6 L=1e-6
mnway44_cell89 ML44 gate_way44_cell89 GND GND n1 W=1e-6 L=1e-6
mpway44_cell89 ML44 gate_way44_cell89 GND ML44 p1 W=2.4e-6 L=1e-6
mnway44_cell90 ML44 gate_way44_cell90 GND GND n1 W=1e-6 L=1e-6
mpway44_cell90 ML44 gate_way44_cell90 GND ML44 p1 W=2.4e-6 L=1e-6
mnway44_cell91 ML44 gate_way44_cell91 GND GND n1 W=1e-6 L=1e-6
mpway44_cell91 ML44 gate_way44_cell91 GND ML44 p1 W=2.4e-6 L=1e-6
mnway44_cell92 ML44 gate_way44_cell92 GND GND n1 W=1e-6 L=1e-6
mpway44_cell92 ML44 gate_way44_cell92 GND ML44 p1 W=2.4e-6 L=1e-6
mnway44_cell93 ML44 gate_way44_cell93 GND GND n1 W=1e-6 L=1e-6
mpway44_cell93 ML44 gate_way44_cell93 GND ML44 p1 W=2.4e-6 L=1e-6
mnway44_cell94 ML44 gate_way44_cell94 GND GND n1 W=1e-6 L=1e-6
mpway44_cell94 ML44 gate_way44_cell94 GND ML44 p1 W=2.4e-6 L=1e-6
mnway44_cell95 ML44 gate_way44_cell95 GND GND n1 W=1e-6 L=1e-6
mpway44_cell95 ML44 gate_way44_cell95 GND ML44 p1 W=2.4e-6 L=1e-6
mnway44_cell96 ML44 gate_way44_cell96 GND GND n1 W=1e-6 L=1e-6
mpway44_cell96 ML44 gate_way44_cell96 GND ML44 p1 W=2.4e-6 L=1e-6
mnway44_cell97 ML44 gate_way44_cell97 GND GND n1 W=1e-6 L=1e-6
mpway44_cell97 ML44 gate_way44_cell97 GND ML44 p1 W=2.4e-6 L=1e-6
mnway44_cell98 ML44 gate_way44_cell98 GND GND n1 W=1e-6 L=1e-6
mpway44_cell98 ML44 gate_way44_cell98 GND ML44 p1 W=2.4e-6 L=1e-6
mnway44_cell99 ML44 gate_way44_cell99 GND GND n1 W=1e-6 L=1e-6
mpway44_cell99 ML44 gate_way44_cell99 GND ML44 p1 W=2.4e-6 L=1e-6
mnway45_cell0 ML45 gate_way45_cell0 GND GND n1 W=1e-6 L=1e-6
mpway45_cell0 ML45 gate_way45_cell0 GND ML45 p1 W=2.4e-6 L=1e-6
mnway45_cell1 ML45 gate_way45_cell1 GND GND n1 W=1e-6 L=1e-6
mpway45_cell1 ML45 gate_way45_cell1 GND ML45 p1 W=2.4e-6 L=1e-6
mnway45_cell2 ML45 gate_way45_cell2 GND GND n1 W=1e-6 L=1e-6
mpway45_cell2 ML45 gate_way45_cell2 GND ML45 p1 W=2.4e-6 L=1e-6
mnway45_cell3 ML45 gate_way45_cell3 GND GND n1 W=1e-6 L=1e-6
mpway45_cell3 ML45 gate_way45_cell3 GND ML45 p1 W=2.4e-6 L=1e-6
mnway45_cell4 ML45 gate_way45_cell4 GND GND n1 W=1e-6 L=1e-6
mpway45_cell4 ML45 gate_way45_cell4 GND ML45 p1 W=2.4e-6 L=1e-6
mnway45_cell5 ML45 gate_way45_cell5 GND GND n1 W=1e-6 L=1e-6
mpway45_cell5 ML45 gate_way45_cell5 GND ML45 p1 W=2.4e-6 L=1e-6
mnway45_cell6 ML45 gate_way45_cell6 GND GND n1 W=1e-6 L=1e-6
mpway45_cell6 ML45 gate_way45_cell6 GND ML45 p1 W=2.4e-6 L=1e-6
mnway45_cell7 ML45 gate_way45_cell7 GND GND n1 W=1e-6 L=1e-6
mpway45_cell7 ML45 gate_way45_cell7 GND ML45 p1 W=2.4e-6 L=1e-6
mnway45_cell8 ML45 gate_way45_cell8 GND GND n1 W=1e-6 L=1e-6
mpway45_cell8 ML45 gate_way45_cell8 GND ML45 p1 W=2.4e-6 L=1e-6
mnway45_cell9 ML45 gate_way45_cell9 GND GND n1 W=1e-6 L=1e-6
mpway45_cell9 ML45 gate_way45_cell9 GND ML45 p1 W=2.4e-6 L=1e-6
mnway45_cell10 ML45 gate_way45_cell10 GND GND n1 W=1e-6 L=1e-6
mpway45_cell10 ML45 gate_way45_cell10 GND ML45 p1 W=2.4e-6 L=1e-6
mnway45_cell11 ML45 gate_way45_cell11 GND GND n1 W=1e-6 L=1e-6
mpway45_cell11 ML45 gate_way45_cell11 GND ML45 p1 W=2.4e-6 L=1e-6
mnway45_cell12 ML45 gate_way45_cell12 GND GND n1 W=1e-6 L=1e-6
mpway45_cell12 ML45 gate_way45_cell12 GND ML45 p1 W=2.4e-6 L=1e-6
mnway45_cell13 ML45 gate_way45_cell13 GND GND n1 W=1e-6 L=1e-6
mpway45_cell13 ML45 gate_way45_cell13 GND ML45 p1 W=2.4e-6 L=1e-6
mnway45_cell14 ML45 gate_way45_cell14 GND GND n1 W=1e-6 L=1e-6
mpway45_cell14 ML45 gate_way45_cell14 GND ML45 p1 W=2.4e-6 L=1e-6
mnway45_cell15 ML45 gate_way45_cell15 GND GND n1 W=1e-6 L=1e-6
mpway45_cell15 ML45 gate_way45_cell15 GND ML45 p1 W=2.4e-6 L=1e-6
mnway45_cell16 ML45 gate_way45_cell16 GND GND n1 W=1e-6 L=1e-6
mpway45_cell16 ML45 gate_way45_cell16 GND ML45 p1 W=2.4e-6 L=1e-6
mnway45_cell17 ML45 gate_way45_cell17 GND GND n1 W=1e-6 L=1e-6
mpway45_cell17 ML45 gate_way45_cell17 GND ML45 p1 W=2.4e-6 L=1e-6
mnway45_cell18 ML45 gate_way45_cell18 GND GND n1 W=1e-6 L=1e-6
mpway45_cell18 ML45 gate_way45_cell18 GND ML45 p1 W=2.4e-6 L=1e-6
mnway45_cell19 ML45 gate_way45_cell19 GND GND n1 W=1e-6 L=1e-6
mpway45_cell19 ML45 gate_way45_cell19 GND ML45 p1 W=2.4e-6 L=1e-6
mnway45_cell20 ML45 gate_way45_cell20 GND GND n1 W=1e-6 L=1e-6
mpway45_cell20 ML45 gate_way45_cell20 GND ML45 p1 W=2.4e-6 L=1e-6
mnway45_cell21 ML45 gate_way45_cell21 GND GND n1 W=1e-6 L=1e-6
mpway45_cell21 ML45 gate_way45_cell21 GND ML45 p1 W=2.4e-6 L=1e-6
mnway45_cell22 ML45 gate_way45_cell22 GND GND n1 W=1e-6 L=1e-6
mpway45_cell22 ML45 gate_way45_cell22 GND ML45 p1 W=2.4e-6 L=1e-6
mnway45_cell23 ML45 gate_way45_cell23 GND GND n1 W=1e-6 L=1e-6
mpway45_cell23 ML45 gate_way45_cell23 GND ML45 p1 W=2.4e-6 L=1e-6
mnway45_cell24 ML45 gate_way45_cell24 GND GND n1 W=1e-6 L=1e-6
mpway45_cell24 ML45 gate_way45_cell24 GND ML45 p1 W=2.4e-6 L=1e-6
mnway45_cell25 ML45 gate_way45_cell25 GND GND n1 W=1e-6 L=1e-6
mpway45_cell25 ML45 gate_way45_cell25 GND ML45 p1 W=2.4e-6 L=1e-6
mnway45_cell26 ML45 gate_way45_cell26 GND GND n1 W=1e-6 L=1e-6
mpway45_cell26 ML45 gate_way45_cell26 GND ML45 p1 W=2.4e-6 L=1e-6
mnway45_cell27 ML45 gate_way45_cell27 GND GND n1 W=1e-6 L=1e-6
mpway45_cell27 ML45 gate_way45_cell27 GND ML45 p1 W=2.4e-6 L=1e-6
mnway45_cell28 ML45 gate_way45_cell28 GND GND n1 W=1e-6 L=1e-6
mpway45_cell28 ML45 gate_way45_cell28 GND ML45 p1 W=2.4e-6 L=1e-6
mnway45_cell29 ML45 gate_way45_cell29 GND GND n1 W=1e-6 L=1e-6
mpway45_cell29 ML45 gate_way45_cell29 GND ML45 p1 W=2.4e-6 L=1e-6
mnway45_cell30 ML45 gate_way45_cell30 GND GND n1 W=1e-6 L=1e-6
mpway45_cell30 ML45 gate_way45_cell30 GND ML45 p1 W=2.4e-6 L=1e-6
mnway45_cell31 ML45 gate_way45_cell31 GND GND n1 W=1e-6 L=1e-6
mpway45_cell31 ML45 gate_way45_cell31 GND ML45 p1 W=2.4e-6 L=1e-6
mnway45_cell32 ML45 gate_way45_cell32 GND GND n1 W=1e-6 L=1e-6
mpway45_cell32 ML45 gate_way45_cell32 GND ML45 p1 W=2.4e-6 L=1e-6
mnway45_cell33 ML45 gate_way45_cell33 GND GND n1 W=1e-6 L=1e-6
mpway45_cell33 ML45 gate_way45_cell33 GND ML45 p1 W=2.4e-6 L=1e-6
mnway45_cell34 ML45 gate_way45_cell34 GND GND n1 W=1e-6 L=1e-6
mpway45_cell34 ML45 gate_way45_cell34 GND ML45 p1 W=2.4e-6 L=1e-6
mnway45_cell35 ML45 gate_way45_cell35 GND GND n1 W=1e-6 L=1e-6
mpway45_cell35 ML45 gate_way45_cell35 GND ML45 p1 W=2.4e-6 L=1e-6
mnway45_cell36 ML45 gate_way45_cell36 GND GND n1 W=1e-6 L=1e-6
mpway45_cell36 ML45 gate_way45_cell36 GND ML45 p1 W=2.4e-6 L=1e-6
mnway45_cell37 ML45 gate_way45_cell37 GND GND n1 W=1e-6 L=1e-6
mpway45_cell37 ML45 gate_way45_cell37 GND ML45 p1 W=2.4e-6 L=1e-6
mnway45_cell38 ML45 gate_way45_cell38 GND GND n1 W=1e-6 L=1e-6
mpway45_cell38 ML45 gate_way45_cell38 GND ML45 p1 W=2.4e-6 L=1e-6
mnway45_cell39 ML45 gate_way45_cell39 GND GND n1 W=1e-6 L=1e-6
mpway45_cell39 ML45 gate_way45_cell39 GND ML45 p1 W=2.4e-6 L=1e-6
mnway45_cell40 ML45 gate_way45_cell40 GND GND n1 W=1e-6 L=1e-6
mpway45_cell40 ML45 gate_way45_cell40 GND ML45 p1 W=2.4e-6 L=1e-6
mnway45_cell41 ML45 gate_way45_cell41 GND GND n1 W=1e-6 L=1e-6
mpway45_cell41 ML45 gate_way45_cell41 GND ML45 p1 W=2.4e-6 L=1e-6
mnway45_cell42 ML45 gate_way45_cell42 GND GND n1 W=1e-6 L=1e-6
mpway45_cell42 ML45 gate_way45_cell42 GND ML45 p1 W=2.4e-6 L=1e-6
mnway45_cell43 ML45 gate_way45_cell43 GND GND n1 W=1e-6 L=1e-6
mpway45_cell43 ML45 gate_way45_cell43 GND ML45 p1 W=2.4e-6 L=1e-6
mnway45_cell44 ML45 gate_way45_cell44 GND GND n1 W=1e-6 L=1e-6
mpway45_cell44 ML45 gate_way45_cell44 GND ML45 p1 W=2.4e-6 L=1e-6
mnway45_cell45 ML45 gate_way45_cell45 GND GND n1 W=1e-6 L=1e-6
mpway45_cell45 ML45 gate_way45_cell45 GND ML45 p1 W=2.4e-6 L=1e-6
mnway45_cell46 ML45 gate_way45_cell46 GND GND n1 W=1e-6 L=1e-6
mpway45_cell46 ML45 gate_way45_cell46 GND ML45 p1 W=2.4e-6 L=1e-6
mnway45_cell47 ML45 gate_way45_cell47 GND GND n1 W=1e-6 L=1e-6
mpway45_cell47 ML45 gate_way45_cell47 GND ML45 p1 W=2.4e-6 L=1e-6
mnway45_cell48 ML45 gate_way45_cell48 GND GND n1 W=1e-6 L=1e-6
mpway45_cell48 ML45 gate_way45_cell48 GND ML45 p1 W=2.4e-6 L=1e-6
mnway45_cell49 ML45 gate_way45_cell49 GND GND n1 W=1e-6 L=1e-6
mpway45_cell49 ML45 gate_way45_cell49 GND ML45 p1 W=2.4e-6 L=1e-6
mnway45_cell50 ML45 gate_way45_cell50 GND GND n1 W=1e-6 L=1e-6
mpway45_cell50 ML45 gate_way45_cell50 GND ML45 p1 W=2.4e-6 L=1e-6
mnway45_cell51 ML45 gate_way45_cell51 GND GND n1 W=1e-6 L=1e-6
mpway45_cell51 ML45 gate_way45_cell51 GND ML45 p1 W=2.4e-6 L=1e-6
mnway45_cell52 ML45 gate_way45_cell52 GND GND n1 W=1e-6 L=1e-6
mpway45_cell52 ML45 gate_way45_cell52 GND ML45 p1 W=2.4e-6 L=1e-6
mnway45_cell53 ML45 gate_way45_cell53 GND GND n1 W=1e-6 L=1e-6
mpway45_cell53 ML45 gate_way45_cell53 GND ML45 p1 W=2.4e-6 L=1e-6
mnway45_cell54 ML45 gate_way45_cell54 GND GND n1 W=1e-6 L=1e-6
mpway45_cell54 ML45 gate_way45_cell54 GND ML45 p1 W=2.4e-6 L=1e-6
mnway45_cell55 ML45 gate_way45_cell55 GND GND n1 W=1e-6 L=1e-6
mpway45_cell55 ML45 gate_way45_cell55 GND ML45 p1 W=2.4e-6 L=1e-6
mnway45_cell56 ML45 gate_way45_cell56 GND GND n1 W=1e-6 L=1e-6
mpway45_cell56 ML45 gate_way45_cell56 GND ML45 p1 W=2.4e-6 L=1e-6
mnway45_cell57 ML45 gate_way45_cell57 GND GND n1 W=1e-6 L=1e-6
mpway45_cell57 ML45 gate_way45_cell57 GND ML45 p1 W=2.4e-6 L=1e-6
mnway45_cell58 ML45 gate_way45_cell58 GND GND n1 W=1e-6 L=1e-6
mpway45_cell58 ML45 gate_way45_cell58 GND ML45 p1 W=2.4e-6 L=1e-6
mnway45_cell59 ML45 gate_way45_cell59 GND GND n1 W=1e-6 L=1e-6
mpway45_cell59 ML45 gate_way45_cell59 GND ML45 p1 W=2.4e-6 L=1e-6
mnway45_cell60 ML45 gate_way45_cell60 GND GND n1 W=1e-6 L=1e-6
mpway45_cell60 ML45 gate_way45_cell60 GND ML45 p1 W=2.4e-6 L=1e-6
mnway45_cell61 ML45 gate_way45_cell61 GND GND n1 W=1e-6 L=1e-6
mpway45_cell61 ML45 gate_way45_cell61 GND ML45 p1 W=2.4e-6 L=1e-6
mnway45_cell62 ML45 gate_way45_cell62 GND GND n1 W=1e-6 L=1e-6
mpway45_cell62 ML45 gate_way45_cell62 GND ML45 p1 W=2.4e-6 L=1e-6
mnway45_cell63 ML45 gate_way45_cell63 GND GND n1 W=1e-6 L=1e-6
mpway45_cell63 ML45 gate_way45_cell63 GND ML45 p1 W=2.4e-6 L=1e-6
mnway45_cell64 ML45 gate_way45_cell64 GND GND n1 W=1e-6 L=1e-6
mpway45_cell64 ML45 gate_way45_cell64 GND ML45 p1 W=2.4e-6 L=1e-6
mnway45_cell65 ML45 gate_way45_cell65 GND GND n1 W=1e-6 L=1e-6
mpway45_cell65 ML45 gate_way45_cell65 GND ML45 p1 W=2.4e-6 L=1e-6
mnway45_cell66 ML45 gate_way45_cell66 GND GND n1 W=1e-6 L=1e-6
mpway45_cell66 ML45 gate_way45_cell66 GND ML45 p1 W=2.4e-6 L=1e-6
mnway45_cell67 ML45 gate_way45_cell67 GND GND n1 W=1e-6 L=1e-6
mpway45_cell67 ML45 gate_way45_cell67 GND ML45 p1 W=2.4e-6 L=1e-6
mnway45_cell68 ML45 gate_way45_cell68 GND GND n1 W=1e-6 L=1e-6
mpway45_cell68 ML45 gate_way45_cell68 GND ML45 p1 W=2.4e-6 L=1e-6
mnway45_cell69 ML45 gate_way45_cell69 GND GND n1 W=1e-6 L=1e-6
mpway45_cell69 ML45 gate_way45_cell69 GND ML45 p1 W=2.4e-6 L=1e-6
mnway45_cell70 ML45 gate_way45_cell70 GND GND n1 W=1e-6 L=1e-6
mpway45_cell70 ML45 gate_way45_cell70 GND ML45 p1 W=2.4e-6 L=1e-6
mnway45_cell71 ML45 gate_way45_cell71 GND GND n1 W=1e-6 L=1e-6
mpway45_cell71 ML45 gate_way45_cell71 GND ML45 p1 W=2.4e-6 L=1e-6
mnway45_cell72 ML45 gate_way45_cell72 GND GND n1 W=1e-6 L=1e-6
mpway45_cell72 ML45 gate_way45_cell72 GND ML45 p1 W=2.4e-6 L=1e-6
mnway45_cell73 ML45 gate_way45_cell73 GND GND n1 W=1e-6 L=1e-6
mpway45_cell73 ML45 gate_way45_cell73 GND ML45 p1 W=2.4e-6 L=1e-6
mnway45_cell74 ML45 gate_way45_cell74 GND GND n1 W=1e-6 L=1e-6
mpway45_cell74 ML45 gate_way45_cell74 GND ML45 p1 W=2.4e-6 L=1e-6
mnway45_cell75 ML45 gate_way45_cell75 GND GND n1 W=1e-6 L=1e-6
mpway45_cell75 ML45 gate_way45_cell75 GND ML45 p1 W=2.4e-6 L=1e-6
mnway45_cell76 ML45 gate_way45_cell76 GND GND n1 W=1e-6 L=1e-6
mpway45_cell76 ML45 gate_way45_cell76 GND ML45 p1 W=2.4e-6 L=1e-6
mnway45_cell77 ML45 gate_way45_cell77 GND GND n1 W=1e-6 L=1e-6
mpway45_cell77 ML45 gate_way45_cell77 GND ML45 p1 W=2.4e-6 L=1e-6
mnway45_cell78 ML45 gate_way45_cell78 GND GND n1 W=1e-6 L=1e-6
mpway45_cell78 ML45 gate_way45_cell78 GND ML45 p1 W=2.4e-6 L=1e-6
mnway45_cell79 ML45 gate_way45_cell79 GND GND n1 W=1e-6 L=1e-6
mpway45_cell79 ML45 gate_way45_cell79 GND ML45 p1 W=2.4e-6 L=1e-6
mnway45_cell80 ML45 gate_way45_cell80 GND GND n1 W=1e-6 L=1e-6
mpway45_cell80 ML45 gate_way45_cell80 GND ML45 p1 W=2.4e-6 L=1e-6
mnway45_cell81 ML45 gate_way45_cell81 GND GND n1 W=1e-6 L=1e-6
mpway45_cell81 ML45 gate_way45_cell81 GND ML45 p1 W=2.4e-6 L=1e-6
mnway45_cell82 ML45 gate_way45_cell82 GND GND n1 W=1e-6 L=1e-6
mpway45_cell82 ML45 gate_way45_cell82 GND ML45 p1 W=2.4e-6 L=1e-6
mnway45_cell83 ML45 gate_way45_cell83 GND GND n1 W=1e-6 L=1e-6
mpway45_cell83 ML45 gate_way45_cell83 GND ML45 p1 W=2.4e-6 L=1e-6
mnway45_cell84 ML45 gate_way45_cell84 GND GND n1 W=1e-6 L=1e-6
mpway45_cell84 ML45 gate_way45_cell84 GND ML45 p1 W=2.4e-6 L=1e-6
mnway45_cell85 ML45 gate_way45_cell85 GND GND n1 W=1e-6 L=1e-6
mpway45_cell85 ML45 gate_way45_cell85 GND ML45 p1 W=2.4e-6 L=1e-6
mnway45_cell86 ML45 gate_way45_cell86 GND GND n1 W=1e-6 L=1e-6
mpway45_cell86 ML45 gate_way45_cell86 GND ML45 p1 W=2.4e-6 L=1e-6
mnway45_cell87 ML45 gate_way45_cell87 GND GND n1 W=1e-6 L=1e-6
mpway45_cell87 ML45 gate_way45_cell87 GND ML45 p1 W=2.4e-6 L=1e-6
mnway45_cell88 ML45 gate_way45_cell88 GND GND n1 W=1e-6 L=1e-6
mpway45_cell88 ML45 gate_way45_cell88 GND ML45 p1 W=2.4e-6 L=1e-6
mnway45_cell89 ML45 gate_way45_cell89 GND GND n1 W=1e-6 L=1e-6
mpway45_cell89 ML45 gate_way45_cell89 GND ML45 p1 W=2.4e-6 L=1e-6
mnway45_cell90 ML45 gate_way45_cell90 GND GND n1 W=1e-6 L=1e-6
mpway45_cell90 ML45 gate_way45_cell90 GND ML45 p1 W=2.4e-6 L=1e-6
mnway45_cell91 ML45 gate_way45_cell91 GND GND n1 W=1e-6 L=1e-6
mpway45_cell91 ML45 gate_way45_cell91 GND ML45 p1 W=2.4e-6 L=1e-6
mnway45_cell92 ML45 gate_way45_cell92 GND GND n1 W=1e-6 L=1e-6
mpway45_cell92 ML45 gate_way45_cell92 GND ML45 p1 W=2.4e-6 L=1e-6
mnway45_cell93 ML45 gate_way45_cell93 GND GND n1 W=1e-6 L=1e-6
mpway45_cell93 ML45 gate_way45_cell93 GND ML45 p1 W=2.4e-6 L=1e-6
mnway45_cell94 ML45 gate_way45_cell94 GND GND n1 W=1e-6 L=1e-6
mpway45_cell94 ML45 gate_way45_cell94 GND ML45 p1 W=2.4e-6 L=1e-6
mnway45_cell95 ML45 gate_way45_cell95 GND GND n1 W=1e-6 L=1e-6
mpway45_cell95 ML45 gate_way45_cell95 GND ML45 p1 W=2.4e-6 L=1e-6
mnway45_cell96 ML45 gate_way45_cell96 GND GND n1 W=1e-6 L=1e-6
mpway45_cell96 ML45 gate_way45_cell96 GND ML45 p1 W=2.4e-6 L=1e-6
mnway45_cell97 ML45 gate_way45_cell97 GND GND n1 W=1e-6 L=1e-6
mpway45_cell97 ML45 gate_way45_cell97 GND ML45 p1 W=2.4e-6 L=1e-6
mnway45_cell98 ML45 gate_way45_cell98 GND GND n1 W=1e-6 L=1e-6
mpway45_cell98 ML45 gate_way45_cell98 GND ML45 p1 W=2.4e-6 L=1e-6
mnway45_cell99 ML45 gate_way45_cell99 GND GND n1 W=1e-6 L=1e-6
mpway45_cell99 ML45 gate_way45_cell99 GND ML45 p1 W=2.4e-6 L=1e-6
mnway46_cell0 ML46 gate_way46_cell0 GND GND n1 W=1e-6 L=1e-6
mpway46_cell0 ML46 gate_way46_cell0 GND ML46 p1 W=2.4e-6 L=1e-6
mnway46_cell1 ML46 gate_way46_cell1 GND GND n1 W=1e-6 L=1e-6
mpway46_cell1 ML46 gate_way46_cell1 GND ML46 p1 W=2.4e-6 L=1e-6
mnway46_cell2 ML46 gate_way46_cell2 GND GND n1 W=1e-6 L=1e-6
mpway46_cell2 ML46 gate_way46_cell2 GND ML46 p1 W=2.4e-6 L=1e-6
mnway46_cell3 ML46 gate_way46_cell3 GND GND n1 W=1e-6 L=1e-6
mpway46_cell3 ML46 gate_way46_cell3 GND ML46 p1 W=2.4e-6 L=1e-6
mnway46_cell4 ML46 gate_way46_cell4 GND GND n1 W=1e-6 L=1e-6
mpway46_cell4 ML46 gate_way46_cell4 GND ML46 p1 W=2.4e-6 L=1e-6
mnway46_cell5 ML46 gate_way46_cell5 GND GND n1 W=1e-6 L=1e-6
mpway46_cell5 ML46 gate_way46_cell5 GND ML46 p1 W=2.4e-6 L=1e-6
mnway46_cell6 ML46 gate_way46_cell6 GND GND n1 W=1e-6 L=1e-6
mpway46_cell6 ML46 gate_way46_cell6 GND ML46 p1 W=2.4e-6 L=1e-6
mnway46_cell7 ML46 gate_way46_cell7 GND GND n1 W=1e-6 L=1e-6
mpway46_cell7 ML46 gate_way46_cell7 GND ML46 p1 W=2.4e-6 L=1e-6
mnway46_cell8 ML46 gate_way46_cell8 GND GND n1 W=1e-6 L=1e-6
mpway46_cell8 ML46 gate_way46_cell8 GND ML46 p1 W=2.4e-6 L=1e-6
mnway46_cell9 ML46 gate_way46_cell9 GND GND n1 W=1e-6 L=1e-6
mpway46_cell9 ML46 gate_way46_cell9 GND ML46 p1 W=2.4e-6 L=1e-6
mnway46_cell10 ML46 gate_way46_cell10 GND GND n1 W=1e-6 L=1e-6
mpway46_cell10 ML46 gate_way46_cell10 GND ML46 p1 W=2.4e-6 L=1e-6
mnway46_cell11 ML46 gate_way46_cell11 GND GND n1 W=1e-6 L=1e-6
mpway46_cell11 ML46 gate_way46_cell11 GND ML46 p1 W=2.4e-6 L=1e-6
mnway46_cell12 ML46 gate_way46_cell12 GND GND n1 W=1e-6 L=1e-6
mpway46_cell12 ML46 gate_way46_cell12 GND ML46 p1 W=2.4e-6 L=1e-6
mnway46_cell13 ML46 gate_way46_cell13 GND GND n1 W=1e-6 L=1e-6
mpway46_cell13 ML46 gate_way46_cell13 GND ML46 p1 W=2.4e-6 L=1e-6
mnway46_cell14 ML46 gate_way46_cell14 GND GND n1 W=1e-6 L=1e-6
mpway46_cell14 ML46 gate_way46_cell14 GND ML46 p1 W=2.4e-6 L=1e-6
mnway46_cell15 ML46 gate_way46_cell15 GND GND n1 W=1e-6 L=1e-6
mpway46_cell15 ML46 gate_way46_cell15 GND ML46 p1 W=2.4e-6 L=1e-6
mnway46_cell16 ML46 gate_way46_cell16 GND GND n1 W=1e-6 L=1e-6
mpway46_cell16 ML46 gate_way46_cell16 GND ML46 p1 W=2.4e-6 L=1e-6
mnway46_cell17 ML46 gate_way46_cell17 GND GND n1 W=1e-6 L=1e-6
mpway46_cell17 ML46 gate_way46_cell17 GND ML46 p1 W=2.4e-6 L=1e-6
mnway46_cell18 ML46 gate_way46_cell18 GND GND n1 W=1e-6 L=1e-6
mpway46_cell18 ML46 gate_way46_cell18 GND ML46 p1 W=2.4e-6 L=1e-6
mnway46_cell19 ML46 gate_way46_cell19 GND GND n1 W=1e-6 L=1e-6
mpway46_cell19 ML46 gate_way46_cell19 GND ML46 p1 W=2.4e-6 L=1e-6
mnway46_cell20 ML46 gate_way46_cell20 GND GND n1 W=1e-6 L=1e-6
mpway46_cell20 ML46 gate_way46_cell20 GND ML46 p1 W=2.4e-6 L=1e-6
mnway46_cell21 ML46 gate_way46_cell21 GND GND n1 W=1e-6 L=1e-6
mpway46_cell21 ML46 gate_way46_cell21 GND ML46 p1 W=2.4e-6 L=1e-6
mnway46_cell22 ML46 gate_way46_cell22 GND GND n1 W=1e-6 L=1e-6
mpway46_cell22 ML46 gate_way46_cell22 GND ML46 p1 W=2.4e-6 L=1e-6
mnway46_cell23 ML46 gate_way46_cell23 GND GND n1 W=1e-6 L=1e-6
mpway46_cell23 ML46 gate_way46_cell23 GND ML46 p1 W=2.4e-6 L=1e-6
mnway46_cell24 ML46 gate_way46_cell24 GND GND n1 W=1e-6 L=1e-6
mpway46_cell24 ML46 gate_way46_cell24 GND ML46 p1 W=2.4e-6 L=1e-6
mnway46_cell25 ML46 gate_way46_cell25 GND GND n1 W=1e-6 L=1e-6
mpway46_cell25 ML46 gate_way46_cell25 GND ML46 p1 W=2.4e-6 L=1e-6
mnway46_cell26 ML46 gate_way46_cell26 GND GND n1 W=1e-6 L=1e-6
mpway46_cell26 ML46 gate_way46_cell26 GND ML46 p1 W=2.4e-6 L=1e-6
mnway46_cell27 ML46 gate_way46_cell27 GND GND n1 W=1e-6 L=1e-6
mpway46_cell27 ML46 gate_way46_cell27 GND ML46 p1 W=2.4e-6 L=1e-6
mnway46_cell28 ML46 gate_way46_cell28 GND GND n1 W=1e-6 L=1e-6
mpway46_cell28 ML46 gate_way46_cell28 GND ML46 p1 W=2.4e-6 L=1e-6
mnway46_cell29 ML46 gate_way46_cell29 GND GND n1 W=1e-6 L=1e-6
mpway46_cell29 ML46 gate_way46_cell29 GND ML46 p1 W=2.4e-6 L=1e-6
mnway46_cell30 ML46 gate_way46_cell30 GND GND n1 W=1e-6 L=1e-6
mpway46_cell30 ML46 gate_way46_cell30 GND ML46 p1 W=2.4e-6 L=1e-6
mnway46_cell31 ML46 gate_way46_cell31 GND GND n1 W=1e-6 L=1e-6
mpway46_cell31 ML46 gate_way46_cell31 GND ML46 p1 W=2.4e-6 L=1e-6
mnway46_cell32 ML46 gate_way46_cell32 GND GND n1 W=1e-6 L=1e-6
mpway46_cell32 ML46 gate_way46_cell32 GND ML46 p1 W=2.4e-6 L=1e-6
mnway46_cell33 ML46 gate_way46_cell33 GND GND n1 W=1e-6 L=1e-6
mpway46_cell33 ML46 gate_way46_cell33 GND ML46 p1 W=2.4e-6 L=1e-6
mnway46_cell34 ML46 gate_way46_cell34 GND GND n1 W=1e-6 L=1e-6
mpway46_cell34 ML46 gate_way46_cell34 GND ML46 p1 W=2.4e-6 L=1e-6
mnway46_cell35 ML46 gate_way46_cell35 GND GND n1 W=1e-6 L=1e-6
mpway46_cell35 ML46 gate_way46_cell35 GND ML46 p1 W=2.4e-6 L=1e-6
mnway46_cell36 ML46 gate_way46_cell36 GND GND n1 W=1e-6 L=1e-6
mpway46_cell36 ML46 gate_way46_cell36 GND ML46 p1 W=2.4e-6 L=1e-6
mnway46_cell37 ML46 gate_way46_cell37 GND GND n1 W=1e-6 L=1e-6
mpway46_cell37 ML46 gate_way46_cell37 GND ML46 p1 W=2.4e-6 L=1e-6
mnway46_cell38 ML46 gate_way46_cell38 GND GND n1 W=1e-6 L=1e-6
mpway46_cell38 ML46 gate_way46_cell38 GND ML46 p1 W=2.4e-6 L=1e-6
mnway46_cell39 ML46 gate_way46_cell39 GND GND n1 W=1e-6 L=1e-6
mpway46_cell39 ML46 gate_way46_cell39 GND ML46 p1 W=2.4e-6 L=1e-6
mnway46_cell40 ML46 gate_way46_cell40 GND GND n1 W=1e-6 L=1e-6
mpway46_cell40 ML46 gate_way46_cell40 GND ML46 p1 W=2.4e-6 L=1e-6
mnway46_cell41 ML46 gate_way46_cell41 GND GND n1 W=1e-6 L=1e-6
mpway46_cell41 ML46 gate_way46_cell41 GND ML46 p1 W=2.4e-6 L=1e-6
mnway46_cell42 ML46 gate_way46_cell42 GND GND n1 W=1e-6 L=1e-6
mpway46_cell42 ML46 gate_way46_cell42 GND ML46 p1 W=2.4e-6 L=1e-6
mnway46_cell43 ML46 gate_way46_cell43 GND GND n1 W=1e-6 L=1e-6
mpway46_cell43 ML46 gate_way46_cell43 GND ML46 p1 W=2.4e-6 L=1e-6
mnway46_cell44 ML46 gate_way46_cell44 GND GND n1 W=1e-6 L=1e-6
mpway46_cell44 ML46 gate_way46_cell44 GND ML46 p1 W=2.4e-6 L=1e-6
mnway46_cell45 ML46 gate_way46_cell45 GND GND n1 W=1e-6 L=1e-6
mpway46_cell45 ML46 gate_way46_cell45 GND ML46 p1 W=2.4e-6 L=1e-6
mnway46_cell46 ML46 gate_way46_cell46 GND GND n1 W=1e-6 L=1e-6
mpway46_cell46 ML46 gate_way46_cell46 GND ML46 p1 W=2.4e-6 L=1e-6
mnway46_cell47 ML46 gate_way46_cell47 GND GND n1 W=1e-6 L=1e-6
mpway46_cell47 ML46 gate_way46_cell47 GND ML46 p1 W=2.4e-6 L=1e-6
mnway46_cell48 ML46 gate_way46_cell48 GND GND n1 W=1e-6 L=1e-6
mpway46_cell48 ML46 gate_way46_cell48 GND ML46 p1 W=2.4e-6 L=1e-6
mnway46_cell49 ML46 gate_way46_cell49 GND GND n1 W=1e-6 L=1e-6
mpway46_cell49 ML46 gate_way46_cell49 GND ML46 p1 W=2.4e-6 L=1e-6
mnway46_cell50 ML46 gate_way46_cell50 GND GND n1 W=1e-6 L=1e-6
mpway46_cell50 ML46 gate_way46_cell50 GND ML46 p1 W=2.4e-6 L=1e-6
mnway46_cell51 ML46 gate_way46_cell51 GND GND n1 W=1e-6 L=1e-6
mpway46_cell51 ML46 gate_way46_cell51 GND ML46 p1 W=2.4e-6 L=1e-6
mnway46_cell52 ML46 gate_way46_cell52 GND GND n1 W=1e-6 L=1e-6
mpway46_cell52 ML46 gate_way46_cell52 GND ML46 p1 W=2.4e-6 L=1e-6
mnway46_cell53 ML46 gate_way46_cell53 GND GND n1 W=1e-6 L=1e-6
mpway46_cell53 ML46 gate_way46_cell53 GND ML46 p1 W=2.4e-6 L=1e-6
mnway46_cell54 ML46 gate_way46_cell54 GND GND n1 W=1e-6 L=1e-6
mpway46_cell54 ML46 gate_way46_cell54 GND ML46 p1 W=2.4e-6 L=1e-6
mnway46_cell55 ML46 gate_way46_cell55 GND GND n1 W=1e-6 L=1e-6
mpway46_cell55 ML46 gate_way46_cell55 GND ML46 p1 W=2.4e-6 L=1e-6
mnway46_cell56 ML46 gate_way46_cell56 GND GND n1 W=1e-6 L=1e-6
mpway46_cell56 ML46 gate_way46_cell56 GND ML46 p1 W=2.4e-6 L=1e-6
mnway46_cell57 ML46 gate_way46_cell57 GND GND n1 W=1e-6 L=1e-6
mpway46_cell57 ML46 gate_way46_cell57 GND ML46 p1 W=2.4e-6 L=1e-6
mnway46_cell58 ML46 gate_way46_cell58 GND GND n1 W=1e-6 L=1e-6
mpway46_cell58 ML46 gate_way46_cell58 GND ML46 p1 W=2.4e-6 L=1e-6
mnway46_cell59 ML46 gate_way46_cell59 GND GND n1 W=1e-6 L=1e-6
mpway46_cell59 ML46 gate_way46_cell59 GND ML46 p1 W=2.4e-6 L=1e-6
mnway46_cell60 ML46 gate_way46_cell60 GND GND n1 W=1e-6 L=1e-6
mpway46_cell60 ML46 gate_way46_cell60 GND ML46 p1 W=2.4e-6 L=1e-6
mnway46_cell61 ML46 gate_way46_cell61 GND GND n1 W=1e-6 L=1e-6
mpway46_cell61 ML46 gate_way46_cell61 GND ML46 p1 W=2.4e-6 L=1e-6
mnway46_cell62 ML46 gate_way46_cell62 GND GND n1 W=1e-6 L=1e-6
mpway46_cell62 ML46 gate_way46_cell62 GND ML46 p1 W=2.4e-6 L=1e-6
mnway46_cell63 ML46 gate_way46_cell63 GND GND n1 W=1e-6 L=1e-6
mpway46_cell63 ML46 gate_way46_cell63 GND ML46 p1 W=2.4e-6 L=1e-6
mnway46_cell64 ML46 gate_way46_cell64 GND GND n1 W=1e-6 L=1e-6
mpway46_cell64 ML46 gate_way46_cell64 GND ML46 p1 W=2.4e-6 L=1e-6
mnway46_cell65 ML46 gate_way46_cell65 GND GND n1 W=1e-6 L=1e-6
mpway46_cell65 ML46 gate_way46_cell65 GND ML46 p1 W=2.4e-6 L=1e-6
mnway46_cell66 ML46 gate_way46_cell66 GND GND n1 W=1e-6 L=1e-6
mpway46_cell66 ML46 gate_way46_cell66 GND ML46 p1 W=2.4e-6 L=1e-6
mnway46_cell67 ML46 gate_way46_cell67 GND GND n1 W=1e-6 L=1e-6
mpway46_cell67 ML46 gate_way46_cell67 GND ML46 p1 W=2.4e-6 L=1e-6
mnway46_cell68 ML46 gate_way46_cell68 GND GND n1 W=1e-6 L=1e-6
mpway46_cell68 ML46 gate_way46_cell68 GND ML46 p1 W=2.4e-6 L=1e-6
mnway46_cell69 ML46 gate_way46_cell69 GND GND n1 W=1e-6 L=1e-6
mpway46_cell69 ML46 gate_way46_cell69 GND ML46 p1 W=2.4e-6 L=1e-6
mnway46_cell70 ML46 gate_way46_cell70 GND GND n1 W=1e-6 L=1e-6
mpway46_cell70 ML46 gate_way46_cell70 GND ML46 p1 W=2.4e-6 L=1e-6
mnway46_cell71 ML46 gate_way46_cell71 GND GND n1 W=1e-6 L=1e-6
mpway46_cell71 ML46 gate_way46_cell71 GND ML46 p1 W=2.4e-6 L=1e-6
mnway46_cell72 ML46 gate_way46_cell72 GND GND n1 W=1e-6 L=1e-6
mpway46_cell72 ML46 gate_way46_cell72 GND ML46 p1 W=2.4e-6 L=1e-6
mnway46_cell73 ML46 gate_way46_cell73 GND GND n1 W=1e-6 L=1e-6
mpway46_cell73 ML46 gate_way46_cell73 GND ML46 p1 W=2.4e-6 L=1e-6
mnway46_cell74 ML46 gate_way46_cell74 GND GND n1 W=1e-6 L=1e-6
mpway46_cell74 ML46 gate_way46_cell74 GND ML46 p1 W=2.4e-6 L=1e-6
mnway46_cell75 ML46 gate_way46_cell75 GND GND n1 W=1e-6 L=1e-6
mpway46_cell75 ML46 gate_way46_cell75 GND ML46 p1 W=2.4e-6 L=1e-6
mnway46_cell76 ML46 gate_way46_cell76 GND GND n1 W=1e-6 L=1e-6
mpway46_cell76 ML46 gate_way46_cell76 GND ML46 p1 W=2.4e-6 L=1e-6
mnway46_cell77 ML46 gate_way46_cell77 GND GND n1 W=1e-6 L=1e-6
mpway46_cell77 ML46 gate_way46_cell77 GND ML46 p1 W=2.4e-6 L=1e-6
mnway46_cell78 ML46 gate_way46_cell78 GND GND n1 W=1e-6 L=1e-6
mpway46_cell78 ML46 gate_way46_cell78 GND ML46 p1 W=2.4e-6 L=1e-6
mnway46_cell79 ML46 gate_way46_cell79 GND GND n1 W=1e-6 L=1e-6
mpway46_cell79 ML46 gate_way46_cell79 GND ML46 p1 W=2.4e-6 L=1e-6
mnway46_cell80 ML46 gate_way46_cell80 GND GND n1 W=1e-6 L=1e-6
mpway46_cell80 ML46 gate_way46_cell80 GND ML46 p1 W=2.4e-6 L=1e-6
mnway46_cell81 ML46 gate_way46_cell81 GND GND n1 W=1e-6 L=1e-6
mpway46_cell81 ML46 gate_way46_cell81 GND ML46 p1 W=2.4e-6 L=1e-6
mnway46_cell82 ML46 gate_way46_cell82 GND GND n1 W=1e-6 L=1e-6
mpway46_cell82 ML46 gate_way46_cell82 GND ML46 p1 W=2.4e-6 L=1e-6
mnway46_cell83 ML46 gate_way46_cell83 GND GND n1 W=1e-6 L=1e-6
mpway46_cell83 ML46 gate_way46_cell83 GND ML46 p1 W=2.4e-6 L=1e-6
mnway46_cell84 ML46 gate_way46_cell84 GND GND n1 W=1e-6 L=1e-6
mpway46_cell84 ML46 gate_way46_cell84 GND ML46 p1 W=2.4e-6 L=1e-6
mnway46_cell85 ML46 gate_way46_cell85 GND GND n1 W=1e-6 L=1e-6
mpway46_cell85 ML46 gate_way46_cell85 GND ML46 p1 W=2.4e-6 L=1e-6
mnway46_cell86 ML46 gate_way46_cell86 GND GND n1 W=1e-6 L=1e-6
mpway46_cell86 ML46 gate_way46_cell86 GND ML46 p1 W=2.4e-6 L=1e-6
mnway46_cell87 ML46 gate_way46_cell87 GND GND n1 W=1e-6 L=1e-6
mpway46_cell87 ML46 gate_way46_cell87 GND ML46 p1 W=2.4e-6 L=1e-6
mnway46_cell88 ML46 gate_way46_cell88 GND GND n1 W=1e-6 L=1e-6
mpway46_cell88 ML46 gate_way46_cell88 GND ML46 p1 W=2.4e-6 L=1e-6
mnway46_cell89 ML46 gate_way46_cell89 GND GND n1 W=1e-6 L=1e-6
mpway46_cell89 ML46 gate_way46_cell89 GND ML46 p1 W=2.4e-6 L=1e-6
mnway46_cell90 ML46 gate_way46_cell90 GND GND n1 W=1e-6 L=1e-6
mpway46_cell90 ML46 gate_way46_cell90 GND ML46 p1 W=2.4e-6 L=1e-6
mnway46_cell91 ML46 gate_way46_cell91 GND GND n1 W=1e-6 L=1e-6
mpway46_cell91 ML46 gate_way46_cell91 GND ML46 p1 W=2.4e-6 L=1e-6
mnway46_cell92 ML46 gate_way46_cell92 GND GND n1 W=1e-6 L=1e-6
mpway46_cell92 ML46 gate_way46_cell92 GND ML46 p1 W=2.4e-6 L=1e-6
mnway46_cell93 ML46 gate_way46_cell93 GND GND n1 W=1e-6 L=1e-6
mpway46_cell93 ML46 gate_way46_cell93 GND ML46 p1 W=2.4e-6 L=1e-6
mnway46_cell94 ML46 gate_way46_cell94 GND GND n1 W=1e-6 L=1e-6
mpway46_cell94 ML46 gate_way46_cell94 GND ML46 p1 W=2.4e-6 L=1e-6
mnway46_cell95 ML46 gate_way46_cell95 GND GND n1 W=1e-6 L=1e-6
mpway46_cell95 ML46 gate_way46_cell95 GND ML46 p1 W=2.4e-6 L=1e-6
mnway46_cell96 ML46 gate_way46_cell96 GND GND n1 W=1e-6 L=1e-6
mpway46_cell96 ML46 gate_way46_cell96 GND ML46 p1 W=2.4e-6 L=1e-6
mnway46_cell97 ML46 gate_way46_cell97 GND GND n1 W=1e-6 L=1e-6
mpway46_cell97 ML46 gate_way46_cell97 GND ML46 p1 W=2.4e-6 L=1e-6
mnway46_cell98 ML46 gate_way46_cell98 GND GND n1 W=1e-6 L=1e-6
mpway46_cell98 ML46 gate_way46_cell98 GND ML46 p1 W=2.4e-6 L=1e-6
mnway46_cell99 ML46 gate_way46_cell99 GND GND n1 W=1e-6 L=1e-6
mpway46_cell99 ML46 gate_way46_cell99 GND ML46 p1 W=2.4e-6 L=1e-6
mnway47_cell0 ML47 gate_way47_cell0 GND GND n1 W=1e-6 L=1e-6
mpway47_cell0 ML47 gate_way47_cell0 GND ML47 p1 W=2.4e-6 L=1e-6
mnway47_cell1 ML47 gate_way47_cell1 GND GND n1 W=1e-6 L=1e-6
mpway47_cell1 ML47 gate_way47_cell1 GND ML47 p1 W=2.4e-6 L=1e-6
mnway47_cell2 ML47 gate_way47_cell2 GND GND n1 W=1e-6 L=1e-6
mpway47_cell2 ML47 gate_way47_cell2 GND ML47 p1 W=2.4e-6 L=1e-6
mnway47_cell3 ML47 gate_way47_cell3 GND GND n1 W=1e-6 L=1e-6
mpway47_cell3 ML47 gate_way47_cell3 GND ML47 p1 W=2.4e-6 L=1e-6
mnway47_cell4 ML47 gate_way47_cell4 GND GND n1 W=1e-6 L=1e-6
mpway47_cell4 ML47 gate_way47_cell4 GND ML47 p1 W=2.4e-6 L=1e-6
mnway47_cell5 ML47 gate_way47_cell5 GND GND n1 W=1e-6 L=1e-6
mpway47_cell5 ML47 gate_way47_cell5 GND ML47 p1 W=2.4e-6 L=1e-6
mnway47_cell6 ML47 gate_way47_cell6 GND GND n1 W=1e-6 L=1e-6
mpway47_cell6 ML47 gate_way47_cell6 GND ML47 p1 W=2.4e-6 L=1e-6
mnway47_cell7 ML47 gate_way47_cell7 GND GND n1 W=1e-6 L=1e-6
mpway47_cell7 ML47 gate_way47_cell7 GND ML47 p1 W=2.4e-6 L=1e-6
mnway47_cell8 ML47 gate_way47_cell8 GND GND n1 W=1e-6 L=1e-6
mpway47_cell8 ML47 gate_way47_cell8 GND ML47 p1 W=2.4e-6 L=1e-6
mnway47_cell9 ML47 gate_way47_cell9 GND GND n1 W=1e-6 L=1e-6
mpway47_cell9 ML47 gate_way47_cell9 GND ML47 p1 W=2.4e-6 L=1e-6
mnway47_cell10 ML47 gate_way47_cell10 GND GND n1 W=1e-6 L=1e-6
mpway47_cell10 ML47 gate_way47_cell10 GND ML47 p1 W=2.4e-6 L=1e-6
mnway47_cell11 ML47 gate_way47_cell11 GND GND n1 W=1e-6 L=1e-6
mpway47_cell11 ML47 gate_way47_cell11 GND ML47 p1 W=2.4e-6 L=1e-6
mnway47_cell12 ML47 gate_way47_cell12 GND GND n1 W=1e-6 L=1e-6
mpway47_cell12 ML47 gate_way47_cell12 GND ML47 p1 W=2.4e-6 L=1e-6
mnway47_cell13 ML47 gate_way47_cell13 GND GND n1 W=1e-6 L=1e-6
mpway47_cell13 ML47 gate_way47_cell13 GND ML47 p1 W=2.4e-6 L=1e-6
mnway47_cell14 ML47 gate_way47_cell14 GND GND n1 W=1e-6 L=1e-6
mpway47_cell14 ML47 gate_way47_cell14 GND ML47 p1 W=2.4e-6 L=1e-6
mnway47_cell15 ML47 gate_way47_cell15 GND GND n1 W=1e-6 L=1e-6
mpway47_cell15 ML47 gate_way47_cell15 GND ML47 p1 W=2.4e-6 L=1e-6
mnway47_cell16 ML47 gate_way47_cell16 GND GND n1 W=1e-6 L=1e-6
mpway47_cell16 ML47 gate_way47_cell16 GND ML47 p1 W=2.4e-6 L=1e-6
mnway47_cell17 ML47 gate_way47_cell17 GND GND n1 W=1e-6 L=1e-6
mpway47_cell17 ML47 gate_way47_cell17 GND ML47 p1 W=2.4e-6 L=1e-6
mnway47_cell18 ML47 gate_way47_cell18 GND GND n1 W=1e-6 L=1e-6
mpway47_cell18 ML47 gate_way47_cell18 GND ML47 p1 W=2.4e-6 L=1e-6
mnway47_cell19 ML47 gate_way47_cell19 GND GND n1 W=1e-6 L=1e-6
mpway47_cell19 ML47 gate_way47_cell19 GND ML47 p1 W=2.4e-6 L=1e-6
mnway47_cell20 ML47 gate_way47_cell20 GND GND n1 W=1e-6 L=1e-6
mpway47_cell20 ML47 gate_way47_cell20 GND ML47 p1 W=2.4e-6 L=1e-6
mnway47_cell21 ML47 gate_way47_cell21 GND GND n1 W=1e-6 L=1e-6
mpway47_cell21 ML47 gate_way47_cell21 GND ML47 p1 W=2.4e-6 L=1e-6
mnway47_cell22 ML47 gate_way47_cell22 GND GND n1 W=1e-6 L=1e-6
mpway47_cell22 ML47 gate_way47_cell22 GND ML47 p1 W=2.4e-6 L=1e-6
mnway47_cell23 ML47 gate_way47_cell23 GND GND n1 W=1e-6 L=1e-6
mpway47_cell23 ML47 gate_way47_cell23 GND ML47 p1 W=2.4e-6 L=1e-6
mnway47_cell24 ML47 gate_way47_cell24 GND GND n1 W=1e-6 L=1e-6
mpway47_cell24 ML47 gate_way47_cell24 GND ML47 p1 W=2.4e-6 L=1e-6
mnway47_cell25 ML47 gate_way47_cell25 GND GND n1 W=1e-6 L=1e-6
mpway47_cell25 ML47 gate_way47_cell25 GND ML47 p1 W=2.4e-6 L=1e-6
mnway47_cell26 ML47 gate_way47_cell26 GND GND n1 W=1e-6 L=1e-6
mpway47_cell26 ML47 gate_way47_cell26 GND ML47 p1 W=2.4e-6 L=1e-6
mnway47_cell27 ML47 gate_way47_cell27 GND GND n1 W=1e-6 L=1e-6
mpway47_cell27 ML47 gate_way47_cell27 GND ML47 p1 W=2.4e-6 L=1e-6
mnway47_cell28 ML47 gate_way47_cell28 GND GND n1 W=1e-6 L=1e-6
mpway47_cell28 ML47 gate_way47_cell28 GND ML47 p1 W=2.4e-6 L=1e-6
mnway47_cell29 ML47 gate_way47_cell29 GND GND n1 W=1e-6 L=1e-6
mpway47_cell29 ML47 gate_way47_cell29 GND ML47 p1 W=2.4e-6 L=1e-6
mnway47_cell30 ML47 gate_way47_cell30 GND GND n1 W=1e-6 L=1e-6
mpway47_cell30 ML47 gate_way47_cell30 GND ML47 p1 W=2.4e-6 L=1e-6
mnway47_cell31 ML47 gate_way47_cell31 GND GND n1 W=1e-6 L=1e-6
mpway47_cell31 ML47 gate_way47_cell31 GND ML47 p1 W=2.4e-6 L=1e-6
mnway47_cell32 ML47 gate_way47_cell32 GND GND n1 W=1e-6 L=1e-6
mpway47_cell32 ML47 gate_way47_cell32 GND ML47 p1 W=2.4e-6 L=1e-6
mnway47_cell33 ML47 gate_way47_cell33 GND GND n1 W=1e-6 L=1e-6
mpway47_cell33 ML47 gate_way47_cell33 GND ML47 p1 W=2.4e-6 L=1e-6
mnway47_cell34 ML47 gate_way47_cell34 GND GND n1 W=1e-6 L=1e-6
mpway47_cell34 ML47 gate_way47_cell34 GND ML47 p1 W=2.4e-6 L=1e-6
mnway47_cell35 ML47 gate_way47_cell35 GND GND n1 W=1e-6 L=1e-6
mpway47_cell35 ML47 gate_way47_cell35 GND ML47 p1 W=2.4e-6 L=1e-6
mnway47_cell36 ML47 gate_way47_cell36 GND GND n1 W=1e-6 L=1e-6
mpway47_cell36 ML47 gate_way47_cell36 GND ML47 p1 W=2.4e-6 L=1e-6
mnway47_cell37 ML47 gate_way47_cell37 GND GND n1 W=1e-6 L=1e-6
mpway47_cell37 ML47 gate_way47_cell37 GND ML47 p1 W=2.4e-6 L=1e-6
mnway47_cell38 ML47 gate_way47_cell38 GND GND n1 W=1e-6 L=1e-6
mpway47_cell38 ML47 gate_way47_cell38 GND ML47 p1 W=2.4e-6 L=1e-6
mnway47_cell39 ML47 gate_way47_cell39 GND GND n1 W=1e-6 L=1e-6
mpway47_cell39 ML47 gate_way47_cell39 GND ML47 p1 W=2.4e-6 L=1e-6
mnway47_cell40 ML47 gate_way47_cell40 GND GND n1 W=1e-6 L=1e-6
mpway47_cell40 ML47 gate_way47_cell40 GND ML47 p1 W=2.4e-6 L=1e-6
mnway47_cell41 ML47 gate_way47_cell41 GND GND n1 W=1e-6 L=1e-6
mpway47_cell41 ML47 gate_way47_cell41 GND ML47 p1 W=2.4e-6 L=1e-6
mnway47_cell42 ML47 gate_way47_cell42 GND GND n1 W=1e-6 L=1e-6
mpway47_cell42 ML47 gate_way47_cell42 GND ML47 p1 W=2.4e-6 L=1e-6
mnway47_cell43 ML47 gate_way47_cell43 GND GND n1 W=1e-6 L=1e-6
mpway47_cell43 ML47 gate_way47_cell43 GND ML47 p1 W=2.4e-6 L=1e-6
mnway47_cell44 ML47 gate_way47_cell44 GND GND n1 W=1e-6 L=1e-6
mpway47_cell44 ML47 gate_way47_cell44 GND ML47 p1 W=2.4e-6 L=1e-6
mnway47_cell45 ML47 gate_way47_cell45 GND GND n1 W=1e-6 L=1e-6
mpway47_cell45 ML47 gate_way47_cell45 GND ML47 p1 W=2.4e-6 L=1e-6
mnway47_cell46 ML47 gate_way47_cell46 GND GND n1 W=1e-6 L=1e-6
mpway47_cell46 ML47 gate_way47_cell46 GND ML47 p1 W=2.4e-6 L=1e-6
mnway47_cell47 ML47 gate_way47_cell47 GND GND n1 W=1e-6 L=1e-6
mpway47_cell47 ML47 gate_way47_cell47 GND ML47 p1 W=2.4e-6 L=1e-6
mnway47_cell48 ML47 gate_way47_cell48 GND GND n1 W=1e-6 L=1e-6
mpway47_cell48 ML47 gate_way47_cell48 GND ML47 p1 W=2.4e-6 L=1e-6
mnway47_cell49 ML47 gate_way47_cell49 GND GND n1 W=1e-6 L=1e-6
mpway47_cell49 ML47 gate_way47_cell49 GND ML47 p1 W=2.4e-6 L=1e-6
mnway47_cell50 ML47 gate_way47_cell50 GND GND n1 W=1e-6 L=1e-6
mpway47_cell50 ML47 gate_way47_cell50 GND ML47 p1 W=2.4e-6 L=1e-6
mnway47_cell51 ML47 gate_way47_cell51 GND GND n1 W=1e-6 L=1e-6
mpway47_cell51 ML47 gate_way47_cell51 GND ML47 p1 W=2.4e-6 L=1e-6
mnway47_cell52 ML47 gate_way47_cell52 GND GND n1 W=1e-6 L=1e-6
mpway47_cell52 ML47 gate_way47_cell52 GND ML47 p1 W=2.4e-6 L=1e-6
mnway47_cell53 ML47 gate_way47_cell53 GND GND n1 W=1e-6 L=1e-6
mpway47_cell53 ML47 gate_way47_cell53 GND ML47 p1 W=2.4e-6 L=1e-6
mnway47_cell54 ML47 gate_way47_cell54 GND GND n1 W=1e-6 L=1e-6
mpway47_cell54 ML47 gate_way47_cell54 GND ML47 p1 W=2.4e-6 L=1e-6
mnway47_cell55 ML47 gate_way47_cell55 GND GND n1 W=1e-6 L=1e-6
mpway47_cell55 ML47 gate_way47_cell55 GND ML47 p1 W=2.4e-6 L=1e-6
mnway47_cell56 ML47 gate_way47_cell56 GND GND n1 W=1e-6 L=1e-6
mpway47_cell56 ML47 gate_way47_cell56 GND ML47 p1 W=2.4e-6 L=1e-6
mnway47_cell57 ML47 gate_way47_cell57 GND GND n1 W=1e-6 L=1e-6
mpway47_cell57 ML47 gate_way47_cell57 GND ML47 p1 W=2.4e-6 L=1e-6
mnway47_cell58 ML47 gate_way47_cell58 GND GND n1 W=1e-6 L=1e-6
mpway47_cell58 ML47 gate_way47_cell58 GND ML47 p1 W=2.4e-6 L=1e-6
mnway47_cell59 ML47 gate_way47_cell59 GND GND n1 W=1e-6 L=1e-6
mpway47_cell59 ML47 gate_way47_cell59 GND ML47 p1 W=2.4e-6 L=1e-6
mnway47_cell60 ML47 gate_way47_cell60 GND GND n1 W=1e-6 L=1e-6
mpway47_cell60 ML47 gate_way47_cell60 GND ML47 p1 W=2.4e-6 L=1e-6
mnway47_cell61 ML47 gate_way47_cell61 GND GND n1 W=1e-6 L=1e-6
mpway47_cell61 ML47 gate_way47_cell61 GND ML47 p1 W=2.4e-6 L=1e-6
mnway47_cell62 ML47 gate_way47_cell62 GND GND n1 W=1e-6 L=1e-6
mpway47_cell62 ML47 gate_way47_cell62 GND ML47 p1 W=2.4e-6 L=1e-6
mnway47_cell63 ML47 gate_way47_cell63 GND GND n1 W=1e-6 L=1e-6
mpway47_cell63 ML47 gate_way47_cell63 GND ML47 p1 W=2.4e-6 L=1e-6
mnway47_cell64 ML47 gate_way47_cell64 GND GND n1 W=1e-6 L=1e-6
mpway47_cell64 ML47 gate_way47_cell64 GND ML47 p1 W=2.4e-6 L=1e-6
mnway47_cell65 ML47 gate_way47_cell65 GND GND n1 W=1e-6 L=1e-6
mpway47_cell65 ML47 gate_way47_cell65 GND ML47 p1 W=2.4e-6 L=1e-6
mnway47_cell66 ML47 gate_way47_cell66 GND GND n1 W=1e-6 L=1e-6
mpway47_cell66 ML47 gate_way47_cell66 GND ML47 p1 W=2.4e-6 L=1e-6
mnway47_cell67 ML47 gate_way47_cell67 GND GND n1 W=1e-6 L=1e-6
mpway47_cell67 ML47 gate_way47_cell67 GND ML47 p1 W=2.4e-6 L=1e-6
mnway47_cell68 ML47 gate_way47_cell68 GND GND n1 W=1e-6 L=1e-6
mpway47_cell68 ML47 gate_way47_cell68 GND ML47 p1 W=2.4e-6 L=1e-6
mnway47_cell69 ML47 gate_way47_cell69 GND GND n1 W=1e-6 L=1e-6
mpway47_cell69 ML47 gate_way47_cell69 GND ML47 p1 W=2.4e-6 L=1e-6
mnway47_cell70 ML47 gate_way47_cell70 GND GND n1 W=1e-6 L=1e-6
mpway47_cell70 ML47 gate_way47_cell70 GND ML47 p1 W=2.4e-6 L=1e-6
mnway47_cell71 ML47 gate_way47_cell71 GND GND n1 W=1e-6 L=1e-6
mpway47_cell71 ML47 gate_way47_cell71 GND ML47 p1 W=2.4e-6 L=1e-6
mnway47_cell72 ML47 gate_way47_cell72 GND GND n1 W=1e-6 L=1e-6
mpway47_cell72 ML47 gate_way47_cell72 GND ML47 p1 W=2.4e-6 L=1e-6
mnway47_cell73 ML47 gate_way47_cell73 GND GND n1 W=1e-6 L=1e-6
mpway47_cell73 ML47 gate_way47_cell73 GND ML47 p1 W=2.4e-6 L=1e-6
mnway47_cell74 ML47 gate_way47_cell74 GND GND n1 W=1e-6 L=1e-6
mpway47_cell74 ML47 gate_way47_cell74 GND ML47 p1 W=2.4e-6 L=1e-6
mnway47_cell75 ML47 gate_way47_cell75 GND GND n1 W=1e-6 L=1e-6
mpway47_cell75 ML47 gate_way47_cell75 GND ML47 p1 W=2.4e-6 L=1e-6
mnway47_cell76 ML47 gate_way47_cell76 GND GND n1 W=1e-6 L=1e-6
mpway47_cell76 ML47 gate_way47_cell76 GND ML47 p1 W=2.4e-6 L=1e-6
mnway47_cell77 ML47 gate_way47_cell77 GND GND n1 W=1e-6 L=1e-6
mpway47_cell77 ML47 gate_way47_cell77 GND ML47 p1 W=2.4e-6 L=1e-6
mnway47_cell78 ML47 gate_way47_cell78 GND GND n1 W=1e-6 L=1e-6
mpway47_cell78 ML47 gate_way47_cell78 GND ML47 p1 W=2.4e-6 L=1e-6
mnway47_cell79 ML47 gate_way47_cell79 GND GND n1 W=1e-6 L=1e-6
mpway47_cell79 ML47 gate_way47_cell79 GND ML47 p1 W=2.4e-6 L=1e-6
mnway47_cell80 ML47 gate_way47_cell80 GND GND n1 W=1e-6 L=1e-6
mpway47_cell80 ML47 gate_way47_cell80 GND ML47 p1 W=2.4e-6 L=1e-6
mnway47_cell81 ML47 gate_way47_cell81 GND GND n1 W=1e-6 L=1e-6
mpway47_cell81 ML47 gate_way47_cell81 GND ML47 p1 W=2.4e-6 L=1e-6
mnway47_cell82 ML47 gate_way47_cell82 GND GND n1 W=1e-6 L=1e-6
mpway47_cell82 ML47 gate_way47_cell82 GND ML47 p1 W=2.4e-6 L=1e-6
mnway47_cell83 ML47 gate_way47_cell83 GND GND n1 W=1e-6 L=1e-6
mpway47_cell83 ML47 gate_way47_cell83 GND ML47 p1 W=2.4e-6 L=1e-6
mnway47_cell84 ML47 gate_way47_cell84 GND GND n1 W=1e-6 L=1e-6
mpway47_cell84 ML47 gate_way47_cell84 GND ML47 p1 W=2.4e-6 L=1e-6
mnway47_cell85 ML47 gate_way47_cell85 GND GND n1 W=1e-6 L=1e-6
mpway47_cell85 ML47 gate_way47_cell85 GND ML47 p1 W=2.4e-6 L=1e-6
mnway47_cell86 ML47 gate_way47_cell86 GND GND n1 W=1e-6 L=1e-6
mpway47_cell86 ML47 gate_way47_cell86 GND ML47 p1 W=2.4e-6 L=1e-6
mnway47_cell87 ML47 gate_way47_cell87 GND GND n1 W=1e-6 L=1e-6
mpway47_cell87 ML47 gate_way47_cell87 GND ML47 p1 W=2.4e-6 L=1e-6
mnway47_cell88 ML47 gate_way47_cell88 GND GND n1 W=1e-6 L=1e-6
mpway47_cell88 ML47 gate_way47_cell88 GND ML47 p1 W=2.4e-6 L=1e-6
mnway47_cell89 ML47 gate_way47_cell89 GND GND n1 W=1e-6 L=1e-6
mpway47_cell89 ML47 gate_way47_cell89 GND ML47 p1 W=2.4e-6 L=1e-6
mnway47_cell90 ML47 gate_way47_cell90 GND GND n1 W=1e-6 L=1e-6
mpway47_cell90 ML47 gate_way47_cell90 GND ML47 p1 W=2.4e-6 L=1e-6
mnway47_cell91 ML47 gate_way47_cell91 GND GND n1 W=1e-6 L=1e-6
mpway47_cell91 ML47 gate_way47_cell91 GND ML47 p1 W=2.4e-6 L=1e-6
mnway47_cell92 ML47 gate_way47_cell92 GND GND n1 W=1e-6 L=1e-6
mpway47_cell92 ML47 gate_way47_cell92 GND ML47 p1 W=2.4e-6 L=1e-6
mnway47_cell93 ML47 gate_way47_cell93 GND GND n1 W=1e-6 L=1e-6
mpway47_cell93 ML47 gate_way47_cell93 GND ML47 p1 W=2.4e-6 L=1e-6
mnway47_cell94 ML47 gate_way47_cell94 GND GND n1 W=1e-6 L=1e-6
mpway47_cell94 ML47 gate_way47_cell94 GND ML47 p1 W=2.4e-6 L=1e-6
mnway47_cell95 ML47 gate_way47_cell95 GND GND n1 W=1e-6 L=1e-6
mpway47_cell95 ML47 gate_way47_cell95 GND ML47 p1 W=2.4e-6 L=1e-6
mnway47_cell96 ML47 gate_way47_cell96 GND GND n1 W=1e-6 L=1e-6
mpway47_cell96 ML47 gate_way47_cell96 GND ML47 p1 W=2.4e-6 L=1e-6
mnway47_cell97 ML47 gate_way47_cell97 GND GND n1 W=1e-6 L=1e-6
mpway47_cell97 ML47 gate_way47_cell97 GND ML47 p1 W=2.4e-6 L=1e-6
mnway47_cell98 ML47 gate_way47_cell98 GND GND n1 W=1e-6 L=1e-6
mpway47_cell98 ML47 gate_way47_cell98 GND ML47 p1 W=2.4e-6 L=1e-6
mnway47_cell99 ML47 gate_way47_cell99 GND GND n1 W=1e-6 L=1e-6
mpway47_cell99 ML47 gate_way47_cell99 GND ML47 p1 W=2.4e-6 L=1e-6
mnway48_cell0 ML48 gate_way48_cell0 GND GND n1 W=1e-6 L=1e-6
mpway48_cell0 ML48 gate_way48_cell0 GND ML48 p1 W=2.4e-6 L=1e-6
mnway48_cell1 ML48 gate_way48_cell1 GND GND n1 W=1e-6 L=1e-6
mpway48_cell1 ML48 gate_way48_cell1 GND ML48 p1 W=2.4e-6 L=1e-6
mnway48_cell2 ML48 gate_way48_cell2 GND GND n1 W=1e-6 L=1e-6
mpway48_cell2 ML48 gate_way48_cell2 GND ML48 p1 W=2.4e-6 L=1e-6
mnway48_cell3 ML48 gate_way48_cell3 GND GND n1 W=1e-6 L=1e-6
mpway48_cell3 ML48 gate_way48_cell3 GND ML48 p1 W=2.4e-6 L=1e-6
mnway48_cell4 ML48 gate_way48_cell4 GND GND n1 W=1e-6 L=1e-6
mpway48_cell4 ML48 gate_way48_cell4 GND ML48 p1 W=2.4e-6 L=1e-6
mnway48_cell5 ML48 gate_way48_cell5 GND GND n1 W=1e-6 L=1e-6
mpway48_cell5 ML48 gate_way48_cell5 GND ML48 p1 W=2.4e-6 L=1e-6
mnway48_cell6 ML48 gate_way48_cell6 GND GND n1 W=1e-6 L=1e-6
mpway48_cell6 ML48 gate_way48_cell6 GND ML48 p1 W=2.4e-6 L=1e-6
mnway48_cell7 ML48 gate_way48_cell7 GND GND n1 W=1e-6 L=1e-6
mpway48_cell7 ML48 gate_way48_cell7 GND ML48 p1 W=2.4e-6 L=1e-6
mnway48_cell8 ML48 gate_way48_cell8 GND GND n1 W=1e-6 L=1e-6
mpway48_cell8 ML48 gate_way48_cell8 GND ML48 p1 W=2.4e-6 L=1e-6
mnway48_cell9 ML48 gate_way48_cell9 GND GND n1 W=1e-6 L=1e-6
mpway48_cell9 ML48 gate_way48_cell9 GND ML48 p1 W=2.4e-6 L=1e-6
mnway48_cell10 ML48 gate_way48_cell10 GND GND n1 W=1e-6 L=1e-6
mpway48_cell10 ML48 gate_way48_cell10 GND ML48 p1 W=2.4e-6 L=1e-6
mnway48_cell11 ML48 gate_way48_cell11 GND GND n1 W=1e-6 L=1e-6
mpway48_cell11 ML48 gate_way48_cell11 GND ML48 p1 W=2.4e-6 L=1e-6
mnway48_cell12 ML48 gate_way48_cell12 GND GND n1 W=1e-6 L=1e-6
mpway48_cell12 ML48 gate_way48_cell12 GND ML48 p1 W=2.4e-6 L=1e-6
mnway48_cell13 ML48 gate_way48_cell13 GND GND n1 W=1e-6 L=1e-6
mpway48_cell13 ML48 gate_way48_cell13 GND ML48 p1 W=2.4e-6 L=1e-6
mnway48_cell14 ML48 gate_way48_cell14 GND GND n1 W=1e-6 L=1e-6
mpway48_cell14 ML48 gate_way48_cell14 GND ML48 p1 W=2.4e-6 L=1e-6
mnway48_cell15 ML48 gate_way48_cell15 GND GND n1 W=1e-6 L=1e-6
mpway48_cell15 ML48 gate_way48_cell15 GND ML48 p1 W=2.4e-6 L=1e-6
mnway48_cell16 ML48 gate_way48_cell16 GND GND n1 W=1e-6 L=1e-6
mpway48_cell16 ML48 gate_way48_cell16 GND ML48 p1 W=2.4e-6 L=1e-6
mnway48_cell17 ML48 gate_way48_cell17 GND GND n1 W=1e-6 L=1e-6
mpway48_cell17 ML48 gate_way48_cell17 GND ML48 p1 W=2.4e-6 L=1e-6
mnway48_cell18 ML48 gate_way48_cell18 GND GND n1 W=1e-6 L=1e-6
mpway48_cell18 ML48 gate_way48_cell18 GND ML48 p1 W=2.4e-6 L=1e-6
mnway48_cell19 ML48 gate_way48_cell19 GND GND n1 W=1e-6 L=1e-6
mpway48_cell19 ML48 gate_way48_cell19 GND ML48 p1 W=2.4e-6 L=1e-6
mnway48_cell20 ML48 gate_way48_cell20 GND GND n1 W=1e-6 L=1e-6
mpway48_cell20 ML48 gate_way48_cell20 GND ML48 p1 W=2.4e-6 L=1e-6
mnway48_cell21 ML48 gate_way48_cell21 GND GND n1 W=1e-6 L=1e-6
mpway48_cell21 ML48 gate_way48_cell21 GND ML48 p1 W=2.4e-6 L=1e-6
mnway48_cell22 ML48 gate_way48_cell22 GND GND n1 W=1e-6 L=1e-6
mpway48_cell22 ML48 gate_way48_cell22 GND ML48 p1 W=2.4e-6 L=1e-6
mnway48_cell23 ML48 gate_way48_cell23 GND GND n1 W=1e-6 L=1e-6
mpway48_cell23 ML48 gate_way48_cell23 GND ML48 p1 W=2.4e-6 L=1e-6
mnway48_cell24 ML48 gate_way48_cell24 GND GND n1 W=1e-6 L=1e-6
mpway48_cell24 ML48 gate_way48_cell24 GND ML48 p1 W=2.4e-6 L=1e-6
mnway48_cell25 ML48 gate_way48_cell25 GND GND n1 W=1e-6 L=1e-6
mpway48_cell25 ML48 gate_way48_cell25 GND ML48 p1 W=2.4e-6 L=1e-6
mnway48_cell26 ML48 gate_way48_cell26 GND GND n1 W=1e-6 L=1e-6
mpway48_cell26 ML48 gate_way48_cell26 GND ML48 p1 W=2.4e-6 L=1e-6
mnway48_cell27 ML48 gate_way48_cell27 GND GND n1 W=1e-6 L=1e-6
mpway48_cell27 ML48 gate_way48_cell27 GND ML48 p1 W=2.4e-6 L=1e-6
mnway48_cell28 ML48 gate_way48_cell28 GND GND n1 W=1e-6 L=1e-6
mpway48_cell28 ML48 gate_way48_cell28 GND ML48 p1 W=2.4e-6 L=1e-6
mnway48_cell29 ML48 gate_way48_cell29 GND GND n1 W=1e-6 L=1e-6
mpway48_cell29 ML48 gate_way48_cell29 GND ML48 p1 W=2.4e-6 L=1e-6
mnway48_cell30 ML48 gate_way48_cell30 GND GND n1 W=1e-6 L=1e-6
mpway48_cell30 ML48 gate_way48_cell30 GND ML48 p1 W=2.4e-6 L=1e-6
mnway48_cell31 ML48 gate_way48_cell31 GND GND n1 W=1e-6 L=1e-6
mpway48_cell31 ML48 gate_way48_cell31 GND ML48 p1 W=2.4e-6 L=1e-6
mnway48_cell32 ML48 gate_way48_cell32 GND GND n1 W=1e-6 L=1e-6
mpway48_cell32 ML48 gate_way48_cell32 GND ML48 p1 W=2.4e-6 L=1e-6
mnway48_cell33 ML48 gate_way48_cell33 GND GND n1 W=1e-6 L=1e-6
mpway48_cell33 ML48 gate_way48_cell33 GND ML48 p1 W=2.4e-6 L=1e-6
mnway48_cell34 ML48 gate_way48_cell34 GND GND n1 W=1e-6 L=1e-6
mpway48_cell34 ML48 gate_way48_cell34 GND ML48 p1 W=2.4e-6 L=1e-6
mnway48_cell35 ML48 gate_way48_cell35 GND GND n1 W=1e-6 L=1e-6
mpway48_cell35 ML48 gate_way48_cell35 GND ML48 p1 W=2.4e-6 L=1e-6
mnway48_cell36 ML48 gate_way48_cell36 GND GND n1 W=1e-6 L=1e-6
mpway48_cell36 ML48 gate_way48_cell36 GND ML48 p1 W=2.4e-6 L=1e-6
mnway48_cell37 ML48 gate_way48_cell37 GND GND n1 W=1e-6 L=1e-6
mpway48_cell37 ML48 gate_way48_cell37 GND ML48 p1 W=2.4e-6 L=1e-6
mnway48_cell38 ML48 gate_way48_cell38 GND GND n1 W=1e-6 L=1e-6
mpway48_cell38 ML48 gate_way48_cell38 GND ML48 p1 W=2.4e-6 L=1e-6
mnway48_cell39 ML48 gate_way48_cell39 GND GND n1 W=1e-6 L=1e-6
mpway48_cell39 ML48 gate_way48_cell39 GND ML48 p1 W=2.4e-6 L=1e-6
mnway48_cell40 ML48 gate_way48_cell40 GND GND n1 W=1e-6 L=1e-6
mpway48_cell40 ML48 gate_way48_cell40 GND ML48 p1 W=2.4e-6 L=1e-6
mnway48_cell41 ML48 gate_way48_cell41 GND GND n1 W=1e-6 L=1e-6
mpway48_cell41 ML48 gate_way48_cell41 GND ML48 p1 W=2.4e-6 L=1e-6
mnway48_cell42 ML48 gate_way48_cell42 GND GND n1 W=1e-6 L=1e-6
mpway48_cell42 ML48 gate_way48_cell42 GND ML48 p1 W=2.4e-6 L=1e-6
mnway48_cell43 ML48 gate_way48_cell43 GND GND n1 W=1e-6 L=1e-6
mpway48_cell43 ML48 gate_way48_cell43 GND ML48 p1 W=2.4e-6 L=1e-6
mnway48_cell44 ML48 gate_way48_cell44 GND GND n1 W=1e-6 L=1e-6
mpway48_cell44 ML48 gate_way48_cell44 GND ML48 p1 W=2.4e-6 L=1e-6
mnway48_cell45 ML48 gate_way48_cell45 GND GND n1 W=1e-6 L=1e-6
mpway48_cell45 ML48 gate_way48_cell45 GND ML48 p1 W=2.4e-6 L=1e-6
mnway48_cell46 ML48 gate_way48_cell46 GND GND n1 W=1e-6 L=1e-6
mpway48_cell46 ML48 gate_way48_cell46 GND ML48 p1 W=2.4e-6 L=1e-6
mnway48_cell47 ML48 gate_way48_cell47 GND GND n1 W=1e-6 L=1e-6
mpway48_cell47 ML48 gate_way48_cell47 GND ML48 p1 W=2.4e-6 L=1e-6
mnway48_cell48 ML48 gate_way48_cell48 GND GND n1 W=1e-6 L=1e-6
mpway48_cell48 ML48 gate_way48_cell48 GND ML48 p1 W=2.4e-6 L=1e-6
mnway48_cell49 ML48 gate_way48_cell49 GND GND n1 W=1e-6 L=1e-6
mpway48_cell49 ML48 gate_way48_cell49 GND ML48 p1 W=2.4e-6 L=1e-6
mnway48_cell50 ML48 gate_way48_cell50 GND GND n1 W=1e-6 L=1e-6
mpway48_cell50 ML48 gate_way48_cell50 GND ML48 p1 W=2.4e-6 L=1e-6
mnway48_cell51 ML48 gate_way48_cell51 GND GND n1 W=1e-6 L=1e-6
mpway48_cell51 ML48 gate_way48_cell51 GND ML48 p1 W=2.4e-6 L=1e-6
mnway48_cell52 ML48 gate_way48_cell52 GND GND n1 W=1e-6 L=1e-6
mpway48_cell52 ML48 gate_way48_cell52 GND ML48 p1 W=2.4e-6 L=1e-6
mnway48_cell53 ML48 gate_way48_cell53 GND GND n1 W=1e-6 L=1e-6
mpway48_cell53 ML48 gate_way48_cell53 GND ML48 p1 W=2.4e-6 L=1e-6
mnway48_cell54 ML48 gate_way48_cell54 GND GND n1 W=1e-6 L=1e-6
mpway48_cell54 ML48 gate_way48_cell54 GND ML48 p1 W=2.4e-6 L=1e-6
mnway48_cell55 ML48 gate_way48_cell55 GND GND n1 W=1e-6 L=1e-6
mpway48_cell55 ML48 gate_way48_cell55 GND ML48 p1 W=2.4e-6 L=1e-6
mnway48_cell56 ML48 gate_way48_cell56 GND GND n1 W=1e-6 L=1e-6
mpway48_cell56 ML48 gate_way48_cell56 GND ML48 p1 W=2.4e-6 L=1e-6
mnway48_cell57 ML48 gate_way48_cell57 GND GND n1 W=1e-6 L=1e-6
mpway48_cell57 ML48 gate_way48_cell57 GND ML48 p1 W=2.4e-6 L=1e-6
mnway48_cell58 ML48 gate_way48_cell58 GND GND n1 W=1e-6 L=1e-6
mpway48_cell58 ML48 gate_way48_cell58 GND ML48 p1 W=2.4e-6 L=1e-6
mnway48_cell59 ML48 gate_way48_cell59 GND GND n1 W=1e-6 L=1e-6
mpway48_cell59 ML48 gate_way48_cell59 GND ML48 p1 W=2.4e-6 L=1e-6
mnway48_cell60 ML48 gate_way48_cell60 GND GND n1 W=1e-6 L=1e-6
mpway48_cell60 ML48 gate_way48_cell60 GND ML48 p1 W=2.4e-6 L=1e-6
mnway48_cell61 ML48 gate_way48_cell61 GND GND n1 W=1e-6 L=1e-6
mpway48_cell61 ML48 gate_way48_cell61 GND ML48 p1 W=2.4e-6 L=1e-6
mnway48_cell62 ML48 gate_way48_cell62 GND GND n1 W=1e-6 L=1e-6
mpway48_cell62 ML48 gate_way48_cell62 GND ML48 p1 W=2.4e-6 L=1e-6
mnway48_cell63 ML48 gate_way48_cell63 GND GND n1 W=1e-6 L=1e-6
mpway48_cell63 ML48 gate_way48_cell63 GND ML48 p1 W=2.4e-6 L=1e-6
mnway48_cell64 ML48 gate_way48_cell64 GND GND n1 W=1e-6 L=1e-6
mpway48_cell64 ML48 gate_way48_cell64 GND ML48 p1 W=2.4e-6 L=1e-6
mnway48_cell65 ML48 gate_way48_cell65 GND GND n1 W=1e-6 L=1e-6
mpway48_cell65 ML48 gate_way48_cell65 GND ML48 p1 W=2.4e-6 L=1e-6
mnway48_cell66 ML48 gate_way48_cell66 GND GND n1 W=1e-6 L=1e-6
mpway48_cell66 ML48 gate_way48_cell66 GND ML48 p1 W=2.4e-6 L=1e-6
mnway48_cell67 ML48 gate_way48_cell67 GND GND n1 W=1e-6 L=1e-6
mpway48_cell67 ML48 gate_way48_cell67 GND ML48 p1 W=2.4e-6 L=1e-6
mnway48_cell68 ML48 gate_way48_cell68 GND GND n1 W=1e-6 L=1e-6
mpway48_cell68 ML48 gate_way48_cell68 GND ML48 p1 W=2.4e-6 L=1e-6
mnway48_cell69 ML48 gate_way48_cell69 GND GND n1 W=1e-6 L=1e-6
mpway48_cell69 ML48 gate_way48_cell69 GND ML48 p1 W=2.4e-6 L=1e-6
mnway48_cell70 ML48 gate_way48_cell70 GND GND n1 W=1e-6 L=1e-6
mpway48_cell70 ML48 gate_way48_cell70 GND ML48 p1 W=2.4e-6 L=1e-6
mnway48_cell71 ML48 gate_way48_cell71 GND GND n1 W=1e-6 L=1e-6
mpway48_cell71 ML48 gate_way48_cell71 GND ML48 p1 W=2.4e-6 L=1e-6
mnway48_cell72 ML48 gate_way48_cell72 GND GND n1 W=1e-6 L=1e-6
mpway48_cell72 ML48 gate_way48_cell72 GND ML48 p1 W=2.4e-6 L=1e-6
mnway48_cell73 ML48 gate_way48_cell73 GND GND n1 W=1e-6 L=1e-6
mpway48_cell73 ML48 gate_way48_cell73 GND ML48 p1 W=2.4e-6 L=1e-6
mnway48_cell74 ML48 gate_way48_cell74 GND GND n1 W=1e-6 L=1e-6
mpway48_cell74 ML48 gate_way48_cell74 GND ML48 p1 W=2.4e-6 L=1e-6
mnway48_cell75 ML48 gate_way48_cell75 GND GND n1 W=1e-6 L=1e-6
mpway48_cell75 ML48 gate_way48_cell75 GND ML48 p1 W=2.4e-6 L=1e-6
mnway48_cell76 ML48 gate_way48_cell76 GND GND n1 W=1e-6 L=1e-6
mpway48_cell76 ML48 gate_way48_cell76 GND ML48 p1 W=2.4e-6 L=1e-6
mnway48_cell77 ML48 gate_way48_cell77 GND GND n1 W=1e-6 L=1e-6
mpway48_cell77 ML48 gate_way48_cell77 GND ML48 p1 W=2.4e-6 L=1e-6
mnway48_cell78 ML48 gate_way48_cell78 GND GND n1 W=1e-6 L=1e-6
mpway48_cell78 ML48 gate_way48_cell78 GND ML48 p1 W=2.4e-6 L=1e-6
mnway48_cell79 ML48 gate_way48_cell79 GND GND n1 W=1e-6 L=1e-6
mpway48_cell79 ML48 gate_way48_cell79 GND ML48 p1 W=2.4e-6 L=1e-6
mnway48_cell80 ML48 gate_way48_cell80 GND GND n1 W=1e-6 L=1e-6
mpway48_cell80 ML48 gate_way48_cell80 GND ML48 p1 W=2.4e-6 L=1e-6
mnway48_cell81 ML48 gate_way48_cell81 GND GND n1 W=1e-6 L=1e-6
mpway48_cell81 ML48 gate_way48_cell81 GND ML48 p1 W=2.4e-6 L=1e-6
mnway48_cell82 ML48 gate_way48_cell82 GND GND n1 W=1e-6 L=1e-6
mpway48_cell82 ML48 gate_way48_cell82 GND ML48 p1 W=2.4e-6 L=1e-6
mnway48_cell83 ML48 gate_way48_cell83 GND GND n1 W=1e-6 L=1e-6
mpway48_cell83 ML48 gate_way48_cell83 GND ML48 p1 W=2.4e-6 L=1e-6
mnway48_cell84 ML48 gate_way48_cell84 GND GND n1 W=1e-6 L=1e-6
mpway48_cell84 ML48 gate_way48_cell84 GND ML48 p1 W=2.4e-6 L=1e-6
mnway48_cell85 ML48 gate_way48_cell85 GND GND n1 W=1e-6 L=1e-6
mpway48_cell85 ML48 gate_way48_cell85 GND ML48 p1 W=2.4e-6 L=1e-6
mnway48_cell86 ML48 gate_way48_cell86 GND GND n1 W=1e-6 L=1e-6
mpway48_cell86 ML48 gate_way48_cell86 GND ML48 p1 W=2.4e-6 L=1e-6
mnway48_cell87 ML48 gate_way48_cell87 GND GND n1 W=1e-6 L=1e-6
mpway48_cell87 ML48 gate_way48_cell87 GND ML48 p1 W=2.4e-6 L=1e-6
mnway48_cell88 ML48 gate_way48_cell88 GND GND n1 W=1e-6 L=1e-6
mpway48_cell88 ML48 gate_way48_cell88 GND ML48 p1 W=2.4e-6 L=1e-6
mnway48_cell89 ML48 gate_way48_cell89 GND GND n1 W=1e-6 L=1e-6
mpway48_cell89 ML48 gate_way48_cell89 GND ML48 p1 W=2.4e-6 L=1e-6
mnway48_cell90 ML48 gate_way48_cell90 GND GND n1 W=1e-6 L=1e-6
mpway48_cell90 ML48 gate_way48_cell90 GND ML48 p1 W=2.4e-6 L=1e-6
mnway48_cell91 ML48 gate_way48_cell91 GND GND n1 W=1e-6 L=1e-6
mpway48_cell91 ML48 gate_way48_cell91 GND ML48 p1 W=2.4e-6 L=1e-6
mnway48_cell92 ML48 gate_way48_cell92 GND GND n1 W=1e-6 L=1e-6
mpway48_cell92 ML48 gate_way48_cell92 GND ML48 p1 W=2.4e-6 L=1e-6
mnway48_cell93 ML48 gate_way48_cell93 GND GND n1 W=1e-6 L=1e-6
mpway48_cell93 ML48 gate_way48_cell93 GND ML48 p1 W=2.4e-6 L=1e-6
mnway48_cell94 ML48 gate_way48_cell94 GND GND n1 W=1e-6 L=1e-6
mpway48_cell94 ML48 gate_way48_cell94 GND ML48 p1 W=2.4e-6 L=1e-6
mnway48_cell95 ML48 gate_way48_cell95 GND GND n1 W=1e-6 L=1e-6
mpway48_cell95 ML48 gate_way48_cell95 GND ML48 p1 W=2.4e-6 L=1e-6
mnway48_cell96 ML48 gate_way48_cell96 GND GND n1 W=1e-6 L=1e-6
mpway48_cell96 ML48 gate_way48_cell96 GND ML48 p1 W=2.4e-6 L=1e-6
mnway48_cell97 ML48 gate_way48_cell97 GND GND n1 W=1e-6 L=1e-6
mpway48_cell97 ML48 gate_way48_cell97 GND ML48 p1 W=2.4e-6 L=1e-6
mnway48_cell98 ML48 gate_way48_cell98 GND GND n1 W=1e-6 L=1e-6
mpway48_cell98 ML48 gate_way48_cell98 GND ML48 p1 W=2.4e-6 L=1e-6
mnway48_cell99 ML48 gate_way48_cell99 GND GND n1 W=1e-6 L=1e-6
mpway48_cell99 ML48 gate_way48_cell99 GND ML48 p1 W=2.4e-6 L=1e-6
mnway49_cell0 ML49 gate_way49_cell0 GND GND n1 W=1e-6 L=1e-6
mpway49_cell0 ML49 gate_way49_cell0 GND ML49 p1 W=2.4e-6 L=1e-6
mnway49_cell1 ML49 gate_way49_cell1 GND GND n1 W=1e-6 L=1e-6
mpway49_cell1 ML49 gate_way49_cell1 GND ML49 p1 W=2.4e-6 L=1e-6
mnway49_cell2 ML49 gate_way49_cell2 GND GND n1 W=1e-6 L=1e-6
mpway49_cell2 ML49 gate_way49_cell2 GND ML49 p1 W=2.4e-6 L=1e-6
mnway49_cell3 ML49 gate_way49_cell3 GND GND n1 W=1e-6 L=1e-6
mpway49_cell3 ML49 gate_way49_cell3 GND ML49 p1 W=2.4e-6 L=1e-6
mnway49_cell4 ML49 gate_way49_cell4 GND GND n1 W=1e-6 L=1e-6
mpway49_cell4 ML49 gate_way49_cell4 GND ML49 p1 W=2.4e-6 L=1e-6
mnway49_cell5 ML49 gate_way49_cell5 GND GND n1 W=1e-6 L=1e-6
mpway49_cell5 ML49 gate_way49_cell5 GND ML49 p1 W=2.4e-6 L=1e-6
mnway49_cell6 ML49 gate_way49_cell6 GND GND n1 W=1e-6 L=1e-6
mpway49_cell6 ML49 gate_way49_cell6 GND ML49 p1 W=2.4e-6 L=1e-6
mnway49_cell7 ML49 gate_way49_cell7 GND GND n1 W=1e-6 L=1e-6
mpway49_cell7 ML49 gate_way49_cell7 GND ML49 p1 W=2.4e-6 L=1e-6
mnway49_cell8 ML49 gate_way49_cell8 GND GND n1 W=1e-6 L=1e-6
mpway49_cell8 ML49 gate_way49_cell8 GND ML49 p1 W=2.4e-6 L=1e-6
mnway49_cell9 ML49 gate_way49_cell9 GND GND n1 W=1e-6 L=1e-6
mpway49_cell9 ML49 gate_way49_cell9 GND ML49 p1 W=2.4e-6 L=1e-6
mnway49_cell10 ML49 gate_way49_cell10 GND GND n1 W=1e-6 L=1e-6
mpway49_cell10 ML49 gate_way49_cell10 GND ML49 p1 W=2.4e-6 L=1e-6
mnway49_cell11 ML49 gate_way49_cell11 GND GND n1 W=1e-6 L=1e-6
mpway49_cell11 ML49 gate_way49_cell11 GND ML49 p1 W=2.4e-6 L=1e-6
mnway49_cell12 ML49 gate_way49_cell12 GND GND n1 W=1e-6 L=1e-6
mpway49_cell12 ML49 gate_way49_cell12 GND ML49 p1 W=2.4e-6 L=1e-6
mnway49_cell13 ML49 gate_way49_cell13 GND GND n1 W=1e-6 L=1e-6
mpway49_cell13 ML49 gate_way49_cell13 GND ML49 p1 W=2.4e-6 L=1e-6
mnway49_cell14 ML49 gate_way49_cell14 GND GND n1 W=1e-6 L=1e-6
mpway49_cell14 ML49 gate_way49_cell14 GND ML49 p1 W=2.4e-6 L=1e-6
mnway49_cell15 ML49 gate_way49_cell15 GND GND n1 W=1e-6 L=1e-6
mpway49_cell15 ML49 gate_way49_cell15 GND ML49 p1 W=2.4e-6 L=1e-6
mnway49_cell16 ML49 gate_way49_cell16 GND GND n1 W=1e-6 L=1e-6
mpway49_cell16 ML49 gate_way49_cell16 GND ML49 p1 W=2.4e-6 L=1e-6
mnway49_cell17 ML49 gate_way49_cell17 GND GND n1 W=1e-6 L=1e-6
mpway49_cell17 ML49 gate_way49_cell17 GND ML49 p1 W=2.4e-6 L=1e-6
mnway49_cell18 ML49 gate_way49_cell18 GND GND n1 W=1e-6 L=1e-6
mpway49_cell18 ML49 gate_way49_cell18 GND ML49 p1 W=2.4e-6 L=1e-6
mnway49_cell19 ML49 gate_way49_cell19 GND GND n1 W=1e-6 L=1e-6
mpway49_cell19 ML49 gate_way49_cell19 GND ML49 p1 W=2.4e-6 L=1e-6
mnway49_cell20 ML49 gate_way49_cell20 GND GND n1 W=1e-6 L=1e-6
mpway49_cell20 ML49 gate_way49_cell20 GND ML49 p1 W=2.4e-6 L=1e-6
mnway49_cell21 ML49 gate_way49_cell21 GND GND n1 W=1e-6 L=1e-6
mpway49_cell21 ML49 gate_way49_cell21 GND ML49 p1 W=2.4e-6 L=1e-6
mnway49_cell22 ML49 gate_way49_cell22 GND GND n1 W=1e-6 L=1e-6
mpway49_cell22 ML49 gate_way49_cell22 GND ML49 p1 W=2.4e-6 L=1e-6
mnway49_cell23 ML49 gate_way49_cell23 GND GND n1 W=1e-6 L=1e-6
mpway49_cell23 ML49 gate_way49_cell23 GND ML49 p1 W=2.4e-6 L=1e-6
mnway49_cell24 ML49 gate_way49_cell24 GND GND n1 W=1e-6 L=1e-6
mpway49_cell24 ML49 gate_way49_cell24 GND ML49 p1 W=2.4e-6 L=1e-6
mnway49_cell25 ML49 gate_way49_cell25 GND GND n1 W=1e-6 L=1e-6
mpway49_cell25 ML49 gate_way49_cell25 GND ML49 p1 W=2.4e-6 L=1e-6
mnway49_cell26 ML49 gate_way49_cell26 GND GND n1 W=1e-6 L=1e-6
mpway49_cell26 ML49 gate_way49_cell26 GND ML49 p1 W=2.4e-6 L=1e-6
mnway49_cell27 ML49 gate_way49_cell27 GND GND n1 W=1e-6 L=1e-6
mpway49_cell27 ML49 gate_way49_cell27 GND ML49 p1 W=2.4e-6 L=1e-6
mnway49_cell28 ML49 gate_way49_cell28 GND GND n1 W=1e-6 L=1e-6
mpway49_cell28 ML49 gate_way49_cell28 GND ML49 p1 W=2.4e-6 L=1e-6
mnway49_cell29 ML49 gate_way49_cell29 GND GND n1 W=1e-6 L=1e-6
mpway49_cell29 ML49 gate_way49_cell29 GND ML49 p1 W=2.4e-6 L=1e-6
mnway49_cell30 ML49 gate_way49_cell30 GND GND n1 W=1e-6 L=1e-6
mpway49_cell30 ML49 gate_way49_cell30 GND ML49 p1 W=2.4e-6 L=1e-6
mnway49_cell31 ML49 gate_way49_cell31 GND GND n1 W=1e-6 L=1e-6
mpway49_cell31 ML49 gate_way49_cell31 GND ML49 p1 W=2.4e-6 L=1e-6
mnway49_cell32 ML49 gate_way49_cell32 GND GND n1 W=1e-6 L=1e-6
mpway49_cell32 ML49 gate_way49_cell32 GND ML49 p1 W=2.4e-6 L=1e-6
mnway49_cell33 ML49 gate_way49_cell33 GND GND n1 W=1e-6 L=1e-6
mpway49_cell33 ML49 gate_way49_cell33 GND ML49 p1 W=2.4e-6 L=1e-6
mnway49_cell34 ML49 gate_way49_cell34 GND GND n1 W=1e-6 L=1e-6
mpway49_cell34 ML49 gate_way49_cell34 GND ML49 p1 W=2.4e-6 L=1e-6
mnway49_cell35 ML49 gate_way49_cell35 GND GND n1 W=1e-6 L=1e-6
mpway49_cell35 ML49 gate_way49_cell35 GND ML49 p1 W=2.4e-6 L=1e-6
mnway49_cell36 ML49 gate_way49_cell36 GND GND n1 W=1e-6 L=1e-6
mpway49_cell36 ML49 gate_way49_cell36 GND ML49 p1 W=2.4e-6 L=1e-6
mnway49_cell37 ML49 gate_way49_cell37 GND GND n1 W=1e-6 L=1e-6
mpway49_cell37 ML49 gate_way49_cell37 GND ML49 p1 W=2.4e-6 L=1e-6
mnway49_cell38 ML49 gate_way49_cell38 GND GND n1 W=1e-6 L=1e-6
mpway49_cell38 ML49 gate_way49_cell38 GND ML49 p1 W=2.4e-6 L=1e-6
mnway49_cell39 ML49 gate_way49_cell39 GND GND n1 W=1e-6 L=1e-6
mpway49_cell39 ML49 gate_way49_cell39 GND ML49 p1 W=2.4e-6 L=1e-6
mnway49_cell40 ML49 gate_way49_cell40 GND GND n1 W=1e-6 L=1e-6
mpway49_cell40 ML49 gate_way49_cell40 GND ML49 p1 W=2.4e-6 L=1e-6
mnway49_cell41 ML49 gate_way49_cell41 GND GND n1 W=1e-6 L=1e-6
mpway49_cell41 ML49 gate_way49_cell41 GND ML49 p1 W=2.4e-6 L=1e-6
mnway49_cell42 ML49 gate_way49_cell42 GND GND n1 W=1e-6 L=1e-6
mpway49_cell42 ML49 gate_way49_cell42 GND ML49 p1 W=2.4e-6 L=1e-6
mnway49_cell43 ML49 gate_way49_cell43 GND GND n1 W=1e-6 L=1e-6
mpway49_cell43 ML49 gate_way49_cell43 GND ML49 p1 W=2.4e-6 L=1e-6
mnway49_cell44 ML49 gate_way49_cell44 GND GND n1 W=1e-6 L=1e-6
mpway49_cell44 ML49 gate_way49_cell44 GND ML49 p1 W=2.4e-6 L=1e-6
mnway49_cell45 ML49 gate_way49_cell45 GND GND n1 W=1e-6 L=1e-6
mpway49_cell45 ML49 gate_way49_cell45 GND ML49 p1 W=2.4e-6 L=1e-6
mnway49_cell46 ML49 gate_way49_cell46 GND GND n1 W=1e-6 L=1e-6
mpway49_cell46 ML49 gate_way49_cell46 GND ML49 p1 W=2.4e-6 L=1e-6
mnway49_cell47 ML49 gate_way49_cell47 GND GND n1 W=1e-6 L=1e-6
mpway49_cell47 ML49 gate_way49_cell47 GND ML49 p1 W=2.4e-6 L=1e-6
mnway49_cell48 ML49 gate_way49_cell48 GND GND n1 W=1e-6 L=1e-6
mpway49_cell48 ML49 gate_way49_cell48 GND ML49 p1 W=2.4e-6 L=1e-6
mnway49_cell49 ML49 gate_way49_cell49 GND GND n1 W=1e-6 L=1e-6
mpway49_cell49 ML49 gate_way49_cell49 GND ML49 p1 W=2.4e-6 L=1e-6
mnway49_cell50 ML49 gate_way49_cell50 GND GND n1 W=1e-6 L=1e-6
mpway49_cell50 ML49 gate_way49_cell50 GND ML49 p1 W=2.4e-6 L=1e-6
mnway49_cell51 ML49 gate_way49_cell51 GND GND n1 W=1e-6 L=1e-6
mpway49_cell51 ML49 gate_way49_cell51 GND ML49 p1 W=2.4e-6 L=1e-6
mnway49_cell52 ML49 gate_way49_cell52 GND GND n1 W=1e-6 L=1e-6
mpway49_cell52 ML49 gate_way49_cell52 GND ML49 p1 W=2.4e-6 L=1e-6
mnway49_cell53 ML49 gate_way49_cell53 GND GND n1 W=1e-6 L=1e-6
mpway49_cell53 ML49 gate_way49_cell53 GND ML49 p1 W=2.4e-6 L=1e-6
mnway49_cell54 ML49 gate_way49_cell54 GND GND n1 W=1e-6 L=1e-6
mpway49_cell54 ML49 gate_way49_cell54 GND ML49 p1 W=2.4e-6 L=1e-6
mnway49_cell55 ML49 gate_way49_cell55 GND GND n1 W=1e-6 L=1e-6
mpway49_cell55 ML49 gate_way49_cell55 GND ML49 p1 W=2.4e-6 L=1e-6
mnway49_cell56 ML49 gate_way49_cell56 GND GND n1 W=1e-6 L=1e-6
mpway49_cell56 ML49 gate_way49_cell56 GND ML49 p1 W=2.4e-6 L=1e-6
mnway49_cell57 ML49 gate_way49_cell57 GND GND n1 W=1e-6 L=1e-6
mpway49_cell57 ML49 gate_way49_cell57 GND ML49 p1 W=2.4e-6 L=1e-6
mnway49_cell58 ML49 gate_way49_cell58 GND GND n1 W=1e-6 L=1e-6
mpway49_cell58 ML49 gate_way49_cell58 GND ML49 p1 W=2.4e-6 L=1e-6
mnway49_cell59 ML49 gate_way49_cell59 GND GND n1 W=1e-6 L=1e-6
mpway49_cell59 ML49 gate_way49_cell59 GND ML49 p1 W=2.4e-6 L=1e-6
mnway49_cell60 ML49 gate_way49_cell60 GND GND n1 W=1e-6 L=1e-6
mpway49_cell60 ML49 gate_way49_cell60 GND ML49 p1 W=2.4e-6 L=1e-6
mnway49_cell61 ML49 gate_way49_cell61 GND GND n1 W=1e-6 L=1e-6
mpway49_cell61 ML49 gate_way49_cell61 GND ML49 p1 W=2.4e-6 L=1e-6
mnway49_cell62 ML49 gate_way49_cell62 GND GND n1 W=1e-6 L=1e-6
mpway49_cell62 ML49 gate_way49_cell62 GND ML49 p1 W=2.4e-6 L=1e-6
mnway49_cell63 ML49 gate_way49_cell63 GND GND n1 W=1e-6 L=1e-6
mpway49_cell63 ML49 gate_way49_cell63 GND ML49 p1 W=2.4e-6 L=1e-6
mnway49_cell64 ML49 gate_way49_cell64 GND GND n1 W=1e-6 L=1e-6
mpway49_cell64 ML49 gate_way49_cell64 GND ML49 p1 W=2.4e-6 L=1e-6
mnway49_cell65 ML49 gate_way49_cell65 GND GND n1 W=1e-6 L=1e-6
mpway49_cell65 ML49 gate_way49_cell65 GND ML49 p1 W=2.4e-6 L=1e-6
mnway49_cell66 ML49 gate_way49_cell66 GND GND n1 W=1e-6 L=1e-6
mpway49_cell66 ML49 gate_way49_cell66 GND ML49 p1 W=2.4e-6 L=1e-6
mnway49_cell67 ML49 gate_way49_cell67 GND GND n1 W=1e-6 L=1e-6
mpway49_cell67 ML49 gate_way49_cell67 GND ML49 p1 W=2.4e-6 L=1e-6
mnway49_cell68 ML49 gate_way49_cell68 GND GND n1 W=1e-6 L=1e-6
mpway49_cell68 ML49 gate_way49_cell68 GND ML49 p1 W=2.4e-6 L=1e-6
mnway49_cell69 ML49 gate_way49_cell69 GND GND n1 W=1e-6 L=1e-6
mpway49_cell69 ML49 gate_way49_cell69 GND ML49 p1 W=2.4e-6 L=1e-6
mnway49_cell70 ML49 gate_way49_cell70 GND GND n1 W=1e-6 L=1e-6
mpway49_cell70 ML49 gate_way49_cell70 GND ML49 p1 W=2.4e-6 L=1e-6
mnway49_cell71 ML49 gate_way49_cell71 GND GND n1 W=1e-6 L=1e-6
mpway49_cell71 ML49 gate_way49_cell71 GND ML49 p1 W=2.4e-6 L=1e-6
mnway49_cell72 ML49 gate_way49_cell72 GND GND n1 W=1e-6 L=1e-6
mpway49_cell72 ML49 gate_way49_cell72 GND ML49 p1 W=2.4e-6 L=1e-6
mnway49_cell73 ML49 gate_way49_cell73 GND GND n1 W=1e-6 L=1e-6
mpway49_cell73 ML49 gate_way49_cell73 GND ML49 p1 W=2.4e-6 L=1e-6
mnway49_cell74 ML49 gate_way49_cell74 GND GND n1 W=1e-6 L=1e-6
mpway49_cell74 ML49 gate_way49_cell74 GND ML49 p1 W=2.4e-6 L=1e-6
mnway49_cell75 ML49 gate_way49_cell75 GND GND n1 W=1e-6 L=1e-6
mpway49_cell75 ML49 gate_way49_cell75 GND ML49 p1 W=2.4e-6 L=1e-6
mnway49_cell76 ML49 gate_way49_cell76 GND GND n1 W=1e-6 L=1e-6
mpway49_cell76 ML49 gate_way49_cell76 GND ML49 p1 W=2.4e-6 L=1e-6
mnway49_cell77 ML49 gate_way49_cell77 GND GND n1 W=1e-6 L=1e-6
mpway49_cell77 ML49 gate_way49_cell77 GND ML49 p1 W=2.4e-6 L=1e-6
mnway49_cell78 ML49 gate_way49_cell78 GND GND n1 W=1e-6 L=1e-6
mpway49_cell78 ML49 gate_way49_cell78 GND ML49 p1 W=2.4e-6 L=1e-6
mnway49_cell79 ML49 gate_way49_cell79 GND GND n1 W=1e-6 L=1e-6
mpway49_cell79 ML49 gate_way49_cell79 GND ML49 p1 W=2.4e-6 L=1e-6
mnway49_cell80 ML49 gate_way49_cell80 GND GND n1 W=1e-6 L=1e-6
mpway49_cell80 ML49 gate_way49_cell80 GND ML49 p1 W=2.4e-6 L=1e-6
mnway49_cell81 ML49 gate_way49_cell81 GND GND n1 W=1e-6 L=1e-6
mpway49_cell81 ML49 gate_way49_cell81 GND ML49 p1 W=2.4e-6 L=1e-6
mnway49_cell82 ML49 gate_way49_cell82 GND GND n1 W=1e-6 L=1e-6
mpway49_cell82 ML49 gate_way49_cell82 GND ML49 p1 W=2.4e-6 L=1e-6
mnway49_cell83 ML49 gate_way49_cell83 GND GND n1 W=1e-6 L=1e-6
mpway49_cell83 ML49 gate_way49_cell83 GND ML49 p1 W=2.4e-6 L=1e-6
mnway49_cell84 ML49 gate_way49_cell84 GND GND n1 W=1e-6 L=1e-6
mpway49_cell84 ML49 gate_way49_cell84 GND ML49 p1 W=2.4e-6 L=1e-6
mnway49_cell85 ML49 gate_way49_cell85 GND GND n1 W=1e-6 L=1e-6
mpway49_cell85 ML49 gate_way49_cell85 GND ML49 p1 W=2.4e-6 L=1e-6
mnway49_cell86 ML49 gate_way49_cell86 GND GND n1 W=1e-6 L=1e-6
mpway49_cell86 ML49 gate_way49_cell86 GND ML49 p1 W=2.4e-6 L=1e-6
mnway49_cell87 ML49 gate_way49_cell87 GND GND n1 W=1e-6 L=1e-6
mpway49_cell87 ML49 gate_way49_cell87 GND ML49 p1 W=2.4e-6 L=1e-6
mnway49_cell88 ML49 gate_way49_cell88 GND GND n1 W=1e-6 L=1e-6
mpway49_cell88 ML49 gate_way49_cell88 GND ML49 p1 W=2.4e-6 L=1e-6
mnway49_cell89 ML49 gate_way49_cell89 GND GND n1 W=1e-6 L=1e-6
mpway49_cell89 ML49 gate_way49_cell89 GND ML49 p1 W=2.4e-6 L=1e-6
mnway49_cell90 ML49 gate_way49_cell90 GND GND n1 W=1e-6 L=1e-6
mpway49_cell90 ML49 gate_way49_cell90 GND ML49 p1 W=2.4e-6 L=1e-6
mnway49_cell91 ML49 gate_way49_cell91 GND GND n1 W=1e-6 L=1e-6
mpway49_cell91 ML49 gate_way49_cell91 GND ML49 p1 W=2.4e-6 L=1e-6
mnway49_cell92 ML49 gate_way49_cell92 GND GND n1 W=1e-6 L=1e-6
mpway49_cell92 ML49 gate_way49_cell92 GND ML49 p1 W=2.4e-6 L=1e-6
mnway49_cell93 ML49 gate_way49_cell93 GND GND n1 W=1e-6 L=1e-6
mpway49_cell93 ML49 gate_way49_cell93 GND ML49 p1 W=2.4e-6 L=1e-6
mnway49_cell94 ML49 gate_way49_cell94 GND GND n1 W=1e-6 L=1e-6
mpway49_cell94 ML49 gate_way49_cell94 GND ML49 p1 W=2.4e-6 L=1e-6
mnway49_cell95 ML49 gate_way49_cell95 GND GND n1 W=1e-6 L=1e-6
mpway49_cell95 ML49 gate_way49_cell95 GND ML49 p1 W=2.4e-6 L=1e-6
mnway49_cell96 ML49 gate_way49_cell96 GND GND n1 W=1e-6 L=1e-6
mpway49_cell96 ML49 gate_way49_cell96 GND ML49 p1 W=2.4e-6 L=1e-6
mnway49_cell97 ML49 gate_way49_cell97 GND GND n1 W=1e-6 L=1e-6
mpway49_cell97 ML49 gate_way49_cell97 GND ML49 p1 W=2.4e-6 L=1e-6
mnway49_cell98 ML49 gate_way49_cell98 GND GND n1 W=1e-6 L=1e-6
mpway49_cell98 ML49 gate_way49_cell98 GND ML49 p1 W=2.4e-6 L=1e-6
mnway49_cell99 ML49 gate_way49_cell99 GND GND n1 W=1e-6 L=1e-6
mpway49_cell99 ML49 gate_way49_cell99 GND ML49 p1 W=2.4e-6 L=1e-6
mnway50_cell0 ML50 gate_way50_cell0 GND GND n1 W=1e-6 L=1e-6
mpway50_cell0 ML50 gate_way50_cell0 GND ML50 p1 W=2.4e-6 L=1e-6
mnway50_cell1 ML50 gate_way50_cell1 GND GND n1 W=1e-6 L=1e-6
mpway50_cell1 ML50 gate_way50_cell1 GND ML50 p1 W=2.4e-6 L=1e-6
mnway50_cell2 ML50 gate_way50_cell2 GND GND n1 W=1e-6 L=1e-6
mpway50_cell2 ML50 gate_way50_cell2 GND ML50 p1 W=2.4e-6 L=1e-6
mnway50_cell3 ML50 gate_way50_cell3 GND GND n1 W=1e-6 L=1e-6
mpway50_cell3 ML50 gate_way50_cell3 GND ML50 p1 W=2.4e-6 L=1e-6
mnway50_cell4 ML50 gate_way50_cell4 GND GND n1 W=1e-6 L=1e-6
mpway50_cell4 ML50 gate_way50_cell4 GND ML50 p1 W=2.4e-6 L=1e-6
mnway50_cell5 ML50 gate_way50_cell5 GND GND n1 W=1e-6 L=1e-6
mpway50_cell5 ML50 gate_way50_cell5 GND ML50 p1 W=2.4e-6 L=1e-6
mnway50_cell6 ML50 gate_way50_cell6 GND GND n1 W=1e-6 L=1e-6
mpway50_cell6 ML50 gate_way50_cell6 GND ML50 p1 W=2.4e-6 L=1e-6
mnway50_cell7 ML50 gate_way50_cell7 GND GND n1 W=1e-6 L=1e-6
mpway50_cell7 ML50 gate_way50_cell7 GND ML50 p1 W=2.4e-6 L=1e-6
mnway50_cell8 ML50 gate_way50_cell8 GND GND n1 W=1e-6 L=1e-6
mpway50_cell8 ML50 gate_way50_cell8 GND ML50 p1 W=2.4e-6 L=1e-6
mnway50_cell9 ML50 gate_way50_cell9 GND GND n1 W=1e-6 L=1e-6
mpway50_cell9 ML50 gate_way50_cell9 GND ML50 p1 W=2.4e-6 L=1e-6
mnway50_cell10 ML50 gate_way50_cell10 GND GND n1 W=1e-6 L=1e-6
mpway50_cell10 ML50 gate_way50_cell10 GND ML50 p1 W=2.4e-6 L=1e-6
mnway50_cell11 ML50 gate_way50_cell11 GND GND n1 W=1e-6 L=1e-6
mpway50_cell11 ML50 gate_way50_cell11 GND ML50 p1 W=2.4e-6 L=1e-6
mnway50_cell12 ML50 gate_way50_cell12 GND GND n1 W=1e-6 L=1e-6
mpway50_cell12 ML50 gate_way50_cell12 GND ML50 p1 W=2.4e-6 L=1e-6
mnway50_cell13 ML50 gate_way50_cell13 GND GND n1 W=1e-6 L=1e-6
mpway50_cell13 ML50 gate_way50_cell13 GND ML50 p1 W=2.4e-6 L=1e-6
mnway50_cell14 ML50 gate_way50_cell14 GND GND n1 W=1e-6 L=1e-6
mpway50_cell14 ML50 gate_way50_cell14 GND ML50 p1 W=2.4e-6 L=1e-6
mnway50_cell15 ML50 gate_way50_cell15 GND GND n1 W=1e-6 L=1e-6
mpway50_cell15 ML50 gate_way50_cell15 GND ML50 p1 W=2.4e-6 L=1e-6
mnway50_cell16 ML50 gate_way50_cell16 GND GND n1 W=1e-6 L=1e-6
mpway50_cell16 ML50 gate_way50_cell16 GND ML50 p1 W=2.4e-6 L=1e-6
mnway50_cell17 ML50 gate_way50_cell17 GND GND n1 W=1e-6 L=1e-6
mpway50_cell17 ML50 gate_way50_cell17 GND ML50 p1 W=2.4e-6 L=1e-6
mnway50_cell18 ML50 gate_way50_cell18 GND GND n1 W=1e-6 L=1e-6
mpway50_cell18 ML50 gate_way50_cell18 GND ML50 p1 W=2.4e-6 L=1e-6
mnway50_cell19 ML50 gate_way50_cell19 GND GND n1 W=1e-6 L=1e-6
mpway50_cell19 ML50 gate_way50_cell19 GND ML50 p1 W=2.4e-6 L=1e-6
mnway50_cell20 ML50 gate_way50_cell20 GND GND n1 W=1e-6 L=1e-6
mpway50_cell20 ML50 gate_way50_cell20 GND ML50 p1 W=2.4e-6 L=1e-6
mnway50_cell21 ML50 gate_way50_cell21 GND GND n1 W=1e-6 L=1e-6
mpway50_cell21 ML50 gate_way50_cell21 GND ML50 p1 W=2.4e-6 L=1e-6
mnway50_cell22 ML50 gate_way50_cell22 GND GND n1 W=1e-6 L=1e-6
mpway50_cell22 ML50 gate_way50_cell22 GND ML50 p1 W=2.4e-6 L=1e-6
mnway50_cell23 ML50 gate_way50_cell23 GND GND n1 W=1e-6 L=1e-6
mpway50_cell23 ML50 gate_way50_cell23 GND ML50 p1 W=2.4e-6 L=1e-6
mnway50_cell24 ML50 gate_way50_cell24 GND GND n1 W=1e-6 L=1e-6
mpway50_cell24 ML50 gate_way50_cell24 GND ML50 p1 W=2.4e-6 L=1e-6
mnway50_cell25 ML50 gate_way50_cell25 GND GND n1 W=1e-6 L=1e-6
mpway50_cell25 ML50 gate_way50_cell25 GND ML50 p1 W=2.4e-6 L=1e-6
mnway50_cell26 ML50 gate_way50_cell26 GND GND n1 W=1e-6 L=1e-6
mpway50_cell26 ML50 gate_way50_cell26 GND ML50 p1 W=2.4e-6 L=1e-6
mnway50_cell27 ML50 gate_way50_cell27 GND GND n1 W=1e-6 L=1e-6
mpway50_cell27 ML50 gate_way50_cell27 GND ML50 p1 W=2.4e-6 L=1e-6
mnway50_cell28 ML50 gate_way50_cell28 GND GND n1 W=1e-6 L=1e-6
mpway50_cell28 ML50 gate_way50_cell28 GND ML50 p1 W=2.4e-6 L=1e-6
mnway50_cell29 ML50 gate_way50_cell29 GND GND n1 W=1e-6 L=1e-6
mpway50_cell29 ML50 gate_way50_cell29 GND ML50 p1 W=2.4e-6 L=1e-6
mnway50_cell30 ML50 gate_way50_cell30 GND GND n1 W=1e-6 L=1e-6
mpway50_cell30 ML50 gate_way50_cell30 GND ML50 p1 W=2.4e-6 L=1e-6
mnway50_cell31 ML50 gate_way50_cell31 GND GND n1 W=1e-6 L=1e-6
mpway50_cell31 ML50 gate_way50_cell31 GND ML50 p1 W=2.4e-6 L=1e-6
mnway50_cell32 ML50 gate_way50_cell32 GND GND n1 W=1e-6 L=1e-6
mpway50_cell32 ML50 gate_way50_cell32 GND ML50 p1 W=2.4e-6 L=1e-6
mnway50_cell33 ML50 gate_way50_cell33 GND GND n1 W=1e-6 L=1e-6
mpway50_cell33 ML50 gate_way50_cell33 GND ML50 p1 W=2.4e-6 L=1e-6
mnway50_cell34 ML50 gate_way50_cell34 GND GND n1 W=1e-6 L=1e-6
mpway50_cell34 ML50 gate_way50_cell34 GND ML50 p1 W=2.4e-6 L=1e-6
mnway50_cell35 ML50 gate_way50_cell35 GND GND n1 W=1e-6 L=1e-6
mpway50_cell35 ML50 gate_way50_cell35 GND ML50 p1 W=2.4e-6 L=1e-6
mnway50_cell36 ML50 gate_way50_cell36 GND GND n1 W=1e-6 L=1e-6
mpway50_cell36 ML50 gate_way50_cell36 GND ML50 p1 W=2.4e-6 L=1e-6
mnway50_cell37 ML50 gate_way50_cell37 GND GND n1 W=1e-6 L=1e-6
mpway50_cell37 ML50 gate_way50_cell37 GND ML50 p1 W=2.4e-6 L=1e-6
mnway50_cell38 ML50 gate_way50_cell38 GND GND n1 W=1e-6 L=1e-6
mpway50_cell38 ML50 gate_way50_cell38 GND ML50 p1 W=2.4e-6 L=1e-6
mnway50_cell39 ML50 gate_way50_cell39 GND GND n1 W=1e-6 L=1e-6
mpway50_cell39 ML50 gate_way50_cell39 GND ML50 p1 W=2.4e-6 L=1e-6
mnway50_cell40 ML50 gate_way50_cell40 GND GND n1 W=1e-6 L=1e-6
mpway50_cell40 ML50 gate_way50_cell40 GND ML50 p1 W=2.4e-6 L=1e-6
mnway50_cell41 ML50 gate_way50_cell41 GND GND n1 W=1e-6 L=1e-6
mpway50_cell41 ML50 gate_way50_cell41 GND ML50 p1 W=2.4e-6 L=1e-6
mnway50_cell42 ML50 gate_way50_cell42 GND GND n1 W=1e-6 L=1e-6
mpway50_cell42 ML50 gate_way50_cell42 GND ML50 p1 W=2.4e-6 L=1e-6
mnway50_cell43 ML50 gate_way50_cell43 GND GND n1 W=1e-6 L=1e-6
mpway50_cell43 ML50 gate_way50_cell43 GND ML50 p1 W=2.4e-6 L=1e-6
mnway50_cell44 ML50 gate_way50_cell44 GND GND n1 W=1e-6 L=1e-6
mpway50_cell44 ML50 gate_way50_cell44 GND ML50 p1 W=2.4e-6 L=1e-6
mnway50_cell45 ML50 gate_way50_cell45 GND GND n1 W=1e-6 L=1e-6
mpway50_cell45 ML50 gate_way50_cell45 GND ML50 p1 W=2.4e-6 L=1e-6
mnway50_cell46 ML50 gate_way50_cell46 GND GND n1 W=1e-6 L=1e-6
mpway50_cell46 ML50 gate_way50_cell46 GND ML50 p1 W=2.4e-6 L=1e-6
mnway50_cell47 ML50 gate_way50_cell47 GND GND n1 W=1e-6 L=1e-6
mpway50_cell47 ML50 gate_way50_cell47 GND ML50 p1 W=2.4e-6 L=1e-6
mnway50_cell48 ML50 gate_way50_cell48 GND GND n1 W=1e-6 L=1e-6
mpway50_cell48 ML50 gate_way50_cell48 GND ML50 p1 W=2.4e-6 L=1e-6
mnway50_cell49 ML50 gate_way50_cell49 GND GND n1 W=1e-6 L=1e-6
mpway50_cell49 ML50 gate_way50_cell49 GND ML50 p1 W=2.4e-6 L=1e-6
mnway50_cell50 ML50 gate_way50_cell50 GND GND n1 W=1e-6 L=1e-6
mpway50_cell50 ML50 gate_way50_cell50 GND ML50 p1 W=2.4e-6 L=1e-6
mnway50_cell51 ML50 gate_way50_cell51 GND GND n1 W=1e-6 L=1e-6
mpway50_cell51 ML50 gate_way50_cell51 GND ML50 p1 W=2.4e-6 L=1e-6
mnway50_cell52 ML50 gate_way50_cell52 GND GND n1 W=1e-6 L=1e-6
mpway50_cell52 ML50 gate_way50_cell52 GND ML50 p1 W=2.4e-6 L=1e-6
mnway50_cell53 ML50 gate_way50_cell53 GND GND n1 W=1e-6 L=1e-6
mpway50_cell53 ML50 gate_way50_cell53 GND ML50 p1 W=2.4e-6 L=1e-6
mnway50_cell54 ML50 gate_way50_cell54 GND GND n1 W=1e-6 L=1e-6
mpway50_cell54 ML50 gate_way50_cell54 GND ML50 p1 W=2.4e-6 L=1e-6
mnway50_cell55 ML50 gate_way50_cell55 GND GND n1 W=1e-6 L=1e-6
mpway50_cell55 ML50 gate_way50_cell55 GND ML50 p1 W=2.4e-6 L=1e-6
mnway50_cell56 ML50 gate_way50_cell56 GND GND n1 W=1e-6 L=1e-6
mpway50_cell56 ML50 gate_way50_cell56 GND ML50 p1 W=2.4e-6 L=1e-6
mnway50_cell57 ML50 gate_way50_cell57 GND GND n1 W=1e-6 L=1e-6
mpway50_cell57 ML50 gate_way50_cell57 GND ML50 p1 W=2.4e-6 L=1e-6
mnway50_cell58 ML50 gate_way50_cell58 GND GND n1 W=1e-6 L=1e-6
mpway50_cell58 ML50 gate_way50_cell58 GND ML50 p1 W=2.4e-6 L=1e-6
mnway50_cell59 ML50 gate_way50_cell59 GND GND n1 W=1e-6 L=1e-6
mpway50_cell59 ML50 gate_way50_cell59 GND ML50 p1 W=2.4e-6 L=1e-6
mnway50_cell60 ML50 gate_way50_cell60 GND GND n1 W=1e-6 L=1e-6
mpway50_cell60 ML50 gate_way50_cell60 GND ML50 p1 W=2.4e-6 L=1e-6
mnway50_cell61 ML50 gate_way50_cell61 GND GND n1 W=1e-6 L=1e-6
mpway50_cell61 ML50 gate_way50_cell61 GND ML50 p1 W=2.4e-6 L=1e-6
mnway50_cell62 ML50 gate_way50_cell62 GND GND n1 W=1e-6 L=1e-6
mpway50_cell62 ML50 gate_way50_cell62 GND ML50 p1 W=2.4e-6 L=1e-6
mnway50_cell63 ML50 gate_way50_cell63 GND GND n1 W=1e-6 L=1e-6
mpway50_cell63 ML50 gate_way50_cell63 GND ML50 p1 W=2.4e-6 L=1e-6
mnway50_cell64 ML50 gate_way50_cell64 GND GND n1 W=1e-6 L=1e-6
mpway50_cell64 ML50 gate_way50_cell64 GND ML50 p1 W=2.4e-6 L=1e-6
mnway50_cell65 ML50 gate_way50_cell65 GND GND n1 W=1e-6 L=1e-6
mpway50_cell65 ML50 gate_way50_cell65 GND ML50 p1 W=2.4e-6 L=1e-6
mnway50_cell66 ML50 gate_way50_cell66 GND GND n1 W=1e-6 L=1e-6
mpway50_cell66 ML50 gate_way50_cell66 GND ML50 p1 W=2.4e-6 L=1e-6
mnway50_cell67 ML50 gate_way50_cell67 GND GND n1 W=1e-6 L=1e-6
mpway50_cell67 ML50 gate_way50_cell67 GND ML50 p1 W=2.4e-6 L=1e-6
mnway50_cell68 ML50 gate_way50_cell68 GND GND n1 W=1e-6 L=1e-6
mpway50_cell68 ML50 gate_way50_cell68 GND ML50 p1 W=2.4e-6 L=1e-6
mnway50_cell69 ML50 gate_way50_cell69 GND GND n1 W=1e-6 L=1e-6
mpway50_cell69 ML50 gate_way50_cell69 GND ML50 p1 W=2.4e-6 L=1e-6
mnway50_cell70 ML50 gate_way50_cell70 GND GND n1 W=1e-6 L=1e-6
mpway50_cell70 ML50 gate_way50_cell70 GND ML50 p1 W=2.4e-6 L=1e-6
mnway50_cell71 ML50 gate_way50_cell71 GND GND n1 W=1e-6 L=1e-6
mpway50_cell71 ML50 gate_way50_cell71 GND ML50 p1 W=2.4e-6 L=1e-6
mnway50_cell72 ML50 gate_way50_cell72 GND GND n1 W=1e-6 L=1e-6
mpway50_cell72 ML50 gate_way50_cell72 GND ML50 p1 W=2.4e-6 L=1e-6
mnway50_cell73 ML50 gate_way50_cell73 GND GND n1 W=1e-6 L=1e-6
mpway50_cell73 ML50 gate_way50_cell73 GND ML50 p1 W=2.4e-6 L=1e-6
mnway50_cell74 ML50 gate_way50_cell74 GND GND n1 W=1e-6 L=1e-6
mpway50_cell74 ML50 gate_way50_cell74 GND ML50 p1 W=2.4e-6 L=1e-6
mnway50_cell75 ML50 gate_way50_cell75 GND GND n1 W=1e-6 L=1e-6
mpway50_cell75 ML50 gate_way50_cell75 GND ML50 p1 W=2.4e-6 L=1e-6
mnway50_cell76 ML50 gate_way50_cell76 GND GND n1 W=1e-6 L=1e-6
mpway50_cell76 ML50 gate_way50_cell76 GND ML50 p1 W=2.4e-6 L=1e-6
mnway50_cell77 ML50 gate_way50_cell77 GND GND n1 W=1e-6 L=1e-6
mpway50_cell77 ML50 gate_way50_cell77 GND ML50 p1 W=2.4e-6 L=1e-6
mnway50_cell78 ML50 gate_way50_cell78 GND GND n1 W=1e-6 L=1e-6
mpway50_cell78 ML50 gate_way50_cell78 GND ML50 p1 W=2.4e-6 L=1e-6
mnway50_cell79 ML50 gate_way50_cell79 GND GND n1 W=1e-6 L=1e-6
mpway50_cell79 ML50 gate_way50_cell79 GND ML50 p1 W=2.4e-6 L=1e-6
mnway50_cell80 ML50 gate_way50_cell80 GND GND n1 W=1e-6 L=1e-6
mpway50_cell80 ML50 gate_way50_cell80 GND ML50 p1 W=2.4e-6 L=1e-6
mnway50_cell81 ML50 gate_way50_cell81 GND GND n1 W=1e-6 L=1e-6
mpway50_cell81 ML50 gate_way50_cell81 GND ML50 p1 W=2.4e-6 L=1e-6
mnway50_cell82 ML50 gate_way50_cell82 GND GND n1 W=1e-6 L=1e-6
mpway50_cell82 ML50 gate_way50_cell82 GND ML50 p1 W=2.4e-6 L=1e-6
mnway50_cell83 ML50 gate_way50_cell83 GND GND n1 W=1e-6 L=1e-6
mpway50_cell83 ML50 gate_way50_cell83 GND ML50 p1 W=2.4e-6 L=1e-6
mnway50_cell84 ML50 gate_way50_cell84 GND GND n1 W=1e-6 L=1e-6
mpway50_cell84 ML50 gate_way50_cell84 GND ML50 p1 W=2.4e-6 L=1e-6
mnway50_cell85 ML50 gate_way50_cell85 GND GND n1 W=1e-6 L=1e-6
mpway50_cell85 ML50 gate_way50_cell85 GND ML50 p1 W=2.4e-6 L=1e-6
mnway50_cell86 ML50 gate_way50_cell86 GND GND n1 W=1e-6 L=1e-6
mpway50_cell86 ML50 gate_way50_cell86 GND ML50 p1 W=2.4e-6 L=1e-6
mnway50_cell87 ML50 gate_way50_cell87 GND GND n1 W=1e-6 L=1e-6
mpway50_cell87 ML50 gate_way50_cell87 GND ML50 p1 W=2.4e-6 L=1e-6
mnway50_cell88 ML50 gate_way50_cell88 GND GND n1 W=1e-6 L=1e-6
mpway50_cell88 ML50 gate_way50_cell88 GND ML50 p1 W=2.4e-6 L=1e-6
mnway50_cell89 ML50 gate_way50_cell89 GND GND n1 W=1e-6 L=1e-6
mpway50_cell89 ML50 gate_way50_cell89 GND ML50 p1 W=2.4e-6 L=1e-6
mnway50_cell90 ML50 gate_way50_cell90 GND GND n1 W=1e-6 L=1e-6
mpway50_cell90 ML50 gate_way50_cell90 GND ML50 p1 W=2.4e-6 L=1e-6
mnway50_cell91 ML50 gate_way50_cell91 GND GND n1 W=1e-6 L=1e-6
mpway50_cell91 ML50 gate_way50_cell91 GND ML50 p1 W=2.4e-6 L=1e-6
mnway50_cell92 ML50 gate_way50_cell92 GND GND n1 W=1e-6 L=1e-6
mpway50_cell92 ML50 gate_way50_cell92 GND ML50 p1 W=2.4e-6 L=1e-6
mnway50_cell93 ML50 gate_way50_cell93 GND GND n1 W=1e-6 L=1e-6
mpway50_cell93 ML50 gate_way50_cell93 GND ML50 p1 W=2.4e-6 L=1e-6
mnway50_cell94 ML50 gate_way50_cell94 GND GND n1 W=1e-6 L=1e-6
mpway50_cell94 ML50 gate_way50_cell94 GND ML50 p1 W=2.4e-6 L=1e-6
mnway50_cell95 ML50 gate_way50_cell95 GND GND n1 W=1e-6 L=1e-6
mpway50_cell95 ML50 gate_way50_cell95 GND ML50 p1 W=2.4e-6 L=1e-6
mnway50_cell96 ML50 gate_way50_cell96 GND GND n1 W=1e-6 L=1e-6
mpway50_cell96 ML50 gate_way50_cell96 GND ML50 p1 W=2.4e-6 L=1e-6
mnway50_cell97 ML50 gate_way50_cell97 GND GND n1 W=1e-6 L=1e-6
mpway50_cell97 ML50 gate_way50_cell97 GND ML50 p1 W=2.4e-6 L=1e-6
mnway50_cell98 ML50 gate_way50_cell98 GND GND n1 W=1e-6 L=1e-6
mpway50_cell98 ML50 gate_way50_cell98 GND ML50 p1 W=2.4e-6 L=1e-6
mnway50_cell99 ML50 gate_way50_cell99 GND GND n1 W=1e-6 L=1e-6
mpway50_cell99 ML50 gate_way50_cell99 GND ML50 p1 W=2.4e-6 L=1e-6
mnway51_cell0 ML51 gate_way51_cell0 GND GND n1 W=1e-6 L=1e-6
mpway51_cell0 ML51 gate_way51_cell0 GND ML51 p1 W=2.4e-6 L=1e-6
mnway51_cell1 ML51 gate_way51_cell1 GND GND n1 W=1e-6 L=1e-6
mpway51_cell1 ML51 gate_way51_cell1 GND ML51 p1 W=2.4e-6 L=1e-6
mnway51_cell2 ML51 gate_way51_cell2 GND GND n1 W=1e-6 L=1e-6
mpway51_cell2 ML51 gate_way51_cell2 GND ML51 p1 W=2.4e-6 L=1e-6
mnway51_cell3 ML51 gate_way51_cell3 GND GND n1 W=1e-6 L=1e-6
mpway51_cell3 ML51 gate_way51_cell3 GND ML51 p1 W=2.4e-6 L=1e-6
mnway51_cell4 ML51 gate_way51_cell4 GND GND n1 W=1e-6 L=1e-6
mpway51_cell4 ML51 gate_way51_cell4 GND ML51 p1 W=2.4e-6 L=1e-6
mnway51_cell5 ML51 gate_way51_cell5 GND GND n1 W=1e-6 L=1e-6
mpway51_cell5 ML51 gate_way51_cell5 GND ML51 p1 W=2.4e-6 L=1e-6
mnway51_cell6 ML51 gate_way51_cell6 GND GND n1 W=1e-6 L=1e-6
mpway51_cell6 ML51 gate_way51_cell6 GND ML51 p1 W=2.4e-6 L=1e-6
mnway51_cell7 ML51 gate_way51_cell7 GND GND n1 W=1e-6 L=1e-6
mpway51_cell7 ML51 gate_way51_cell7 GND ML51 p1 W=2.4e-6 L=1e-6
mnway51_cell8 ML51 gate_way51_cell8 GND GND n1 W=1e-6 L=1e-6
mpway51_cell8 ML51 gate_way51_cell8 GND ML51 p1 W=2.4e-6 L=1e-6
mnway51_cell9 ML51 gate_way51_cell9 GND GND n1 W=1e-6 L=1e-6
mpway51_cell9 ML51 gate_way51_cell9 GND ML51 p1 W=2.4e-6 L=1e-6
mnway51_cell10 ML51 gate_way51_cell10 GND GND n1 W=1e-6 L=1e-6
mpway51_cell10 ML51 gate_way51_cell10 GND ML51 p1 W=2.4e-6 L=1e-6
mnway51_cell11 ML51 gate_way51_cell11 GND GND n1 W=1e-6 L=1e-6
mpway51_cell11 ML51 gate_way51_cell11 GND ML51 p1 W=2.4e-6 L=1e-6
mnway51_cell12 ML51 gate_way51_cell12 GND GND n1 W=1e-6 L=1e-6
mpway51_cell12 ML51 gate_way51_cell12 GND ML51 p1 W=2.4e-6 L=1e-6
mnway51_cell13 ML51 gate_way51_cell13 GND GND n1 W=1e-6 L=1e-6
mpway51_cell13 ML51 gate_way51_cell13 GND ML51 p1 W=2.4e-6 L=1e-6
mnway51_cell14 ML51 gate_way51_cell14 GND GND n1 W=1e-6 L=1e-6
mpway51_cell14 ML51 gate_way51_cell14 GND ML51 p1 W=2.4e-6 L=1e-6
mnway51_cell15 ML51 gate_way51_cell15 GND GND n1 W=1e-6 L=1e-6
mpway51_cell15 ML51 gate_way51_cell15 GND ML51 p1 W=2.4e-6 L=1e-6
mnway51_cell16 ML51 gate_way51_cell16 GND GND n1 W=1e-6 L=1e-6
mpway51_cell16 ML51 gate_way51_cell16 GND ML51 p1 W=2.4e-6 L=1e-6
mnway51_cell17 ML51 gate_way51_cell17 GND GND n1 W=1e-6 L=1e-6
mpway51_cell17 ML51 gate_way51_cell17 GND ML51 p1 W=2.4e-6 L=1e-6
mnway51_cell18 ML51 gate_way51_cell18 GND GND n1 W=1e-6 L=1e-6
mpway51_cell18 ML51 gate_way51_cell18 GND ML51 p1 W=2.4e-6 L=1e-6
mnway51_cell19 ML51 gate_way51_cell19 GND GND n1 W=1e-6 L=1e-6
mpway51_cell19 ML51 gate_way51_cell19 GND ML51 p1 W=2.4e-6 L=1e-6
mnway51_cell20 ML51 gate_way51_cell20 GND GND n1 W=1e-6 L=1e-6
mpway51_cell20 ML51 gate_way51_cell20 GND ML51 p1 W=2.4e-6 L=1e-6
mnway51_cell21 ML51 gate_way51_cell21 GND GND n1 W=1e-6 L=1e-6
mpway51_cell21 ML51 gate_way51_cell21 GND ML51 p1 W=2.4e-6 L=1e-6
mnway51_cell22 ML51 gate_way51_cell22 GND GND n1 W=1e-6 L=1e-6
mpway51_cell22 ML51 gate_way51_cell22 GND ML51 p1 W=2.4e-6 L=1e-6
mnway51_cell23 ML51 gate_way51_cell23 GND GND n1 W=1e-6 L=1e-6
mpway51_cell23 ML51 gate_way51_cell23 GND ML51 p1 W=2.4e-6 L=1e-6
mnway51_cell24 ML51 gate_way51_cell24 GND GND n1 W=1e-6 L=1e-6
mpway51_cell24 ML51 gate_way51_cell24 GND ML51 p1 W=2.4e-6 L=1e-6
mnway51_cell25 ML51 gate_way51_cell25 GND GND n1 W=1e-6 L=1e-6
mpway51_cell25 ML51 gate_way51_cell25 GND ML51 p1 W=2.4e-6 L=1e-6
mnway51_cell26 ML51 gate_way51_cell26 GND GND n1 W=1e-6 L=1e-6
mpway51_cell26 ML51 gate_way51_cell26 GND ML51 p1 W=2.4e-6 L=1e-6
mnway51_cell27 ML51 gate_way51_cell27 GND GND n1 W=1e-6 L=1e-6
mpway51_cell27 ML51 gate_way51_cell27 GND ML51 p1 W=2.4e-6 L=1e-6
mnway51_cell28 ML51 gate_way51_cell28 GND GND n1 W=1e-6 L=1e-6
mpway51_cell28 ML51 gate_way51_cell28 GND ML51 p1 W=2.4e-6 L=1e-6
mnway51_cell29 ML51 gate_way51_cell29 GND GND n1 W=1e-6 L=1e-6
mpway51_cell29 ML51 gate_way51_cell29 GND ML51 p1 W=2.4e-6 L=1e-6
mnway51_cell30 ML51 gate_way51_cell30 GND GND n1 W=1e-6 L=1e-6
mpway51_cell30 ML51 gate_way51_cell30 GND ML51 p1 W=2.4e-6 L=1e-6
mnway51_cell31 ML51 gate_way51_cell31 GND GND n1 W=1e-6 L=1e-6
mpway51_cell31 ML51 gate_way51_cell31 GND ML51 p1 W=2.4e-6 L=1e-6
mnway51_cell32 ML51 gate_way51_cell32 GND GND n1 W=1e-6 L=1e-6
mpway51_cell32 ML51 gate_way51_cell32 GND ML51 p1 W=2.4e-6 L=1e-6
mnway51_cell33 ML51 gate_way51_cell33 GND GND n1 W=1e-6 L=1e-6
mpway51_cell33 ML51 gate_way51_cell33 GND ML51 p1 W=2.4e-6 L=1e-6
mnway51_cell34 ML51 gate_way51_cell34 GND GND n1 W=1e-6 L=1e-6
mpway51_cell34 ML51 gate_way51_cell34 GND ML51 p1 W=2.4e-6 L=1e-6
mnway51_cell35 ML51 gate_way51_cell35 GND GND n1 W=1e-6 L=1e-6
mpway51_cell35 ML51 gate_way51_cell35 GND ML51 p1 W=2.4e-6 L=1e-6
mnway51_cell36 ML51 gate_way51_cell36 GND GND n1 W=1e-6 L=1e-6
mpway51_cell36 ML51 gate_way51_cell36 GND ML51 p1 W=2.4e-6 L=1e-6
mnway51_cell37 ML51 gate_way51_cell37 GND GND n1 W=1e-6 L=1e-6
mpway51_cell37 ML51 gate_way51_cell37 GND ML51 p1 W=2.4e-6 L=1e-6
mnway51_cell38 ML51 gate_way51_cell38 GND GND n1 W=1e-6 L=1e-6
mpway51_cell38 ML51 gate_way51_cell38 GND ML51 p1 W=2.4e-6 L=1e-6
mnway51_cell39 ML51 gate_way51_cell39 GND GND n1 W=1e-6 L=1e-6
mpway51_cell39 ML51 gate_way51_cell39 GND ML51 p1 W=2.4e-6 L=1e-6
mnway51_cell40 ML51 gate_way51_cell40 GND GND n1 W=1e-6 L=1e-6
mpway51_cell40 ML51 gate_way51_cell40 GND ML51 p1 W=2.4e-6 L=1e-6
mnway51_cell41 ML51 gate_way51_cell41 GND GND n1 W=1e-6 L=1e-6
mpway51_cell41 ML51 gate_way51_cell41 GND ML51 p1 W=2.4e-6 L=1e-6
mnway51_cell42 ML51 gate_way51_cell42 GND GND n1 W=1e-6 L=1e-6
mpway51_cell42 ML51 gate_way51_cell42 GND ML51 p1 W=2.4e-6 L=1e-6
mnway51_cell43 ML51 gate_way51_cell43 GND GND n1 W=1e-6 L=1e-6
mpway51_cell43 ML51 gate_way51_cell43 GND ML51 p1 W=2.4e-6 L=1e-6
mnway51_cell44 ML51 gate_way51_cell44 GND GND n1 W=1e-6 L=1e-6
mpway51_cell44 ML51 gate_way51_cell44 GND ML51 p1 W=2.4e-6 L=1e-6
mnway51_cell45 ML51 gate_way51_cell45 GND GND n1 W=1e-6 L=1e-6
mpway51_cell45 ML51 gate_way51_cell45 GND ML51 p1 W=2.4e-6 L=1e-6
mnway51_cell46 ML51 gate_way51_cell46 GND GND n1 W=1e-6 L=1e-6
mpway51_cell46 ML51 gate_way51_cell46 GND ML51 p1 W=2.4e-6 L=1e-6
mnway51_cell47 ML51 gate_way51_cell47 GND GND n1 W=1e-6 L=1e-6
mpway51_cell47 ML51 gate_way51_cell47 GND ML51 p1 W=2.4e-6 L=1e-6
mnway51_cell48 ML51 gate_way51_cell48 GND GND n1 W=1e-6 L=1e-6
mpway51_cell48 ML51 gate_way51_cell48 GND ML51 p1 W=2.4e-6 L=1e-6
mnway51_cell49 ML51 gate_way51_cell49 GND GND n1 W=1e-6 L=1e-6
mpway51_cell49 ML51 gate_way51_cell49 GND ML51 p1 W=2.4e-6 L=1e-6
mnway51_cell50 ML51 gate_way51_cell50 GND GND n1 W=1e-6 L=1e-6
mpway51_cell50 ML51 gate_way51_cell50 GND ML51 p1 W=2.4e-6 L=1e-6
mnway51_cell51 ML51 gate_way51_cell51 GND GND n1 W=1e-6 L=1e-6
mpway51_cell51 ML51 gate_way51_cell51 GND ML51 p1 W=2.4e-6 L=1e-6
mnway51_cell52 ML51 gate_way51_cell52 GND GND n1 W=1e-6 L=1e-6
mpway51_cell52 ML51 gate_way51_cell52 GND ML51 p1 W=2.4e-6 L=1e-6
mnway51_cell53 ML51 gate_way51_cell53 GND GND n1 W=1e-6 L=1e-6
mpway51_cell53 ML51 gate_way51_cell53 GND ML51 p1 W=2.4e-6 L=1e-6
mnway51_cell54 ML51 gate_way51_cell54 GND GND n1 W=1e-6 L=1e-6
mpway51_cell54 ML51 gate_way51_cell54 GND ML51 p1 W=2.4e-6 L=1e-6
mnway51_cell55 ML51 gate_way51_cell55 GND GND n1 W=1e-6 L=1e-6
mpway51_cell55 ML51 gate_way51_cell55 GND ML51 p1 W=2.4e-6 L=1e-6
mnway51_cell56 ML51 gate_way51_cell56 GND GND n1 W=1e-6 L=1e-6
mpway51_cell56 ML51 gate_way51_cell56 GND ML51 p1 W=2.4e-6 L=1e-6
mnway51_cell57 ML51 gate_way51_cell57 GND GND n1 W=1e-6 L=1e-6
mpway51_cell57 ML51 gate_way51_cell57 GND ML51 p1 W=2.4e-6 L=1e-6
mnway51_cell58 ML51 gate_way51_cell58 GND GND n1 W=1e-6 L=1e-6
mpway51_cell58 ML51 gate_way51_cell58 GND ML51 p1 W=2.4e-6 L=1e-6
mnway51_cell59 ML51 gate_way51_cell59 GND GND n1 W=1e-6 L=1e-6
mpway51_cell59 ML51 gate_way51_cell59 GND ML51 p1 W=2.4e-6 L=1e-6
mnway51_cell60 ML51 gate_way51_cell60 GND GND n1 W=1e-6 L=1e-6
mpway51_cell60 ML51 gate_way51_cell60 GND ML51 p1 W=2.4e-6 L=1e-6
mnway51_cell61 ML51 gate_way51_cell61 GND GND n1 W=1e-6 L=1e-6
mpway51_cell61 ML51 gate_way51_cell61 GND ML51 p1 W=2.4e-6 L=1e-6
mnway51_cell62 ML51 gate_way51_cell62 GND GND n1 W=1e-6 L=1e-6
mpway51_cell62 ML51 gate_way51_cell62 GND ML51 p1 W=2.4e-6 L=1e-6
mnway51_cell63 ML51 gate_way51_cell63 GND GND n1 W=1e-6 L=1e-6
mpway51_cell63 ML51 gate_way51_cell63 GND ML51 p1 W=2.4e-6 L=1e-6
mnway51_cell64 ML51 gate_way51_cell64 GND GND n1 W=1e-6 L=1e-6
mpway51_cell64 ML51 gate_way51_cell64 GND ML51 p1 W=2.4e-6 L=1e-6
mnway51_cell65 ML51 gate_way51_cell65 GND GND n1 W=1e-6 L=1e-6
mpway51_cell65 ML51 gate_way51_cell65 GND ML51 p1 W=2.4e-6 L=1e-6
mnway51_cell66 ML51 gate_way51_cell66 GND GND n1 W=1e-6 L=1e-6
mpway51_cell66 ML51 gate_way51_cell66 GND ML51 p1 W=2.4e-6 L=1e-6
mnway51_cell67 ML51 gate_way51_cell67 GND GND n1 W=1e-6 L=1e-6
mpway51_cell67 ML51 gate_way51_cell67 GND ML51 p1 W=2.4e-6 L=1e-6
mnway51_cell68 ML51 gate_way51_cell68 GND GND n1 W=1e-6 L=1e-6
mpway51_cell68 ML51 gate_way51_cell68 GND ML51 p1 W=2.4e-6 L=1e-6
mnway51_cell69 ML51 gate_way51_cell69 GND GND n1 W=1e-6 L=1e-6
mpway51_cell69 ML51 gate_way51_cell69 GND ML51 p1 W=2.4e-6 L=1e-6
mnway51_cell70 ML51 gate_way51_cell70 GND GND n1 W=1e-6 L=1e-6
mpway51_cell70 ML51 gate_way51_cell70 GND ML51 p1 W=2.4e-6 L=1e-6
mnway51_cell71 ML51 gate_way51_cell71 GND GND n1 W=1e-6 L=1e-6
mpway51_cell71 ML51 gate_way51_cell71 GND ML51 p1 W=2.4e-6 L=1e-6
mnway51_cell72 ML51 gate_way51_cell72 GND GND n1 W=1e-6 L=1e-6
mpway51_cell72 ML51 gate_way51_cell72 GND ML51 p1 W=2.4e-6 L=1e-6
mnway51_cell73 ML51 gate_way51_cell73 GND GND n1 W=1e-6 L=1e-6
mpway51_cell73 ML51 gate_way51_cell73 GND ML51 p1 W=2.4e-6 L=1e-6
mnway51_cell74 ML51 gate_way51_cell74 GND GND n1 W=1e-6 L=1e-6
mpway51_cell74 ML51 gate_way51_cell74 GND ML51 p1 W=2.4e-6 L=1e-6
mnway51_cell75 ML51 gate_way51_cell75 GND GND n1 W=1e-6 L=1e-6
mpway51_cell75 ML51 gate_way51_cell75 GND ML51 p1 W=2.4e-6 L=1e-6
mnway51_cell76 ML51 gate_way51_cell76 GND GND n1 W=1e-6 L=1e-6
mpway51_cell76 ML51 gate_way51_cell76 GND ML51 p1 W=2.4e-6 L=1e-6
mnway51_cell77 ML51 gate_way51_cell77 GND GND n1 W=1e-6 L=1e-6
mpway51_cell77 ML51 gate_way51_cell77 GND ML51 p1 W=2.4e-6 L=1e-6
mnway51_cell78 ML51 gate_way51_cell78 GND GND n1 W=1e-6 L=1e-6
mpway51_cell78 ML51 gate_way51_cell78 GND ML51 p1 W=2.4e-6 L=1e-6
mnway51_cell79 ML51 gate_way51_cell79 GND GND n1 W=1e-6 L=1e-6
mpway51_cell79 ML51 gate_way51_cell79 GND ML51 p1 W=2.4e-6 L=1e-6
mnway51_cell80 ML51 gate_way51_cell80 GND GND n1 W=1e-6 L=1e-6
mpway51_cell80 ML51 gate_way51_cell80 GND ML51 p1 W=2.4e-6 L=1e-6
mnway51_cell81 ML51 gate_way51_cell81 GND GND n1 W=1e-6 L=1e-6
mpway51_cell81 ML51 gate_way51_cell81 GND ML51 p1 W=2.4e-6 L=1e-6
mnway51_cell82 ML51 gate_way51_cell82 GND GND n1 W=1e-6 L=1e-6
mpway51_cell82 ML51 gate_way51_cell82 GND ML51 p1 W=2.4e-6 L=1e-6
mnway51_cell83 ML51 gate_way51_cell83 GND GND n1 W=1e-6 L=1e-6
mpway51_cell83 ML51 gate_way51_cell83 GND ML51 p1 W=2.4e-6 L=1e-6
mnway51_cell84 ML51 gate_way51_cell84 GND GND n1 W=1e-6 L=1e-6
mpway51_cell84 ML51 gate_way51_cell84 GND ML51 p1 W=2.4e-6 L=1e-6
mnway51_cell85 ML51 gate_way51_cell85 GND GND n1 W=1e-6 L=1e-6
mpway51_cell85 ML51 gate_way51_cell85 GND ML51 p1 W=2.4e-6 L=1e-6
mnway51_cell86 ML51 gate_way51_cell86 GND GND n1 W=1e-6 L=1e-6
mpway51_cell86 ML51 gate_way51_cell86 GND ML51 p1 W=2.4e-6 L=1e-6
mnway51_cell87 ML51 gate_way51_cell87 GND GND n1 W=1e-6 L=1e-6
mpway51_cell87 ML51 gate_way51_cell87 GND ML51 p1 W=2.4e-6 L=1e-6
mnway51_cell88 ML51 gate_way51_cell88 GND GND n1 W=1e-6 L=1e-6
mpway51_cell88 ML51 gate_way51_cell88 GND ML51 p1 W=2.4e-6 L=1e-6
mnway51_cell89 ML51 gate_way51_cell89 GND GND n1 W=1e-6 L=1e-6
mpway51_cell89 ML51 gate_way51_cell89 GND ML51 p1 W=2.4e-6 L=1e-6
mnway51_cell90 ML51 gate_way51_cell90 GND GND n1 W=1e-6 L=1e-6
mpway51_cell90 ML51 gate_way51_cell90 GND ML51 p1 W=2.4e-6 L=1e-6
mnway51_cell91 ML51 gate_way51_cell91 GND GND n1 W=1e-6 L=1e-6
mpway51_cell91 ML51 gate_way51_cell91 GND ML51 p1 W=2.4e-6 L=1e-6
mnway51_cell92 ML51 gate_way51_cell92 GND GND n1 W=1e-6 L=1e-6
mpway51_cell92 ML51 gate_way51_cell92 GND ML51 p1 W=2.4e-6 L=1e-6
mnway51_cell93 ML51 gate_way51_cell93 GND GND n1 W=1e-6 L=1e-6
mpway51_cell93 ML51 gate_way51_cell93 GND ML51 p1 W=2.4e-6 L=1e-6
mnway51_cell94 ML51 gate_way51_cell94 GND GND n1 W=1e-6 L=1e-6
mpway51_cell94 ML51 gate_way51_cell94 GND ML51 p1 W=2.4e-6 L=1e-6
mnway51_cell95 ML51 gate_way51_cell95 GND GND n1 W=1e-6 L=1e-6
mpway51_cell95 ML51 gate_way51_cell95 GND ML51 p1 W=2.4e-6 L=1e-6
mnway51_cell96 ML51 gate_way51_cell96 GND GND n1 W=1e-6 L=1e-6
mpway51_cell96 ML51 gate_way51_cell96 GND ML51 p1 W=2.4e-6 L=1e-6
mnway51_cell97 ML51 gate_way51_cell97 GND GND n1 W=1e-6 L=1e-6
mpway51_cell97 ML51 gate_way51_cell97 GND ML51 p1 W=2.4e-6 L=1e-6
mnway51_cell98 ML51 gate_way51_cell98 GND GND n1 W=1e-6 L=1e-6
mpway51_cell98 ML51 gate_way51_cell98 GND ML51 p1 W=2.4e-6 L=1e-6
mnway51_cell99 ML51 gate_way51_cell99 GND GND n1 W=1e-6 L=1e-6
mpway51_cell99 ML51 gate_way51_cell99 GND ML51 p1 W=2.4e-6 L=1e-6
mnway52_cell0 ML52 gate_way52_cell0 GND GND n1 W=1e-6 L=1e-6
mpway52_cell0 ML52 gate_way52_cell0 GND ML52 p1 W=2.4e-6 L=1e-6
mnway52_cell1 ML52 gate_way52_cell1 GND GND n1 W=1e-6 L=1e-6
mpway52_cell1 ML52 gate_way52_cell1 GND ML52 p1 W=2.4e-6 L=1e-6
mnway52_cell2 ML52 gate_way52_cell2 GND GND n1 W=1e-6 L=1e-6
mpway52_cell2 ML52 gate_way52_cell2 GND ML52 p1 W=2.4e-6 L=1e-6
mnway52_cell3 ML52 gate_way52_cell3 GND GND n1 W=1e-6 L=1e-6
mpway52_cell3 ML52 gate_way52_cell3 GND ML52 p1 W=2.4e-6 L=1e-6
mnway52_cell4 ML52 gate_way52_cell4 GND GND n1 W=1e-6 L=1e-6
mpway52_cell4 ML52 gate_way52_cell4 GND ML52 p1 W=2.4e-6 L=1e-6
mnway52_cell5 ML52 gate_way52_cell5 GND GND n1 W=1e-6 L=1e-6
mpway52_cell5 ML52 gate_way52_cell5 GND ML52 p1 W=2.4e-6 L=1e-6
mnway52_cell6 ML52 gate_way52_cell6 GND GND n1 W=1e-6 L=1e-6
mpway52_cell6 ML52 gate_way52_cell6 GND ML52 p1 W=2.4e-6 L=1e-6
mnway52_cell7 ML52 gate_way52_cell7 GND GND n1 W=1e-6 L=1e-6
mpway52_cell7 ML52 gate_way52_cell7 GND ML52 p1 W=2.4e-6 L=1e-6
mnway52_cell8 ML52 gate_way52_cell8 GND GND n1 W=1e-6 L=1e-6
mpway52_cell8 ML52 gate_way52_cell8 GND ML52 p1 W=2.4e-6 L=1e-6
mnway52_cell9 ML52 gate_way52_cell9 GND GND n1 W=1e-6 L=1e-6
mpway52_cell9 ML52 gate_way52_cell9 GND ML52 p1 W=2.4e-6 L=1e-6
mnway52_cell10 ML52 gate_way52_cell10 GND GND n1 W=1e-6 L=1e-6
mpway52_cell10 ML52 gate_way52_cell10 GND ML52 p1 W=2.4e-6 L=1e-6
mnway52_cell11 ML52 gate_way52_cell11 GND GND n1 W=1e-6 L=1e-6
mpway52_cell11 ML52 gate_way52_cell11 GND ML52 p1 W=2.4e-6 L=1e-6
mnway52_cell12 ML52 gate_way52_cell12 GND GND n1 W=1e-6 L=1e-6
mpway52_cell12 ML52 gate_way52_cell12 GND ML52 p1 W=2.4e-6 L=1e-6
mnway52_cell13 ML52 gate_way52_cell13 GND GND n1 W=1e-6 L=1e-6
mpway52_cell13 ML52 gate_way52_cell13 GND ML52 p1 W=2.4e-6 L=1e-6
mnway52_cell14 ML52 gate_way52_cell14 GND GND n1 W=1e-6 L=1e-6
mpway52_cell14 ML52 gate_way52_cell14 GND ML52 p1 W=2.4e-6 L=1e-6
mnway52_cell15 ML52 gate_way52_cell15 GND GND n1 W=1e-6 L=1e-6
mpway52_cell15 ML52 gate_way52_cell15 GND ML52 p1 W=2.4e-6 L=1e-6
mnway52_cell16 ML52 gate_way52_cell16 GND GND n1 W=1e-6 L=1e-6
mpway52_cell16 ML52 gate_way52_cell16 GND ML52 p1 W=2.4e-6 L=1e-6
mnway52_cell17 ML52 gate_way52_cell17 GND GND n1 W=1e-6 L=1e-6
mpway52_cell17 ML52 gate_way52_cell17 GND ML52 p1 W=2.4e-6 L=1e-6
mnway52_cell18 ML52 gate_way52_cell18 GND GND n1 W=1e-6 L=1e-6
mpway52_cell18 ML52 gate_way52_cell18 GND ML52 p1 W=2.4e-6 L=1e-6
mnway52_cell19 ML52 gate_way52_cell19 GND GND n1 W=1e-6 L=1e-6
mpway52_cell19 ML52 gate_way52_cell19 GND ML52 p1 W=2.4e-6 L=1e-6
mnway52_cell20 ML52 gate_way52_cell20 GND GND n1 W=1e-6 L=1e-6
mpway52_cell20 ML52 gate_way52_cell20 GND ML52 p1 W=2.4e-6 L=1e-6
mnway52_cell21 ML52 gate_way52_cell21 GND GND n1 W=1e-6 L=1e-6
mpway52_cell21 ML52 gate_way52_cell21 GND ML52 p1 W=2.4e-6 L=1e-6
mnway52_cell22 ML52 gate_way52_cell22 GND GND n1 W=1e-6 L=1e-6
mpway52_cell22 ML52 gate_way52_cell22 GND ML52 p1 W=2.4e-6 L=1e-6
mnway52_cell23 ML52 gate_way52_cell23 GND GND n1 W=1e-6 L=1e-6
mpway52_cell23 ML52 gate_way52_cell23 GND ML52 p1 W=2.4e-6 L=1e-6
mnway52_cell24 ML52 gate_way52_cell24 GND GND n1 W=1e-6 L=1e-6
mpway52_cell24 ML52 gate_way52_cell24 GND ML52 p1 W=2.4e-6 L=1e-6
mnway52_cell25 ML52 gate_way52_cell25 GND GND n1 W=1e-6 L=1e-6
mpway52_cell25 ML52 gate_way52_cell25 GND ML52 p1 W=2.4e-6 L=1e-6
mnway52_cell26 ML52 gate_way52_cell26 GND GND n1 W=1e-6 L=1e-6
mpway52_cell26 ML52 gate_way52_cell26 GND ML52 p1 W=2.4e-6 L=1e-6
mnway52_cell27 ML52 gate_way52_cell27 GND GND n1 W=1e-6 L=1e-6
mpway52_cell27 ML52 gate_way52_cell27 GND ML52 p1 W=2.4e-6 L=1e-6
mnway52_cell28 ML52 gate_way52_cell28 GND GND n1 W=1e-6 L=1e-6
mpway52_cell28 ML52 gate_way52_cell28 GND ML52 p1 W=2.4e-6 L=1e-6
mnway52_cell29 ML52 gate_way52_cell29 GND GND n1 W=1e-6 L=1e-6
mpway52_cell29 ML52 gate_way52_cell29 GND ML52 p1 W=2.4e-6 L=1e-6
mnway52_cell30 ML52 gate_way52_cell30 GND GND n1 W=1e-6 L=1e-6
mpway52_cell30 ML52 gate_way52_cell30 GND ML52 p1 W=2.4e-6 L=1e-6
mnway52_cell31 ML52 gate_way52_cell31 GND GND n1 W=1e-6 L=1e-6
mpway52_cell31 ML52 gate_way52_cell31 GND ML52 p1 W=2.4e-6 L=1e-6
mnway52_cell32 ML52 gate_way52_cell32 GND GND n1 W=1e-6 L=1e-6
mpway52_cell32 ML52 gate_way52_cell32 GND ML52 p1 W=2.4e-6 L=1e-6
mnway52_cell33 ML52 gate_way52_cell33 GND GND n1 W=1e-6 L=1e-6
mpway52_cell33 ML52 gate_way52_cell33 GND ML52 p1 W=2.4e-6 L=1e-6
mnway52_cell34 ML52 gate_way52_cell34 GND GND n1 W=1e-6 L=1e-6
mpway52_cell34 ML52 gate_way52_cell34 GND ML52 p1 W=2.4e-6 L=1e-6
mnway52_cell35 ML52 gate_way52_cell35 GND GND n1 W=1e-6 L=1e-6
mpway52_cell35 ML52 gate_way52_cell35 GND ML52 p1 W=2.4e-6 L=1e-6
mnway52_cell36 ML52 gate_way52_cell36 GND GND n1 W=1e-6 L=1e-6
mpway52_cell36 ML52 gate_way52_cell36 GND ML52 p1 W=2.4e-6 L=1e-6
mnway52_cell37 ML52 gate_way52_cell37 GND GND n1 W=1e-6 L=1e-6
mpway52_cell37 ML52 gate_way52_cell37 GND ML52 p1 W=2.4e-6 L=1e-6
mnway52_cell38 ML52 gate_way52_cell38 GND GND n1 W=1e-6 L=1e-6
mpway52_cell38 ML52 gate_way52_cell38 GND ML52 p1 W=2.4e-6 L=1e-6
mnway52_cell39 ML52 gate_way52_cell39 GND GND n1 W=1e-6 L=1e-6
mpway52_cell39 ML52 gate_way52_cell39 GND ML52 p1 W=2.4e-6 L=1e-6
mnway52_cell40 ML52 gate_way52_cell40 GND GND n1 W=1e-6 L=1e-6
mpway52_cell40 ML52 gate_way52_cell40 GND ML52 p1 W=2.4e-6 L=1e-6
mnway52_cell41 ML52 gate_way52_cell41 GND GND n1 W=1e-6 L=1e-6
mpway52_cell41 ML52 gate_way52_cell41 GND ML52 p1 W=2.4e-6 L=1e-6
mnway52_cell42 ML52 gate_way52_cell42 GND GND n1 W=1e-6 L=1e-6
mpway52_cell42 ML52 gate_way52_cell42 GND ML52 p1 W=2.4e-6 L=1e-6
mnway52_cell43 ML52 gate_way52_cell43 GND GND n1 W=1e-6 L=1e-6
mpway52_cell43 ML52 gate_way52_cell43 GND ML52 p1 W=2.4e-6 L=1e-6
mnway52_cell44 ML52 gate_way52_cell44 GND GND n1 W=1e-6 L=1e-6
mpway52_cell44 ML52 gate_way52_cell44 GND ML52 p1 W=2.4e-6 L=1e-6
mnway52_cell45 ML52 gate_way52_cell45 GND GND n1 W=1e-6 L=1e-6
mpway52_cell45 ML52 gate_way52_cell45 GND ML52 p1 W=2.4e-6 L=1e-6
mnway52_cell46 ML52 gate_way52_cell46 GND GND n1 W=1e-6 L=1e-6
mpway52_cell46 ML52 gate_way52_cell46 GND ML52 p1 W=2.4e-6 L=1e-6
mnway52_cell47 ML52 gate_way52_cell47 GND GND n1 W=1e-6 L=1e-6
mpway52_cell47 ML52 gate_way52_cell47 GND ML52 p1 W=2.4e-6 L=1e-6
mnway52_cell48 ML52 gate_way52_cell48 GND GND n1 W=1e-6 L=1e-6
mpway52_cell48 ML52 gate_way52_cell48 GND ML52 p1 W=2.4e-6 L=1e-6
mnway52_cell49 ML52 gate_way52_cell49 GND GND n1 W=1e-6 L=1e-6
mpway52_cell49 ML52 gate_way52_cell49 GND ML52 p1 W=2.4e-6 L=1e-6
mnway52_cell50 ML52 gate_way52_cell50 GND GND n1 W=1e-6 L=1e-6
mpway52_cell50 ML52 gate_way52_cell50 GND ML52 p1 W=2.4e-6 L=1e-6
mnway52_cell51 ML52 gate_way52_cell51 GND GND n1 W=1e-6 L=1e-6
mpway52_cell51 ML52 gate_way52_cell51 GND ML52 p1 W=2.4e-6 L=1e-6
mnway52_cell52 ML52 gate_way52_cell52 GND GND n1 W=1e-6 L=1e-6
mpway52_cell52 ML52 gate_way52_cell52 GND ML52 p1 W=2.4e-6 L=1e-6
mnway52_cell53 ML52 gate_way52_cell53 GND GND n1 W=1e-6 L=1e-6
mpway52_cell53 ML52 gate_way52_cell53 GND ML52 p1 W=2.4e-6 L=1e-6
mnway52_cell54 ML52 gate_way52_cell54 GND GND n1 W=1e-6 L=1e-6
mpway52_cell54 ML52 gate_way52_cell54 GND ML52 p1 W=2.4e-6 L=1e-6
mnway52_cell55 ML52 gate_way52_cell55 GND GND n1 W=1e-6 L=1e-6
mpway52_cell55 ML52 gate_way52_cell55 GND ML52 p1 W=2.4e-6 L=1e-6
mnway52_cell56 ML52 gate_way52_cell56 GND GND n1 W=1e-6 L=1e-6
mpway52_cell56 ML52 gate_way52_cell56 GND ML52 p1 W=2.4e-6 L=1e-6
mnway52_cell57 ML52 gate_way52_cell57 GND GND n1 W=1e-6 L=1e-6
mpway52_cell57 ML52 gate_way52_cell57 GND ML52 p1 W=2.4e-6 L=1e-6
mnway52_cell58 ML52 gate_way52_cell58 GND GND n1 W=1e-6 L=1e-6
mpway52_cell58 ML52 gate_way52_cell58 GND ML52 p1 W=2.4e-6 L=1e-6
mnway52_cell59 ML52 gate_way52_cell59 GND GND n1 W=1e-6 L=1e-6
mpway52_cell59 ML52 gate_way52_cell59 GND ML52 p1 W=2.4e-6 L=1e-6
mnway52_cell60 ML52 gate_way52_cell60 GND GND n1 W=1e-6 L=1e-6
mpway52_cell60 ML52 gate_way52_cell60 GND ML52 p1 W=2.4e-6 L=1e-6
mnway52_cell61 ML52 gate_way52_cell61 GND GND n1 W=1e-6 L=1e-6
mpway52_cell61 ML52 gate_way52_cell61 GND ML52 p1 W=2.4e-6 L=1e-6
mnway52_cell62 ML52 gate_way52_cell62 GND GND n1 W=1e-6 L=1e-6
mpway52_cell62 ML52 gate_way52_cell62 GND ML52 p1 W=2.4e-6 L=1e-6
mnway52_cell63 ML52 gate_way52_cell63 GND GND n1 W=1e-6 L=1e-6
mpway52_cell63 ML52 gate_way52_cell63 GND ML52 p1 W=2.4e-6 L=1e-6
mnway52_cell64 ML52 gate_way52_cell64 GND GND n1 W=1e-6 L=1e-6
mpway52_cell64 ML52 gate_way52_cell64 GND ML52 p1 W=2.4e-6 L=1e-6
mnway52_cell65 ML52 gate_way52_cell65 GND GND n1 W=1e-6 L=1e-6
mpway52_cell65 ML52 gate_way52_cell65 GND ML52 p1 W=2.4e-6 L=1e-6
mnway52_cell66 ML52 gate_way52_cell66 GND GND n1 W=1e-6 L=1e-6
mpway52_cell66 ML52 gate_way52_cell66 GND ML52 p1 W=2.4e-6 L=1e-6
mnway52_cell67 ML52 gate_way52_cell67 GND GND n1 W=1e-6 L=1e-6
mpway52_cell67 ML52 gate_way52_cell67 GND ML52 p1 W=2.4e-6 L=1e-6
mnway52_cell68 ML52 gate_way52_cell68 GND GND n1 W=1e-6 L=1e-6
mpway52_cell68 ML52 gate_way52_cell68 GND ML52 p1 W=2.4e-6 L=1e-6
mnway52_cell69 ML52 gate_way52_cell69 GND GND n1 W=1e-6 L=1e-6
mpway52_cell69 ML52 gate_way52_cell69 GND ML52 p1 W=2.4e-6 L=1e-6
mnway52_cell70 ML52 gate_way52_cell70 GND GND n1 W=1e-6 L=1e-6
mpway52_cell70 ML52 gate_way52_cell70 GND ML52 p1 W=2.4e-6 L=1e-6
mnway52_cell71 ML52 gate_way52_cell71 GND GND n1 W=1e-6 L=1e-6
mpway52_cell71 ML52 gate_way52_cell71 GND ML52 p1 W=2.4e-6 L=1e-6
mnway52_cell72 ML52 gate_way52_cell72 GND GND n1 W=1e-6 L=1e-6
mpway52_cell72 ML52 gate_way52_cell72 GND ML52 p1 W=2.4e-6 L=1e-6
mnway52_cell73 ML52 gate_way52_cell73 GND GND n1 W=1e-6 L=1e-6
mpway52_cell73 ML52 gate_way52_cell73 GND ML52 p1 W=2.4e-6 L=1e-6
mnway52_cell74 ML52 gate_way52_cell74 GND GND n1 W=1e-6 L=1e-6
mpway52_cell74 ML52 gate_way52_cell74 GND ML52 p1 W=2.4e-6 L=1e-6
mnway52_cell75 ML52 gate_way52_cell75 GND GND n1 W=1e-6 L=1e-6
mpway52_cell75 ML52 gate_way52_cell75 GND ML52 p1 W=2.4e-6 L=1e-6
mnway52_cell76 ML52 gate_way52_cell76 GND GND n1 W=1e-6 L=1e-6
mpway52_cell76 ML52 gate_way52_cell76 GND ML52 p1 W=2.4e-6 L=1e-6
mnway52_cell77 ML52 gate_way52_cell77 GND GND n1 W=1e-6 L=1e-6
mpway52_cell77 ML52 gate_way52_cell77 GND ML52 p1 W=2.4e-6 L=1e-6
mnway52_cell78 ML52 gate_way52_cell78 GND GND n1 W=1e-6 L=1e-6
mpway52_cell78 ML52 gate_way52_cell78 GND ML52 p1 W=2.4e-6 L=1e-6
mnway52_cell79 ML52 gate_way52_cell79 GND GND n1 W=1e-6 L=1e-6
mpway52_cell79 ML52 gate_way52_cell79 GND ML52 p1 W=2.4e-6 L=1e-6
mnway52_cell80 ML52 gate_way52_cell80 GND GND n1 W=1e-6 L=1e-6
mpway52_cell80 ML52 gate_way52_cell80 GND ML52 p1 W=2.4e-6 L=1e-6
mnway52_cell81 ML52 gate_way52_cell81 GND GND n1 W=1e-6 L=1e-6
mpway52_cell81 ML52 gate_way52_cell81 GND ML52 p1 W=2.4e-6 L=1e-6
mnway52_cell82 ML52 gate_way52_cell82 GND GND n1 W=1e-6 L=1e-6
mpway52_cell82 ML52 gate_way52_cell82 GND ML52 p1 W=2.4e-6 L=1e-6
mnway52_cell83 ML52 gate_way52_cell83 GND GND n1 W=1e-6 L=1e-6
mpway52_cell83 ML52 gate_way52_cell83 GND ML52 p1 W=2.4e-6 L=1e-6
mnway52_cell84 ML52 gate_way52_cell84 GND GND n1 W=1e-6 L=1e-6
mpway52_cell84 ML52 gate_way52_cell84 GND ML52 p1 W=2.4e-6 L=1e-6
mnway52_cell85 ML52 gate_way52_cell85 GND GND n1 W=1e-6 L=1e-6
mpway52_cell85 ML52 gate_way52_cell85 GND ML52 p1 W=2.4e-6 L=1e-6
mnway52_cell86 ML52 gate_way52_cell86 GND GND n1 W=1e-6 L=1e-6
mpway52_cell86 ML52 gate_way52_cell86 GND ML52 p1 W=2.4e-6 L=1e-6
mnway52_cell87 ML52 gate_way52_cell87 GND GND n1 W=1e-6 L=1e-6
mpway52_cell87 ML52 gate_way52_cell87 GND ML52 p1 W=2.4e-6 L=1e-6
mnway52_cell88 ML52 gate_way52_cell88 GND GND n1 W=1e-6 L=1e-6
mpway52_cell88 ML52 gate_way52_cell88 GND ML52 p1 W=2.4e-6 L=1e-6
mnway52_cell89 ML52 gate_way52_cell89 GND GND n1 W=1e-6 L=1e-6
mpway52_cell89 ML52 gate_way52_cell89 GND ML52 p1 W=2.4e-6 L=1e-6
mnway52_cell90 ML52 gate_way52_cell90 GND GND n1 W=1e-6 L=1e-6
mpway52_cell90 ML52 gate_way52_cell90 GND ML52 p1 W=2.4e-6 L=1e-6
mnway52_cell91 ML52 gate_way52_cell91 GND GND n1 W=1e-6 L=1e-6
mpway52_cell91 ML52 gate_way52_cell91 GND ML52 p1 W=2.4e-6 L=1e-6
mnway52_cell92 ML52 gate_way52_cell92 GND GND n1 W=1e-6 L=1e-6
mpway52_cell92 ML52 gate_way52_cell92 GND ML52 p1 W=2.4e-6 L=1e-6
mnway52_cell93 ML52 gate_way52_cell93 GND GND n1 W=1e-6 L=1e-6
mpway52_cell93 ML52 gate_way52_cell93 GND ML52 p1 W=2.4e-6 L=1e-6
mnway52_cell94 ML52 gate_way52_cell94 GND GND n1 W=1e-6 L=1e-6
mpway52_cell94 ML52 gate_way52_cell94 GND ML52 p1 W=2.4e-6 L=1e-6
mnway52_cell95 ML52 gate_way52_cell95 GND GND n1 W=1e-6 L=1e-6
mpway52_cell95 ML52 gate_way52_cell95 GND ML52 p1 W=2.4e-6 L=1e-6
mnway52_cell96 ML52 gate_way52_cell96 GND GND n1 W=1e-6 L=1e-6
mpway52_cell96 ML52 gate_way52_cell96 GND ML52 p1 W=2.4e-6 L=1e-6
mnway52_cell97 ML52 gate_way52_cell97 GND GND n1 W=1e-6 L=1e-6
mpway52_cell97 ML52 gate_way52_cell97 GND ML52 p1 W=2.4e-6 L=1e-6
mnway52_cell98 ML52 gate_way52_cell98 GND GND n1 W=1e-6 L=1e-6
mpway52_cell98 ML52 gate_way52_cell98 GND ML52 p1 W=2.4e-6 L=1e-6
mnway52_cell99 ML52 gate_way52_cell99 GND GND n1 W=1e-6 L=1e-6
mpway52_cell99 ML52 gate_way52_cell99 GND ML52 p1 W=2.4e-6 L=1e-6
mnway53_cell0 ML53 gate_way53_cell0 GND GND n1 W=1e-6 L=1e-6
mpway53_cell0 ML53 gate_way53_cell0 GND ML53 p1 W=2.4e-6 L=1e-6
mnway53_cell1 ML53 gate_way53_cell1 GND GND n1 W=1e-6 L=1e-6
mpway53_cell1 ML53 gate_way53_cell1 GND ML53 p1 W=2.4e-6 L=1e-6
mnway53_cell2 ML53 gate_way53_cell2 GND GND n1 W=1e-6 L=1e-6
mpway53_cell2 ML53 gate_way53_cell2 GND ML53 p1 W=2.4e-6 L=1e-6
mnway53_cell3 ML53 gate_way53_cell3 GND GND n1 W=1e-6 L=1e-6
mpway53_cell3 ML53 gate_way53_cell3 GND ML53 p1 W=2.4e-6 L=1e-6
mnway53_cell4 ML53 gate_way53_cell4 GND GND n1 W=1e-6 L=1e-6
mpway53_cell4 ML53 gate_way53_cell4 GND ML53 p1 W=2.4e-6 L=1e-6
mnway53_cell5 ML53 gate_way53_cell5 GND GND n1 W=1e-6 L=1e-6
mpway53_cell5 ML53 gate_way53_cell5 GND ML53 p1 W=2.4e-6 L=1e-6
mnway53_cell6 ML53 gate_way53_cell6 GND GND n1 W=1e-6 L=1e-6
mpway53_cell6 ML53 gate_way53_cell6 GND ML53 p1 W=2.4e-6 L=1e-6
mnway53_cell7 ML53 gate_way53_cell7 GND GND n1 W=1e-6 L=1e-6
mpway53_cell7 ML53 gate_way53_cell7 GND ML53 p1 W=2.4e-6 L=1e-6
mnway53_cell8 ML53 gate_way53_cell8 GND GND n1 W=1e-6 L=1e-6
mpway53_cell8 ML53 gate_way53_cell8 GND ML53 p1 W=2.4e-6 L=1e-6
mnway53_cell9 ML53 gate_way53_cell9 GND GND n1 W=1e-6 L=1e-6
mpway53_cell9 ML53 gate_way53_cell9 GND ML53 p1 W=2.4e-6 L=1e-6
mnway53_cell10 ML53 gate_way53_cell10 GND GND n1 W=1e-6 L=1e-6
mpway53_cell10 ML53 gate_way53_cell10 GND ML53 p1 W=2.4e-6 L=1e-6
mnway53_cell11 ML53 gate_way53_cell11 GND GND n1 W=1e-6 L=1e-6
mpway53_cell11 ML53 gate_way53_cell11 GND ML53 p1 W=2.4e-6 L=1e-6
mnway53_cell12 ML53 gate_way53_cell12 GND GND n1 W=1e-6 L=1e-6
mpway53_cell12 ML53 gate_way53_cell12 GND ML53 p1 W=2.4e-6 L=1e-6
mnway53_cell13 ML53 gate_way53_cell13 GND GND n1 W=1e-6 L=1e-6
mpway53_cell13 ML53 gate_way53_cell13 GND ML53 p1 W=2.4e-6 L=1e-6
mnway53_cell14 ML53 gate_way53_cell14 GND GND n1 W=1e-6 L=1e-6
mpway53_cell14 ML53 gate_way53_cell14 GND ML53 p1 W=2.4e-6 L=1e-6
mnway53_cell15 ML53 gate_way53_cell15 GND GND n1 W=1e-6 L=1e-6
mpway53_cell15 ML53 gate_way53_cell15 GND ML53 p1 W=2.4e-6 L=1e-6
mnway53_cell16 ML53 gate_way53_cell16 GND GND n1 W=1e-6 L=1e-6
mpway53_cell16 ML53 gate_way53_cell16 GND ML53 p1 W=2.4e-6 L=1e-6
mnway53_cell17 ML53 gate_way53_cell17 GND GND n1 W=1e-6 L=1e-6
mpway53_cell17 ML53 gate_way53_cell17 GND ML53 p1 W=2.4e-6 L=1e-6
mnway53_cell18 ML53 gate_way53_cell18 GND GND n1 W=1e-6 L=1e-6
mpway53_cell18 ML53 gate_way53_cell18 GND ML53 p1 W=2.4e-6 L=1e-6
mnway53_cell19 ML53 gate_way53_cell19 GND GND n1 W=1e-6 L=1e-6
mpway53_cell19 ML53 gate_way53_cell19 GND ML53 p1 W=2.4e-6 L=1e-6
mnway53_cell20 ML53 gate_way53_cell20 GND GND n1 W=1e-6 L=1e-6
mpway53_cell20 ML53 gate_way53_cell20 GND ML53 p1 W=2.4e-6 L=1e-6
mnway53_cell21 ML53 gate_way53_cell21 GND GND n1 W=1e-6 L=1e-6
mpway53_cell21 ML53 gate_way53_cell21 GND ML53 p1 W=2.4e-6 L=1e-6
mnway53_cell22 ML53 gate_way53_cell22 GND GND n1 W=1e-6 L=1e-6
mpway53_cell22 ML53 gate_way53_cell22 GND ML53 p1 W=2.4e-6 L=1e-6
mnway53_cell23 ML53 gate_way53_cell23 GND GND n1 W=1e-6 L=1e-6
mpway53_cell23 ML53 gate_way53_cell23 GND ML53 p1 W=2.4e-6 L=1e-6
mnway53_cell24 ML53 gate_way53_cell24 GND GND n1 W=1e-6 L=1e-6
mpway53_cell24 ML53 gate_way53_cell24 GND ML53 p1 W=2.4e-6 L=1e-6
mnway53_cell25 ML53 gate_way53_cell25 GND GND n1 W=1e-6 L=1e-6
mpway53_cell25 ML53 gate_way53_cell25 GND ML53 p1 W=2.4e-6 L=1e-6
mnway53_cell26 ML53 gate_way53_cell26 GND GND n1 W=1e-6 L=1e-6
mpway53_cell26 ML53 gate_way53_cell26 GND ML53 p1 W=2.4e-6 L=1e-6
mnway53_cell27 ML53 gate_way53_cell27 GND GND n1 W=1e-6 L=1e-6
mpway53_cell27 ML53 gate_way53_cell27 GND ML53 p1 W=2.4e-6 L=1e-6
mnway53_cell28 ML53 gate_way53_cell28 GND GND n1 W=1e-6 L=1e-6
mpway53_cell28 ML53 gate_way53_cell28 GND ML53 p1 W=2.4e-6 L=1e-6
mnway53_cell29 ML53 gate_way53_cell29 GND GND n1 W=1e-6 L=1e-6
mpway53_cell29 ML53 gate_way53_cell29 GND ML53 p1 W=2.4e-6 L=1e-6
mnway53_cell30 ML53 gate_way53_cell30 GND GND n1 W=1e-6 L=1e-6
mpway53_cell30 ML53 gate_way53_cell30 GND ML53 p1 W=2.4e-6 L=1e-6
mnway53_cell31 ML53 gate_way53_cell31 GND GND n1 W=1e-6 L=1e-6
mpway53_cell31 ML53 gate_way53_cell31 GND ML53 p1 W=2.4e-6 L=1e-6
mnway53_cell32 ML53 gate_way53_cell32 GND GND n1 W=1e-6 L=1e-6
mpway53_cell32 ML53 gate_way53_cell32 GND ML53 p1 W=2.4e-6 L=1e-6
mnway53_cell33 ML53 gate_way53_cell33 GND GND n1 W=1e-6 L=1e-6
mpway53_cell33 ML53 gate_way53_cell33 GND ML53 p1 W=2.4e-6 L=1e-6
mnway53_cell34 ML53 gate_way53_cell34 GND GND n1 W=1e-6 L=1e-6
mpway53_cell34 ML53 gate_way53_cell34 GND ML53 p1 W=2.4e-6 L=1e-6
mnway53_cell35 ML53 gate_way53_cell35 GND GND n1 W=1e-6 L=1e-6
mpway53_cell35 ML53 gate_way53_cell35 GND ML53 p1 W=2.4e-6 L=1e-6
mnway53_cell36 ML53 gate_way53_cell36 GND GND n1 W=1e-6 L=1e-6
mpway53_cell36 ML53 gate_way53_cell36 GND ML53 p1 W=2.4e-6 L=1e-6
mnway53_cell37 ML53 gate_way53_cell37 GND GND n1 W=1e-6 L=1e-6
mpway53_cell37 ML53 gate_way53_cell37 GND ML53 p1 W=2.4e-6 L=1e-6
mnway53_cell38 ML53 gate_way53_cell38 GND GND n1 W=1e-6 L=1e-6
mpway53_cell38 ML53 gate_way53_cell38 GND ML53 p1 W=2.4e-6 L=1e-6
mnway53_cell39 ML53 gate_way53_cell39 GND GND n1 W=1e-6 L=1e-6
mpway53_cell39 ML53 gate_way53_cell39 GND ML53 p1 W=2.4e-6 L=1e-6
mnway53_cell40 ML53 gate_way53_cell40 GND GND n1 W=1e-6 L=1e-6
mpway53_cell40 ML53 gate_way53_cell40 GND ML53 p1 W=2.4e-6 L=1e-6
mnway53_cell41 ML53 gate_way53_cell41 GND GND n1 W=1e-6 L=1e-6
mpway53_cell41 ML53 gate_way53_cell41 GND ML53 p1 W=2.4e-6 L=1e-6
mnway53_cell42 ML53 gate_way53_cell42 GND GND n1 W=1e-6 L=1e-6
mpway53_cell42 ML53 gate_way53_cell42 GND ML53 p1 W=2.4e-6 L=1e-6
mnway53_cell43 ML53 gate_way53_cell43 GND GND n1 W=1e-6 L=1e-6
mpway53_cell43 ML53 gate_way53_cell43 GND ML53 p1 W=2.4e-6 L=1e-6
mnway53_cell44 ML53 gate_way53_cell44 GND GND n1 W=1e-6 L=1e-6
mpway53_cell44 ML53 gate_way53_cell44 GND ML53 p1 W=2.4e-6 L=1e-6
mnway53_cell45 ML53 gate_way53_cell45 GND GND n1 W=1e-6 L=1e-6
mpway53_cell45 ML53 gate_way53_cell45 GND ML53 p1 W=2.4e-6 L=1e-6
mnway53_cell46 ML53 gate_way53_cell46 GND GND n1 W=1e-6 L=1e-6
mpway53_cell46 ML53 gate_way53_cell46 GND ML53 p1 W=2.4e-6 L=1e-6
mnway53_cell47 ML53 gate_way53_cell47 GND GND n1 W=1e-6 L=1e-6
mpway53_cell47 ML53 gate_way53_cell47 GND ML53 p1 W=2.4e-6 L=1e-6
mnway53_cell48 ML53 gate_way53_cell48 GND GND n1 W=1e-6 L=1e-6
mpway53_cell48 ML53 gate_way53_cell48 GND ML53 p1 W=2.4e-6 L=1e-6
mnway53_cell49 ML53 gate_way53_cell49 GND GND n1 W=1e-6 L=1e-6
mpway53_cell49 ML53 gate_way53_cell49 GND ML53 p1 W=2.4e-6 L=1e-6
mnway53_cell50 ML53 gate_way53_cell50 GND GND n1 W=1e-6 L=1e-6
mpway53_cell50 ML53 gate_way53_cell50 GND ML53 p1 W=2.4e-6 L=1e-6
mnway53_cell51 ML53 gate_way53_cell51 GND GND n1 W=1e-6 L=1e-6
mpway53_cell51 ML53 gate_way53_cell51 GND ML53 p1 W=2.4e-6 L=1e-6
mnway53_cell52 ML53 gate_way53_cell52 GND GND n1 W=1e-6 L=1e-6
mpway53_cell52 ML53 gate_way53_cell52 GND ML53 p1 W=2.4e-6 L=1e-6
mnway53_cell53 ML53 gate_way53_cell53 GND GND n1 W=1e-6 L=1e-6
mpway53_cell53 ML53 gate_way53_cell53 GND ML53 p1 W=2.4e-6 L=1e-6
mnway53_cell54 ML53 gate_way53_cell54 GND GND n1 W=1e-6 L=1e-6
mpway53_cell54 ML53 gate_way53_cell54 GND ML53 p1 W=2.4e-6 L=1e-6
mnway53_cell55 ML53 gate_way53_cell55 GND GND n1 W=1e-6 L=1e-6
mpway53_cell55 ML53 gate_way53_cell55 GND ML53 p1 W=2.4e-6 L=1e-6
mnway53_cell56 ML53 gate_way53_cell56 GND GND n1 W=1e-6 L=1e-6
mpway53_cell56 ML53 gate_way53_cell56 GND ML53 p1 W=2.4e-6 L=1e-6
mnway53_cell57 ML53 gate_way53_cell57 GND GND n1 W=1e-6 L=1e-6
mpway53_cell57 ML53 gate_way53_cell57 GND ML53 p1 W=2.4e-6 L=1e-6
mnway53_cell58 ML53 gate_way53_cell58 GND GND n1 W=1e-6 L=1e-6
mpway53_cell58 ML53 gate_way53_cell58 GND ML53 p1 W=2.4e-6 L=1e-6
mnway53_cell59 ML53 gate_way53_cell59 GND GND n1 W=1e-6 L=1e-6
mpway53_cell59 ML53 gate_way53_cell59 GND ML53 p1 W=2.4e-6 L=1e-6
mnway53_cell60 ML53 gate_way53_cell60 GND GND n1 W=1e-6 L=1e-6
mpway53_cell60 ML53 gate_way53_cell60 GND ML53 p1 W=2.4e-6 L=1e-6
mnway53_cell61 ML53 gate_way53_cell61 GND GND n1 W=1e-6 L=1e-6
mpway53_cell61 ML53 gate_way53_cell61 GND ML53 p1 W=2.4e-6 L=1e-6
mnway53_cell62 ML53 gate_way53_cell62 GND GND n1 W=1e-6 L=1e-6
mpway53_cell62 ML53 gate_way53_cell62 GND ML53 p1 W=2.4e-6 L=1e-6
mnway53_cell63 ML53 gate_way53_cell63 GND GND n1 W=1e-6 L=1e-6
mpway53_cell63 ML53 gate_way53_cell63 GND ML53 p1 W=2.4e-6 L=1e-6
mnway53_cell64 ML53 gate_way53_cell64 GND GND n1 W=1e-6 L=1e-6
mpway53_cell64 ML53 gate_way53_cell64 GND ML53 p1 W=2.4e-6 L=1e-6
mnway53_cell65 ML53 gate_way53_cell65 GND GND n1 W=1e-6 L=1e-6
mpway53_cell65 ML53 gate_way53_cell65 GND ML53 p1 W=2.4e-6 L=1e-6
mnway53_cell66 ML53 gate_way53_cell66 GND GND n1 W=1e-6 L=1e-6
mpway53_cell66 ML53 gate_way53_cell66 GND ML53 p1 W=2.4e-6 L=1e-6
mnway53_cell67 ML53 gate_way53_cell67 GND GND n1 W=1e-6 L=1e-6
mpway53_cell67 ML53 gate_way53_cell67 GND ML53 p1 W=2.4e-6 L=1e-6
mnway53_cell68 ML53 gate_way53_cell68 GND GND n1 W=1e-6 L=1e-6
mpway53_cell68 ML53 gate_way53_cell68 GND ML53 p1 W=2.4e-6 L=1e-6
mnway53_cell69 ML53 gate_way53_cell69 GND GND n1 W=1e-6 L=1e-6
mpway53_cell69 ML53 gate_way53_cell69 GND ML53 p1 W=2.4e-6 L=1e-6
mnway53_cell70 ML53 gate_way53_cell70 GND GND n1 W=1e-6 L=1e-6
mpway53_cell70 ML53 gate_way53_cell70 GND ML53 p1 W=2.4e-6 L=1e-6
mnway53_cell71 ML53 gate_way53_cell71 GND GND n1 W=1e-6 L=1e-6
mpway53_cell71 ML53 gate_way53_cell71 GND ML53 p1 W=2.4e-6 L=1e-6
mnway53_cell72 ML53 gate_way53_cell72 GND GND n1 W=1e-6 L=1e-6
mpway53_cell72 ML53 gate_way53_cell72 GND ML53 p1 W=2.4e-6 L=1e-6
mnway53_cell73 ML53 gate_way53_cell73 GND GND n1 W=1e-6 L=1e-6
mpway53_cell73 ML53 gate_way53_cell73 GND ML53 p1 W=2.4e-6 L=1e-6
mnway53_cell74 ML53 gate_way53_cell74 GND GND n1 W=1e-6 L=1e-6
mpway53_cell74 ML53 gate_way53_cell74 GND ML53 p1 W=2.4e-6 L=1e-6
mnway53_cell75 ML53 gate_way53_cell75 GND GND n1 W=1e-6 L=1e-6
mpway53_cell75 ML53 gate_way53_cell75 GND ML53 p1 W=2.4e-6 L=1e-6
mnway53_cell76 ML53 gate_way53_cell76 GND GND n1 W=1e-6 L=1e-6
mpway53_cell76 ML53 gate_way53_cell76 GND ML53 p1 W=2.4e-6 L=1e-6
mnway53_cell77 ML53 gate_way53_cell77 GND GND n1 W=1e-6 L=1e-6
mpway53_cell77 ML53 gate_way53_cell77 GND ML53 p1 W=2.4e-6 L=1e-6
mnway53_cell78 ML53 gate_way53_cell78 GND GND n1 W=1e-6 L=1e-6
mpway53_cell78 ML53 gate_way53_cell78 GND ML53 p1 W=2.4e-6 L=1e-6
mnway53_cell79 ML53 gate_way53_cell79 GND GND n1 W=1e-6 L=1e-6
mpway53_cell79 ML53 gate_way53_cell79 GND ML53 p1 W=2.4e-6 L=1e-6
mnway53_cell80 ML53 gate_way53_cell80 GND GND n1 W=1e-6 L=1e-6
mpway53_cell80 ML53 gate_way53_cell80 GND ML53 p1 W=2.4e-6 L=1e-6
mnway53_cell81 ML53 gate_way53_cell81 GND GND n1 W=1e-6 L=1e-6
mpway53_cell81 ML53 gate_way53_cell81 GND ML53 p1 W=2.4e-6 L=1e-6
mnway53_cell82 ML53 gate_way53_cell82 GND GND n1 W=1e-6 L=1e-6
mpway53_cell82 ML53 gate_way53_cell82 GND ML53 p1 W=2.4e-6 L=1e-6
mnway53_cell83 ML53 gate_way53_cell83 GND GND n1 W=1e-6 L=1e-6
mpway53_cell83 ML53 gate_way53_cell83 GND ML53 p1 W=2.4e-6 L=1e-6
mnway53_cell84 ML53 gate_way53_cell84 GND GND n1 W=1e-6 L=1e-6
mpway53_cell84 ML53 gate_way53_cell84 GND ML53 p1 W=2.4e-6 L=1e-6
mnway53_cell85 ML53 gate_way53_cell85 GND GND n1 W=1e-6 L=1e-6
mpway53_cell85 ML53 gate_way53_cell85 GND ML53 p1 W=2.4e-6 L=1e-6
mnway53_cell86 ML53 gate_way53_cell86 GND GND n1 W=1e-6 L=1e-6
mpway53_cell86 ML53 gate_way53_cell86 GND ML53 p1 W=2.4e-6 L=1e-6
mnway53_cell87 ML53 gate_way53_cell87 GND GND n1 W=1e-6 L=1e-6
mpway53_cell87 ML53 gate_way53_cell87 GND ML53 p1 W=2.4e-6 L=1e-6
mnway53_cell88 ML53 gate_way53_cell88 GND GND n1 W=1e-6 L=1e-6
mpway53_cell88 ML53 gate_way53_cell88 GND ML53 p1 W=2.4e-6 L=1e-6
mnway53_cell89 ML53 gate_way53_cell89 GND GND n1 W=1e-6 L=1e-6
mpway53_cell89 ML53 gate_way53_cell89 GND ML53 p1 W=2.4e-6 L=1e-6
mnway53_cell90 ML53 gate_way53_cell90 GND GND n1 W=1e-6 L=1e-6
mpway53_cell90 ML53 gate_way53_cell90 GND ML53 p1 W=2.4e-6 L=1e-6
mnway53_cell91 ML53 gate_way53_cell91 GND GND n1 W=1e-6 L=1e-6
mpway53_cell91 ML53 gate_way53_cell91 GND ML53 p1 W=2.4e-6 L=1e-6
mnway53_cell92 ML53 gate_way53_cell92 GND GND n1 W=1e-6 L=1e-6
mpway53_cell92 ML53 gate_way53_cell92 GND ML53 p1 W=2.4e-6 L=1e-6
mnway53_cell93 ML53 gate_way53_cell93 GND GND n1 W=1e-6 L=1e-6
mpway53_cell93 ML53 gate_way53_cell93 GND ML53 p1 W=2.4e-6 L=1e-6
mnway53_cell94 ML53 gate_way53_cell94 GND GND n1 W=1e-6 L=1e-6
mpway53_cell94 ML53 gate_way53_cell94 GND ML53 p1 W=2.4e-6 L=1e-6
mnway53_cell95 ML53 gate_way53_cell95 GND GND n1 W=1e-6 L=1e-6
mpway53_cell95 ML53 gate_way53_cell95 GND ML53 p1 W=2.4e-6 L=1e-6
mnway53_cell96 ML53 gate_way53_cell96 GND GND n1 W=1e-6 L=1e-6
mpway53_cell96 ML53 gate_way53_cell96 GND ML53 p1 W=2.4e-6 L=1e-6
mnway53_cell97 ML53 gate_way53_cell97 GND GND n1 W=1e-6 L=1e-6
mpway53_cell97 ML53 gate_way53_cell97 GND ML53 p1 W=2.4e-6 L=1e-6
mnway53_cell98 ML53 gate_way53_cell98 GND GND n1 W=1e-6 L=1e-6
mpway53_cell98 ML53 gate_way53_cell98 GND ML53 p1 W=2.4e-6 L=1e-6
mnway53_cell99 ML53 gate_way53_cell99 GND GND n1 W=1e-6 L=1e-6
mpway53_cell99 ML53 gate_way53_cell99 GND ML53 p1 W=2.4e-6 L=1e-6
mnway54_cell0 ML54 gate_way54_cell0 GND GND n1 W=1e-6 L=1e-6
mpway54_cell0 ML54 gate_way54_cell0 GND ML54 p1 W=2.4e-6 L=1e-6
mnway54_cell1 ML54 gate_way54_cell1 GND GND n1 W=1e-6 L=1e-6
mpway54_cell1 ML54 gate_way54_cell1 GND ML54 p1 W=2.4e-6 L=1e-6
mnway54_cell2 ML54 gate_way54_cell2 GND GND n1 W=1e-6 L=1e-6
mpway54_cell2 ML54 gate_way54_cell2 GND ML54 p1 W=2.4e-6 L=1e-6
mnway54_cell3 ML54 gate_way54_cell3 GND GND n1 W=1e-6 L=1e-6
mpway54_cell3 ML54 gate_way54_cell3 GND ML54 p1 W=2.4e-6 L=1e-6
mnway54_cell4 ML54 gate_way54_cell4 GND GND n1 W=1e-6 L=1e-6
mpway54_cell4 ML54 gate_way54_cell4 GND ML54 p1 W=2.4e-6 L=1e-6
mnway54_cell5 ML54 gate_way54_cell5 GND GND n1 W=1e-6 L=1e-6
mpway54_cell5 ML54 gate_way54_cell5 GND ML54 p1 W=2.4e-6 L=1e-6
mnway54_cell6 ML54 gate_way54_cell6 GND GND n1 W=1e-6 L=1e-6
mpway54_cell6 ML54 gate_way54_cell6 GND ML54 p1 W=2.4e-6 L=1e-6
mnway54_cell7 ML54 gate_way54_cell7 GND GND n1 W=1e-6 L=1e-6
mpway54_cell7 ML54 gate_way54_cell7 GND ML54 p1 W=2.4e-6 L=1e-6
mnway54_cell8 ML54 gate_way54_cell8 GND GND n1 W=1e-6 L=1e-6
mpway54_cell8 ML54 gate_way54_cell8 GND ML54 p1 W=2.4e-6 L=1e-6
mnway54_cell9 ML54 gate_way54_cell9 GND GND n1 W=1e-6 L=1e-6
mpway54_cell9 ML54 gate_way54_cell9 GND ML54 p1 W=2.4e-6 L=1e-6
mnway54_cell10 ML54 gate_way54_cell10 GND GND n1 W=1e-6 L=1e-6
mpway54_cell10 ML54 gate_way54_cell10 GND ML54 p1 W=2.4e-6 L=1e-6
mnway54_cell11 ML54 gate_way54_cell11 GND GND n1 W=1e-6 L=1e-6
mpway54_cell11 ML54 gate_way54_cell11 GND ML54 p1 W=2.4e-6 L=1e-6
mnway54_cell12 ML54 gate_way54_cell12 GND GND n1 W=1e-6 L=1e-6
mpway54_cell12 ML54 gate_way54_cell12 GND ML54 p1 W=2.4e-6 L=1e-6
mnway54_cell13 ML54 gate_way54_cell13 GND GND n1 W=1e-6 L=1e-6
mpway54_cell13 ML54 gate_way54_cell13 GND ML54 p1 W=2.4e-6 L=1e-6
mnway54_cell14 ML54 gate_way54_cell14 GND GND n1 W=1e-6 L=1e-6
mpway54_cell14 ML54 gate_way54_cell14 GND ML54 p1 W=2.4e-6 L=1e-6
mnway54_cell15 ML54 gate_way54_cell15 GND GND n1 W=1e-6 L=1e-6
mpway54_cell15 ML54 gate_way54_cell15 GND ML54 p1 W=2.4e-6 L=1e-6
mnway54_cell16 ML54 gate_way54_cell16 GND GND n1 W=1e-6 L=1e-6
mpway54_cell16 ML54 gate_way54_cell16 GND ML54 p1 W=2.4e-6 L=1e-6
mnway54_cell17 ML54 gate_way54_cell17 GND GND n1 W=1e-6 L=1e-6
mpway54_cell17 ML54 gate_way54_cell17 GND ML54 p1 W=2.4e-6 L=1e-6
mnway54_cell18 ML54 gate_way54_cell18 GND GND n1 W=1e-6 L=1e-6
mpway54_cell18 ML54 gate_way54_cell18 GND ML54 p1 W=2.4e-6 L=1e-6
mnway54_cell19 ML54 gate_way54_cell19 GND GND n1 W=1e-6 L=1e-6
mpway54_cell19 ML54 gate_way54_cell19 GND ML54 p1 W=2.4e-6 L=1e-6
mnway54_cell20 ML54 gate_way54_cell20 GND GND n1 W=1e-6 L=1e-6
mpway54_cell20 ML54 gate_way54_cell20 GND ML54 p1 W=2.4e-6 L=1e-6
mnway54_cell21 ML54 gate_way54_cell21 GND GND n1 W=1e-6 L=1e-6
mpway54_cell21 ML54 gate_way54_cell21 GND ML54 p1 W=2.4e-6 L=1e-6
mnway54_cell22 ML54 gate_way54_cell22 GND GND n1 W=1e-6 L=1e-6
mpway54_cell22 ML54 gate_way54_cell22 GND ML54 p1 W=2.4e-6 L=1e-6
mnway54_cell23 ML54 gate_way54_cell23 GND GND n1 W=1e-6 L=1e-6
mpway54_cell23 ML54 gate_way54_cell23 GND ML54 p1 W=2.4e-6 L=1e-6
mnway54_cell24 ML54 gate_way54_cell24 GND GND n1 W=1e-6 L=1e-6
mpway54_cell24 ML54 gate_way54_cell24 GND ML54 p1 W=2.4e-6 L=1e-6
mnway54_cell25 ML54 gate_way54_cell25 GND GND n1 W=1e-6 L=1e-6
mpway54_cell25 ML54 gate_way54_cell25 GND ML54 p1 W=2.4e-6 L=1e-6
mnway54_cell26 ML54 gate_way54_cell26 GND GND n1 W=1e-6 L=1e-6
mpway54_cell26 ML54 gate_way54_cell26 GND ML54 p1 W=2.4e-6 L=1e-6
mnway54_cell27 ML54 gate_way54_cell27 GND GND n1 W=1e-6 L=1e-6
mpway54_cell27 ML54 gate_way54_cell27 GND ML54 p1 W=2.4e-6 L=1e-6
mnway54_cell28 ML54 gate_way54_cell28 GND GND n1 W=1e-6 L=1e-6
mpway54_cell28 ML54 gate_way54_cell28 GND ML54 p1 W=2.4e-6 L=1e-6
mnway54_cell29 ML54 gate_way54_cell29 GND GND n1 W=1e-6 L=1e-6
mpway54_cell29 ML54 gate_way54_cell29 GND ML54 p1 W=2.4e-6 L=1e-6
mnway54_cell30 ML54 gate_way54_cell30 GND GND n1 W=1e-6 L=1e-6
mpway54_cell30 ML54 gate_way54_cell30 GND ML54 p1 W=2.4e-6 L=1e-6
mnway54_cell31 ML54 gate_way54_cell31 GND GND n1 W=1e-6 L=1e-6
mpway54_cell31 ML54 gate_way54_cell31 GND ML54 p1 W=2.4e-6 L=1e-6
mnway54_cell32 ML54 gate_way54_cell32 GND GND n1 W=1e-6 L=1e-6
mpway54_cell32 ML54 gate_way54_cell32 GND ML54 p1 W=2.4e-6 L=1e-6
mnway54_cell33 ML54 gate_way54_cell33 GND GND n1 W=1e-6 L=1e-6
mpway54_cell33 ML54 gate_way54_cell33 GND ML54 p1 W=2.4e-6 L=1e-6
mnway54_cell34 ML54 gate_way54_cell34 GND GND n1 W=1e-6 L=1e-6
mpway54_cell34 ML54 gate_way54_cell34 GND ML54 p1 W=2.4e-6 L=1e-6
mnway54_cell35 ML54 gate_way54_cell35 GND GND n1 W=1e-6 L=1e-6
mpway54_cell35 ML54 gate_way54_cell35 GND ML54 p1 W=2.4e-6 L=1e-6
mnway54_cell36 ML54 gate_way54_cell36 GND GND n1 W=1e-6 L=1e-6
mpway54_cell36 ML54 gate_way54_cell36 GND ML54 p1 W=2.4e-6 L=1e-6
mnway54_cell37 ML54 gate_way54_cell37 GND GND n1 W=1e-6 L=1e-6
mpway54_cell37 ML54 gate_way54_cell37 GND ML54 p1 W=2.4e-6 L=1e-6
mnway54_cell38 ML54 gate_way54_cell38 GND GND n1 W=1e-6 L=1e-6
mpway54_cell38 ML54 gate_way54_cell38 GND ML54 p1 W=2.4e-6 L=1e-6
mnway54_cell39 ML54 gate_way54_cell39 GND GND n1 W=1e-6 L=1e-6
mpway54_cell39 ML54 gate_way54_cell39 GND ML54 p1 W=2.4e-6 L=1e-6
mnway54_cell40 ML54 gate_way54_cell40 GND GND n1 W=1e-6 L=1e-6
mpway54_cell40 ML54 gate_way54_cell40 GND ML54 p1 W=2.4e-6 L=1e-6
mnway54_cell41 ML54 gate_way54_cell41 GND GND n1 W=1e-6 L=1e-6
mpway54_cell41 ML54 gate_way54_cell41 GND ML54 p1 W=2.4e-6 L=1e-6
mnway54_cell42 ML54 gate_way54_cell42 GND GND n1 W=1e-6 L=1e-6
mpway54_cell42 ML54 gate_way54_cell42 GND ML54 p1 W=2.4e-6 L=1e-6
mnway54_cell43 ML54 gate_way54_cell43 GND GND n1 W=1e-6 L=1e-6
mpway54_cell43 ML54 gate_way54_cell43 GND ML54 p1 W=2.4e-6 L=1e-6
mnway54_cell44 ML54 gate_way54_cell44 GND GND n1 W=1e-6 L=1e-6
mpway54_cell44 ML54 gate_way54_cell44 GND ML54 p1 W=2.4e-6 L=1e-6
mnway54_cell45 ML54 gate_way54_cell45 GND GND n1 W=1e-6 L=1e-6
mpway54_cell45 ML54 gate_way54_cell45 GND ML54 p1 W=2.4e-6 L=1e-6
mnway54_cell46 ML54 gate_way54_cell46 GND GND n1 W=1e-6 L=1e-6
mpway54_cell46 ML54 gate_way54_cell46 GND ML54 p1 W=2.4e-6 L=1e-6
mnway54_cell47 ML54 gate_way54_cell47 GND GND n1 W=1e-6 L=1e-6
mpway54_cell47 ML54 gate_way54_cell47 GND ML54 p1 W=2.4e-6 L=1e-6
mnway54_cell48 ML54 gate_way54_cell48 GND GND n1 W=1e-6 L=1e-6
mpway54_cell48 ML54 gate_way54_cell48 GND ML54 p1 W=2.4e-6 L=1e-6
mnway54_cell49 ML54 gate_way54_cell49 GND GND n1 W=1e-6 L=1e-6
mpway54_cell49 ML54 gate_way54_cell49 GND ML54 p1 W=2.4e-6 L=1e-6
mnway54_cell50 ML54 gate_way54_cell50 GND GND n1 W=1e-6 L=1e-6
mpway54_cell50 ML54 gate_way54_cell50 GND ML54 p1 W=2.4e-6 L=1e-6
mnway54_cell51 ML54 gate_way54_cell51 GND GND n1 W=1e-6 L=1e-6
mpway54_cell51 ML54 gate_way54_cell51 GND ML54 p1 W=2.4e-6 L=1e-6
mnway54_cell52 ML54 gate_way54_cell52 GND GND n1 W=1e-6 L=1e-6
mpway54_cell52 ML54 gate_way54_cell52 GND ML54 p1 W=2.4e-6 L=1e-6
mnway54_cell53 ML54 gate_way54_cell53 GND GND n1 W=1e-6 L=1e-6
mpway54_cell53 ML54 gate_way54_cell53 GND ML54 p1 W=2.4e-6 L=1e-6
mnway54_cell54 ML54 gate_way54_cell54 GND GND n1 W=1e-6 L=1e-6
mpway54_cell54 ML54 gate_way54_cell54 GND ML54 p1 W=2.4e-6 L=1e-6
mnway54_cell55 ML54 gate_way54_cell55 GND GND n1 W=1e-6 L=1e-6
mpway54_cell55 ML54 gate_way54_cell55 GND ML54 p1 W=2.4e-6 L=1e-6
mnway54_cell56 ML54 gate_way54_cell56 GND GND n1 W=1e-6 L=1e-6
mpway54_cell56 ML54 gate_way54_cell56 GND ML54 p1 W=2.4e-6 L=1e-6
mnway54_cell57 ML54 gate_way54_cell57 GND GND n1 W=1e-6 L=1e-6
mpway54_cell57 ML54 gate_way54_cell57 GND ML54 p1 W=2.4e-6 L=1e-6
mnway54_cell58 ML54 gate_way54_cell58 GND GND n1 W=1e-6 L=1e-6
mpway54_cell58 ML54 gate_way54_cell58 GND ML54 p1 W=2.4e-6 L=1e-6
mnway54_cell59 ML54 gate_way54_cell59 GND GND n1 W=1e-6 L=1e-6
mpway54_cell59 ML54 gate_way54_cell59 GND ML54 p1 W=2.4e-6 L=1e-6
mnway54_cell60 ML54 gate_way54_cell60 GND GND n1 W=1e-6 L=1e-6
mpway54_cell60 ML54 gate_way54_cell60 GND ML54 p1 W=2.4e-6 L=1e-6
mnway54_cell61 ML54 gate_way54_cell61 GND GND n1 W=1e-6 L=1e-6
mpway54_cell61 ML54 gate_way54_cell61 GND ML54 p1 W=2.4e-6 L=1e-6
mnway54_cell62 ML54 gate_way54_cell62 GND GND n1 W=1e-6 L=1e-6
mpway54_cell62 ML54 gate_way54_cell62 GND ML54 p1 W=2.4e-6 L=1e-6
mnway54_cell63 ML54 gate_way54_cell63 GND GND n1 W=1e-6 L=1e-6
mpway54_cell63 ML54 gate_way54_cell63 GND ML54 p1 W=2.4e-6 L=1e-6
mnway54_cell64 ML54 gate_way54_cell64 GND GND n1 W=1e-6 L=1e-6
mpway54_cell64 ML54 gate_way54_cell64 GND ML54 p1 W=2.4e-6 L=1e-6
mnway54_cell65 ML54 gate_way54_cell65 GND GND n1 W=1e-6 L=1e-6
mpway54_cell65 ML54 gate_way54_cell65 GND ML54 p1 W=2.4e-6 L=1e-6
mnway54_cell66 ML54 gate_way54_cell66 GND GND n1 W=1e-6 L=1e-6
mpway54_cell66 ML54 gate_way54_cell66 GND ML54 p1 W=2.4e-6 L=1e-6
mnway54_cell67 ML54 gate_way54_cell67 GND GND n1 W=1e-6 L=1e-6
mpway54_cell67 ML54 gate_way54_cell67 GND ML54 p1 W=2.4e-6 L=1e-6
mnway54_cell68 ML54 gate_way54_cell68 GND GND n1 W=1e-6 L=1e-6
mpway54_cell68 ML54 gate_way54_cell68 GND ML54 p1 W=2.4e-6 L=1e-6
mnway54_cell69 ML54 gate_way54_cell69 GND GND n1 W=1e-6 L=1e-6
mpway54_cell69 ML54 gate_way54_cell69 GND ML54 p1 W=2.4e-6 L=1e-6
mnway54_cell70 ML54 gate_way54_cell70 GND GND n1 W=1e-6 L=1e-6
mpway54_cell70 ML54 gate_way54_cell70 GND ML54 p1 W=2.4e-6 L=1e-6
mnway54_cell71 ML54 gate_way54_cell71 GND GND n1 W=1e-6 L=1e-6
mpway54_cell71 ML54 gate_way54_cell71 GND ML54 p1 W=2.4e-6 L=1e-6
mnway54_cell72 ML54 gate_way54_cell72 GND GND n1 W=1e-6 L=1e-6
mpway54_cell72 ML54 gate_way54_cell72 GND ML54 p1 W=2.4e-6 L=1e-6
mnway54_cell73 ML54 gate_way54_cell73 GND GND n1 W=1e-6 L=1e-6
mpway54_cell73 ML54 gate_way54_cell73 GND ML54 p1 W=2.4e-6 L=1e-6
mnway54_cell74 ML54 gate_way54_cell74 GND GND n1 W=1e-6 L=1e-6
mpway54_cell74 ML54 gate_way54_cell74 GND ML54 p1 W=2.4e-6 L=1e-6
mnway54_cell75 ML54 gate_way54_cell75 GND GND n1 W=1e-6 L=1e-6
mpway54_cell75 ML54 gate_way54_cell75 GND ML54 p1 W=2.4e-6 L=1e-6
mnway54_cell76 ML54 gate_way54_cell76 GND GND n1 W=1e-6 L=1e-6
mpway54_cell76 ML54 gate_way54_cell76 GND ML54 p1 W=2.4e-6 L=1e-6
mnway54_cell77 ML54 gate_way54_cell77 GND GND n1 W=1e-6 L=1e-6
mpway54_cell77 ML54 gate_way54_cell77 GND ML54 p1 W=2.4e-6 L=1e-6
mnway54_cell78 ML54 gate_way54_cell78 GND GND n1 W=1e-6 L=1e-6
mpway54_cell78 ML54 gate_way54_cell78 GND ML54 p1 W=2.4e-6 L=1e-6
mnway54_cell79 ML54 gate_way54_cell79 GND GND n1 W=1e-6 L=1e-6
mpway54_cell79 ML54 gate_way54_cell79 GND ML54 p1 W=2.4e-6 L=1e-6
mnway54_cell80 ML54 gate_way54_cell80 GND GND n1 W=1e-6 L=1e-6
mpway54_cell80 ML54 gate_way54_cell80 GND ML54 p1 W=2.4e-6 L=1e-6
mnway54_cell81 ML54 gate_way54_cell81 GND GND n1 W=1e-6 L=1e-6
mpway54_cell81 ML54 gate_way54_cell81 GND ML54 p1 W=2.4e-6 L=1e-6
mnway54_cell82 ML54 gate_way54_cell82 GND GND n1 W=1e-6 L=1e-6
mpway54_cell82 ML54 gate_way54_cell82 GND ML54 p1 W=2.4e-6 L=1e-6
mnway54_cell83 ML54 gate_way54_cell83 GND GND n1 W=1e-6 L=1e-6
mpway54_cell83 ML54 gate_way54_cell83 GND ML54 p1 W=2.4e-6 L=1e-6
mnway54_cell84 ML54 gate_way54_cell84 GND GND n1 W=1e-6 L=1e-6
mpway54_cell84 ML54 gate_way54_cell84 GND ML54 p1 W=2.4e-6 L=1e-6
mnway54_cell85 ML54 gate_way54_cell85 GND GND n1 W=1e-6 L=1e-6
mpway54_cell85 ML54 gate_way54_cell85 GND ML54 p1 W=2.4e-6 L=1e-6
mnway54_cell86 ML54 gate_way54_cell86 GND GND n1 W=1e-6 L=1e-6
mpway54_cell86 ML54 gate_way54_cell86 GND ML54 p1 W=2.4e-6 L=1e-6
mnway54_cell87 ML54 gate_way54_cell87 GND GND n1 W=1e-6 L=1e-6
mpway54_cell87 ML54 gate_way54_cell87 GND ML54 p1 W=2.4e-6 L=1e-6
mnway54_cell88 ML54 gate_way54_cell88 GND GND n1 W=1e-6 L=1e-6
mpway54_cell88 ML54 gate_way54_cell88 GND ML54 p1 W=2.4e-6 L=1e-6
mnway54_cell89 ML54 gate_way54_cell89 GND GND n1 W=1e-6 L=1e-6
mpway54_cell89 ML54 gate_way54_cell89 GND ML54 p1 W=2.4e-6 L=1e-6
mnway54_cell90 ML54 gate_way54_cell90 GND GND n1 W=1e-6 L=1e-6
mpway54_cell90 ML54 gate_way54_cell90 GND ML54 p1 W=2.4e-6 L=1e-6
mnway54_cell91 ML54 gate_way54_cell91 GND GND n1 W=1e-6 L=1e-6
mpway54_cell91 ML54 gate_way54_cell91 GND ML54 p1 W=2.4e-6 L=1e-6
mnway54_cell92 ML54 gate_way54_cell92 GND GND n1 W=1e-6 L=1e-6
mpway54_cell92 ML54 gate_way54_cell92 GND ML54 p1 W=2.4e-6 L=1e-6
mnway54_cell93 ML54 gate_way54_cell93 GND GND n1 W=1e-6 L=1e-6
mpway54_cell93 ML54 gate_way54_cell93 GND ML54 p1 W=2.4e-6 L=1e-6
mnway54_cell94 ML54 gate_way54_cell94 GND GND n1 W=1e-6 L=1e-6
mpway54_cell94 ML54 gate_way54_cell94 GND ML54 p1 W=2.4e-6 L=1e-6
mnway54_cell95 ML54 gate_way54_cell95 GND GND n1 W=1e-6 L=1e-6
mpway54_cell95 ML54 gate_way54_cell95 GND ML54 p1 W=2.4e-6 L=1e-6
mnway54_cell96 ML54 gate_way54_cell96 GND GND n1 W=1e-6 L=1e-6
mpway54_cell96 ML54 gate_way54_cell96 GND ML54 p1 W=2.4e-6 L=1e-6
mnway54_cell97 ML54 gate_way54_cell97 GND GND n1 W=1e-6 L=1e-6
mpway54_cell97 ML54 gate_way54_cell97 GND ML54 p1 W=2.4e-6 L=1e-6
mnway54_cell98 ML54 gate_way54_cell98 GND GND n1 W=1e-6 L=1e-6
mpway54_cell98 ML54 gate_way54_cell98 GND ML54 p1 W=2.4e-6 L=1e-6
mnway54_cell99 ML54 gate_way54_cell99 GND GND n1 W=1e-6 L=1e-6
mpway54_cell99 ML54 gate_way54_cell99 GND ML54 p1 W=2.4e-6 L=1e-6
mnway55_cell0 ML55 gate_way55_cell0 GND GND n1 W=1e-6 L=1e-6
mpway55_cell0 ML55 gate_way55_cell0 GND ML55 p1 W=2.4e-6 L=1e-6
mnway55_cell1 ML55 gate_way55_cell1 GND GND n1 W=1e-6 L=1e-6
mpway55_cell1 ML55 gate_way55_cell1 GND ML55 p1 W=2.4e-6 L=1e-6
mnway55_cell2 ML55 gate_way55_cell2 GND GND n1 W=1e-6 L=1e-6
mpway55_cell2 ML55 gate_way55_cell2 GND ML55 p1 W=2.4e-6 L=1e-6
mnway55_cell3 ML55 gate_way55_cell3 GND GND n1 W=1e-6 L=1e-6
mpway55_cell3 ML55 gate_way55_cell3 GND ML55 p1 W=2.4e-6 L=1e-6
mnway55_cell4 ML55 gate_way55_cell4 GND GND n1 W=1e-6 L=1e-6
mpway55_cell4 ML55 gate_way55_cell4 GND ML55 p1 W=2.4e-6 L=1e-6
mnway55_cell5 ML55 gate_way55_cell5 GND GND n1 W=1e-6 L=1e-6
mpway55_cell5 ML55 gate_way55_cell5 GND ML55 p1 W=2.4e-6 L=1e-6
mnway55_cell6 ML55 gate_way55_cell6 GND GND n1 W=1e-6 L=1e-6
mpway55_cell6 ML55 gate_way55_cell6 GND ML55 p1 W=2.4e-6 L=1e-6
mnway55_cell7 ML55 gate_way55_cell7 GND GND n1 W=1e-6 L=1e-6
mpway55_cell7 ML55 gate_way55_cell7 GND ML55 p1 W=2.4e-6 L=1e-6
mnway55_cell8 ML55 gate_way55_cell8 GND GND n1 W=1e-6 L=1e-6
mpway55_cell8 ML55 gate_way55_cell8 GND ML55 p1 W=2.4e-6 L=1e-6
mnway55_cell9 ML55 gate_way55_cell9 GND GND n1 W=1e-6 L=1e-6
mpway55_cell9 ML55 gate_way55_cell9 GND ML55 p1 W=2.4e-6 L=1e-6
mnway55_cell10 ML55 gate_way55_cell10 GND GND n1 W=1e-6 L=1e-6
mpway55_cell10 ML55 gate_way55_cell10 GND ML55 p1 W=2.4e-6 L=1e-6
mnway55_cell11 ML55 gate_way55_cell11 GND GND n1 W=1e-6 L=1e-6
mpway55_cell11 ML55 gate_way55_cell11 GND ML55 p1 W=2.4e-6 L=1e-6
mnway55_cell12 ML55 gate_way55_cell12 GND GND n1 W=1e-6 L=1e-6
mpway55_cell12 ML55 gate_way55_cell12 GND ML55 p1 W=2.4e-6 L=1e-6
mnway55_cell13 ML55 gate_way55_cell13 GND GND n1 W=1e-6 L=1e-6
mpway55_cell13 ML55 gate_way55_cell13 GND ML55 p1 W=2.4e-6 L=1e-6
mnway55_cell14 ML55 gate_way55_cell14 GND GND n1 W=1e-6 L=1e-6
mpway55_cell14 ML55 gate_way55_cell14 GND ML55 p1 W=2.4e-6 L=1e-6
mnway55_cell15 ML55 gate_way55_cell15 GND GND n1 W=1e-6 L=1e-6
mpway55_cell15 ML55 gate_way55_cell15 GND ML55 p1 W=2.4e-6 L=1e-6
mnway55_cell16 ML55 gate_way55_cell16 GND GND n1 W=1e-6 L=1e-6
mpway55_cell16 ML55 gate_way55_cell16 GND ML55 p1 W=2.4e-6 L=1e-6
mnway55_cell17 ML55 gate_way55_cell17 GND GND n1 W=1e-6 L=1e-6
mpway55_cell17 ML55 gate_way55_cell17 GND ML55 p1 W=2.4e-6 L=1e-6
mnway55_cell18 ML55 gate_way55_cell18 GND GND n1 W=1e-6 L=1e-6
mpway55_cell18 ML55 gate_way55_cell18 GND ML55 p1 W=2.4e-6 L=1e-6
mnway55_cell19 ML55 gate_way55_cell19 GND GND n1 W=1e-6 L=1e-6
mpway55_cell19 ML55 gate_way55_cell19 GND ML55 p1 W=2.4e-6 L=1e-6
mnway55_cell20 ML55 gate_way55_cell20 GND GND n1 W=1e-6 L=1e-6
mpway55_cell20 ML55 gate_way55_cell20 GND ML55 p1 W=2.4e-6 L=1e-6
mnway55_cell21 ML55 gate_way55_cell21 GND GND n1 W=1e-6 L=1e-6
mpway55_cell21 ML55 gate_way55_cell21 GND ML55 p1 W=2.4e-6 L=1e-6
mnway55_cell22 ML55 gate_way55_cell22 GND GND n1 W=1e-6 L=1e-6
mpway55_cell22 ML55 gate_way55_cell22 GND ML55 p1 W=2.4e-6 L=1e-6
mnway55_cell23 ML55 gate_way55_cell23 GND GND n1 W=1e-6 L=1e-6
mpway55_cell23 ML55 gate_way55_cell23 GND ML55 p1 W=2.4e-6 L=1e-6
mnway55_cell24 ML55 gate_way55_cell24 GND GND n1 W=1e-6 L=1e-6
mpway55_cell24 ML55 gate_way55_cell24 GND ML55 p1 W=2.4e-6 L=1e-6
mnway55_cell25 ML55 gate_way55_cell25 GND GND n1 W=1e-6 L=1e-6
mpway55_cell25 ML55 gate_way55_cell25 GND ML55 p1 W=2.4e-6 L=1e-6
mnway55_cell26 ML55 gate_way55_cell26 GND GND n1 W=1e-6 L=1e-6
mpway55_cell26 ML55 gate_way55_cell26 GND ML55 p1 W=2.4e-6 L=1e-6
mnway55_cell27 ML55 gate_way55_cell27 GND GND n1 W=1e-6 L=1e-6
mpway55_cell27 ML55 gate_way55_cell27 GND ML55 p1 W=2.4e-6 L=1e-6
mnway55_cell28 ML55 gate_way55_cell28 GND GND n1 W=1e-6 L=1e-6
mpway55_cell28 ML55 gate_way55_cell28 GND ML55 p1 W=2.4e-6 L=1e-6
mnway55_cell29 ML55 gate_way55_cell29 GND GND n1 W=1e-6 L=1e-6
mpway55_cell29 ML55 gate_way55_cell29 GND ML55 p1 W=2.4e-6 L=1e-6
mnway55_cell30 ML55 gate_way55_cell30 GND GND n1 W=1e-6 L=1e-6
mpway55_cell30 ML55 gate_way55_cell30 GND ML55 p1 W=2.4e-6 L=1e-6
mnway55_cell31 ML55 gate_way55_cell31 GND GND n1 W=1e-6 L=1e-6
mpway55_cell31 ML55 gate_way55_cell31 GND ML55 p1 W=2.4e-6 L=1e-6
mnway55_cell32 ML55 gate_way55_cell32 GND GND n1 W=1e-6 L=1e-6
mpway55_cell32 ML55 gate_way55_cell32 GND ML55 p1 W=2.4e-6 L=1e-6
mnway55_cell33 ML55 gate_way55_cell33 GND GND n1 W=1e-6 L=1e-6
mpway55_cell33 ML55 gate_way55_cell33 GND ML55 p1 W=2.4e-6 L=1e-6
mnway55_cell34 ML55 gate_way55_cell34 GND GND n1 W=1e-6 L=1e-6
mpway55_cell34 ML55 gate_way55_cell34 GND ML55 p1 W=2.4e-6 L=1e-6
mnway55_cell35 ML55 gate_way55_cell35 GND GND n1 W=1e-6 L=1e-6
mpway55_cell35 ML55 gate_way55_cell35 GND ML55 p1 W=2.4e-6 L=1e-6
mnway55_cell36 ML55 gate_way55_cell36 GND GND n1 W=1e-6 L=1e-6
mpway55_cell36 ML55 gate_way55_cell36 GND ML55 p1 W=2.4e-6 L=1e-6
mnway55_cell37 ML55 gate_way55_cell37 GND GND n1 W=1e-6 L=1e-6
mpway55_cell37 ML55 gate_way55_cell37 GND ML55 p1 W=2.4e-6 L=1e-6
mnway55_cell38 ML55 gate_way55_cell38 GND GND n1 W=1e-6 L=1e-6
mpway55_cell38 ML55 gate_way55_cell38 GND ML55 p1 W=2.4e-6 L=1e-6
mnway55_cell39 ML55 gate_way55_cell39 GND GND n1 W=1e-6 L=1e-6
mpway55_cell39 ML55 gate_way55_cell39 GND ML55 p1 W=2.4e-6 L=1e-6
mnway55_cell40 ML55 gate_way55_cell40 GND GND n1 W=1e-6 L=1e-6
mpway55_cell40 ML55 gate_way55_cell40 GND ML55 p1 W=2.4e-6 L=1e-6
mnway55_cell41 ML55 gate_way55_cell41 GND GND n1 W=1e-6 L=1e-6
mpway55_cell41 ML55 gate_way55_cell41 GND ML55 p1 W=2.4e-6 L=1e-6
mnway55_cell42 ML55 gate_way55_cell42 GND GND n1 W=1e-6 L=1e-6
mpway55_cell42 ML55 gate_way55_cell42 GND ML55 p1 W=2.4e-6 L=1e-6
mnway55_cell43 ML55 gate_way55_cell43 GND GND n1 W=1e-6 L=1e-6
mpway55_cell43 ML55 gate_way55_cell43 GND ML55 p1 W=2.4e-6 L=1e-6
mnway55_cell44 ML55 gate_way55_cell44 GND GND n1 W=1e-6 L=1e-6
mpway55_cell44 ML55 gate_way55_cell44 GND ML55 p1 W=2.4e-6 L=1e-6
mnway55_cell45 ML55 gate_way55_cell45 GND GND n1 W=1e-6 L=1e-6
mpway55_cell45 ML55 gate_way55_cell45 GND ML55 p1 W=2.4e-6 L=1e-6
mnway55_cell46 ML55 gate_way55_cell46 GND GND n1 W=1e-6 L=1e-6
mpway55_cell46 ML55 gate_way55_cell46 GND ML55 p1 W=2.4e-6 L=1e-6
mnway55_cell47 ML55 gate_way55_cell47 GND GND n1 W=1e-6 L=1e-6
mpway55_cell47 ML55 gate_way55_cell47 GND ML55 p1 W=2.4e-6 L=1e-6
mnway55_cell48 ML55 gate_way55_cell48 GND GND n1 W=1e-6 L=1e-6
mpway55_cell48 ML55 gate_way55_cell48 GND ML55 p1 W=2.4e-6 L=1e-6
mnway55_cell49 ML55 gate_way55_cell49 GND GND n1 W=1e-6 L=1e-6
mpway55_cell49 ML55 gate_way55_cell49 GND ML55 p1 W=2.4e-6 L=1e-6
mnway55_cell50 ML55 gate_way55_cell50 GND GND n1 W=1e-6 L=1e-6
mpway55_cell50 ML55 gate_way55_cell50 GND ML55 p1 W=2.4e-6 L=1e-6
mnway55_cell51 ML55 gate_way55_cell51 GND GND n1 W=1e-6 L=1e-6
mpway55_cell51 ML55 gate_way55_cell51 GND ML55 p1 W=2.4e-6 L=1e-6
mnway55_cell52 ML55 gate_way55_cell52 GND GND n1 W=1e-6 L=1e-6
mpway55_cell52 ML55 gate_way55_cell52 GND ML55 p1 W=2.4e-6 L=1e-6
mnway55_cell53 ML55 gate_way55_cell53 GND GND n1 W=1e-6 L=1e-6
mpway55_cell53 ML55 gate_way55_cell53 GND ML55 p1 W=2.4e-6 L=1e-6
mnway55_cell54 ML55 gate_way55_cell54 GND GND n1 W=1e-6 L=1e-6
mpway55_cell54 ML55 gate_way55_cell54 GND ML55 p1 W=2.4e-6 L=1e-6
mnway55_cell55 ML55 gate_way55_cell55 GND GND n1 W=1e-6 L=1e-6
mpway55_cell55 ML55 gate_way55_cell55 GND ML55 p1 W=2.4e-6 L=1e-6
mnway55_cell56 ML55 gate_way55_cell56 GND GND n1 W=1e-6 L=1e-6
mpway55_cell56 ML55 gate_way55_cell56 GND ML55 p1 W=2.4e-6 L=1e-6
mnway55_cell57 ML55 gate_way55_cell57 GND GND n1 W=1e-6 L=1e-6
mpway55_cell57 ML55 gate_way55_cell57 GND ML55 p1 W=2.4e-6 L=1e-6
mnway55_cell58 ML55 gate_way55_cell58 GND GND n1 W=1e-6 L=1e-6
mpway55_cell58 ML55 gate_way55_cell58 GND ML55 p1 W=2.4e-6 L=1e-6
mnway55_cell59 ML55 gate_way55_cell59 GND GND n1 W=1e-6 L=1e-6
mpway55_cell59 ML55 gate_way55_cell59 GND ML55 p1 W=2.4e-6 L=1e-6
mnway55_cell60 ML55 gate_way55_cell60 GND GND n1 W=1e-6 L=1e-6
mpway55_cell60 ML55 gate_way55_cell60 GND ML55 p1 W=2.4e-6 L=1e-6
mnway55_cell61 ML55 gate_way55_cell61 GND GND n1 W=1e-6 L=1e-6
mpway55_cell61 ML55 gate_way55_cell61 GND ML55 p1 W=2.4e-6 L=1e-6
mnway55_cell62 ML55 gate_way55_cell62 GND GND n1 W=1e-6 L=1e-6
mpway55_cell62 ML55 gate_way55_cell62 GND ML55 p1 W=2.4e-6 L=1e-6
mnway55_cell63 ML55 gate_way55_cell63 GND GND n1 W=1e-6 L=1e-6
mpway55_cell63 ML55 gate_way55_cell63 GND ML55 p1 W=2.4e-6 L=1e-6
mnway55_cell64 ML55 gate_way55_cell64 GND GND n1 W=1e-6 L=1e-6
mpway55_cell64 ML55 gate_way55_cell64 GND ML55 p1 W=2.4e-6 L=1e-6
mnway55_cell65 ML55 gate_way55_cell65 GND GND n1 W=1e-6 L=1e-6
mpway55_cell65 ML55 gate_way55_cell65 GND ML55 p1 W=2.4e-6 L=1e-6
mnway55_cell66 ML55 gate_way55_cell66 GND GND n1 W=1e-6 L=1e-6
mpway55_cell66 ML55 gate_way55_cell66 GND ML55 p1 W=2.4e-6 L=1e-6
mnway55_cell67 ML55 gate_way55_cell67 GND GND n1 W=1e-6 L=1e-6
mpway55_cell67 ML55 gate_way55_cell67 GND ML55 p1 W=2.4e-6 L=1e-6
mnway55_cell68 ML55 gate_way55_cell68 GND GND n1 W=1e-6 L=1e-6
mpway55_cell68 ML55 gate_way55_cell68 GND ML55 p1 W=2.4e-6 L=1e-6
mnway55_cell69 ML55 gate_way55_cell69 GND GND n1 W=1e-6 L=1e-6
mpway55_cell69 ML55 gate_way55_cell69 GND ML55 p1 W=2.4e-6 L=1e-6
mnway55_cell70 ML55 gate_way55_cell70 GND GND n1 W=1e-6 L=1e-6
mpway55_cell70 ML55 gate_way55_cell70 GND ML55 p1 W=2.4e-6 L=1e-6
mnway55_cell71 ML55 gate_way55_cell71 GND GND n1 W=1e-6 L=1e-6
mpway55_cell71 ML55 gate_way55_cell71 GND ML55 p1 W=2.4e-6 L=1e-6
mnway55_cell72 ML55 gate_way55_cell72 GND GND n1 W=1e-6 L=1e-6
mpway55_cell72 ML55 gate_way55_cell72 GND ML55 p1 W=2.4e-6 L=1e-6
mnway55_cell73 ML55 gate_way55_cell73 GND GND n1 W=1e-6 L=1e-6
mpway55_cell73 ML55 gate_way55_cell73 GND ML55 p1 W=2.4e-6 L=1e-6
mnway55_cell74 ML55 gate_way55_cell74 GND GND n1 W=1e-6 L=1e-6
mpway55_cell74 ML55 gate_way55_cell74 GND ML55 p1 W=2.4e-6 L=1e-6
mnway55_cell75 ML55 gate_way55_cell75 GND GND n1 W=1e-6 L=1e-6
mpway55_cell75 ML55 gate_way55_cell75 GND ML55 p1 W=2.4e-6 L=1e-6
mnway55_cell76 ML55 gate_way55_cell76 GND GND n1 W=1e-6 L=1e-6
mpway55_cell76 ML55 gate_way55_cell76 GND ML55 p1 W=2.4e-6 L=1e-6
mnway55_cell77 ML55 gate_way55_cell77 GND GND n1 W=1e-6 L=1e-6
mpway55_cell77 ML55 gate_way55_cell77 GND ML55 p1 W=2.4e-6 L=1e-6
mnway55_cell78 ML55 gate_way55_cell78 GND GND n1 W=1e-6 L=1e-6
mpway55_cell78 ML55 gate_way55_cell78 GND ML55 p1 W=2.4e-6 L=1e-6
mnway55_cell79 ML55 gate_way55_cell79 GND GND n1 W=1e-6 L=1e-6
mpway55_cell79 ML55 gate_way55_cell79 GND ML55 p1 W=2.4e-6 L=1e-6
mnway55_cell80 ML55 gate_way55_cell80 GND GND n1 W=1e-6 L=1e-6
mpway55_cell80 ML55 gate_way55_cell80 GND ML55 p1 W=2.4e-6 L=1e-6
mnway55_cell81 ML55 gate_way55_cell81 GND GND n1 W=1e-6 L=1e-6
mpway55_cell81 ML55 gate_way55_cell81 GND ML55 p1 W=2.4e-6 L=1e-6
mnway55_cell82 ML55 gate_way55_cell82 GND GND n1 W=1e-6 L=1e-6
mpway55_cell82 ML55 gate_way55_cell82 GND ML55 p1 W=2.4e-6 L=1e-6
mnway55_cell83 ML55 gate_way55_cell83 GND GND n1 W=1e-6 L=1e-6
mpway55_cell83 ML55 gate_way55_cell83 GND ML55 p1 W=2.4e-6 L=1e-6
mnway55_cell84 ML55 gate_way55_cell84 GND GND n1 W=1e-6 L=1e-6
mpway55_cell84 ML55 gate_way55_cell84 GND ML55 p1 W=2.4e-6 L=1e-6
mnway55_cell85 ML55 gate_way55_cell85 GND GND n1 W=1e-6 L=1e-6
mpway55_cell85 ML55 gate_way55_cell85 GND ML55 p1 W=2.4e-6 L=1e-6
mnway55_cell86 ML55 gate_way55_cell86 GND GND n1 W=1e-6 L=1e-6
mpway55_cell86 ML55 gate_way55_cell86 GND ML55 p1 W=2.4e-6 L=1e-6
mnway55_cell87 ML55 gate_way55_cell87 GND GND n1 W=1e-6 L=1e-6
mpway55_cell87 ML55 gate_way55_cell87 GND ML55 p1 W=2.4e-6 L=1e-6
mnway55_cell88 ML55 gate_way55_cell88 GND GND n1 W=1e-6 L=1e-6
mpway55_cell88 ML55 gate_way55_cell88 GND ML55 p1 W=2.4e-6 L=1e-6
mnway55_cell89 ML55 gate_way55_cell89 GND GND n1 W=1e-6 L=1e-6
mpway55_cell89 ML55 gate_way55_cell89 GND ML55 p1 W=2.4e-6 L=1e-6
mnway55_cell90 ML55 gate_way55_cell90 GND GND n1 W=1e-6 L=1e-6
mpway55_cell90 ML55 gate_way55_cell90 GND ML55 p1 W=2.4e-6 L=1e-6
mnway55_cell91 ML55 gate_way55_cell91 GND GND n1 W=1e-6 L=1e-6
mpway55_cell91 ML55 gate_way55_cell91 GND ML55 p1 W=2.4e-6 L=1e-6
mnway55_cell92 ML55 gate_way55_cell92 GND GND n1 W=1e-6 L=1e-6
mpway55_cell92 ML55 gate_way55_cell92 GND ML55 p1 W=2.4e-6 L=1e-6
mnway55_cell93 ML55 gate_way55_cell93 GND GND n1 W=1e-6 L=1e-6
mpway55_cell93 ML55 gate_way55_cell93 GND ML55 p1 W=2.4e-6 L=1e-6
mnway55_cell94 ML55 gate_way55_cell94 GND GND n1 W=1e-6 L=1e-6
mpway55_cell94 ML55 gate_way55_cell94 GND ML55 p1 W=2.4e-6 L=1e-6
mnway55_cell95 ML55 gate_way55_cell95 GND GND n1 W=1e-6 L=1e-6
mpway55_cell95 ML55 gate_way55_cell95 GND ML55 p1 W=2.4e-6 L=1e-6
mnway55_cell96 ML55 gate_way55_cell96 GND GND n1 W=1e-6 L=1e-6
mpway55_cell96 ML55 gate_way55_cell96 GND ML55 p1 W=2.4e-6 L=1e-6
mnway55_cell97 ML55 gate_way55_cell97 GND GND n1 W=1e-6 L=1e-6
mpway55_cell97 ML55 gate_way55_cell97 GND ML55 p1 W=2.4e-6 L=1e-6
mnway55_cell98 ML55 gate_way55_cell98 GND GND n1 W=1e-6 L=1e-6
mpway55_cell98 ML55 gate_way55_cell98 GND ML55 p1 W=2.4e-6 L=1e-6
mnway55_cell99 ML55 gate_way55_cell99 GND GND n1 W=1e-6 L=1e-6
mpway55_cell99 ML55 gate_way55_cell99 GND ML55 p1 W=2.4e-6 L=1e-6
mnway56_cell0 ML56 gate_way56_cell0 GND GND n1 W=1e-6 L=1e-6
mpway56_cell0 ML56 gate_way56_cell0 GND ML56 p1 W=2.4e-6 L=1e-6
mnway56_cell1 ML56 gate_way56_cell1 GND GND n1 W=1e-6 L=1e-6
mpway56_cell1 ML56 gate_way56_cell1 GND ML56 p1 W=2.4e-6 L=1e-6
mnway56_cell2 ML56 gate_way56_cell2 GND GND n1 W=1e-6 L=1e-6
mpway56_cell2 ML56 gate_way56_cell2 GND ML56 p1 W=2.4e-6 L=1e-6
mnway56_cell3 ML56 gate_way56_cell3 GND GND n1 W=1e-6 L=1e-6
mpway56_cell3 ML56 gate_way56_cell3 GND ML56 p1 W=2.4e-6 L=1e-6
mnway56_cell4 ML56 gate_way56_cell4 GND GND n1 W=1e-6 L=1e-6
mpway56_cell4 ML56 gate_way56_cell4 GND ML56 p1 W=2.4e-6 L=1e-6
mnway56_cell5 ML56 gate_way56_cell5 GND GND n1 W=1e-6 L=1e-6
mpway56_cell5 ML56 gate_way56_cell5 GND ML56 p1 W=2.4e-6 L=1e-6
mnway56_cell6 ML56 gate_way56_cell6 GND GND n1 W=1e-6 L=1e-6
mpway56_cell6 ML56 gate_way56_cell6 GND ML56 p1 W=2.4e-6 L=1e-6
mnway56_cell7 ML56 gate_way56_cell7 GND GND n1 W=1e-6 L=1e-6
mpway56_cell7 ML56 gate_way56_cell7 GND ML56 p1 W=2.4e-6 L=1e-6
mnway56_cell8 ML56 gate_way56_cell8 GND GND n1 W=1e-6 L=1e-6
mpway56_cell8 ML56 gate_way56_cell8 GND ML56 p1 W=2.4e-6 L=1e-6
mnway56_cell9 ML56 gate_way56_cell9 GND GND n1 W=1e-6 L=1e-6
mpway56_cell9 ML56 gate_way56_cell9 GND ML56 p1 W=2.4e-6 L=1e-6
mnway56_cell10 ML56 gate_way56_cell10 GND GND n1 W=1e-6 L=1e-6
mpway56_cell10 ML56 gate_way56_cell10 GND ML56 p1 W=2.4e-6 L=1e-6
mnway56_cell11 ML56 gate_way56_cell11 GND GND n1 W=1e-6 L=1e-6
mpway56_cell11 ML56 gate_way56_cell11 GND ML56 p1 W=2.4e-6 L=1e-6
mnway56_cell12 ML56 gate_way56_cell12 GND GND n1 W=1e-6 L=1e-6
mpway56_cell12 ML56 gate_way56_cell12 GND ML56 p1 W=2.4e-6 L=1e-6
mnway56_cell13 ML56 gate_way56_cell13 GND GND n1 W=1e-6 L=1e-6
mpway56_cell13 ML56 gate_way56_cell13 GND ML56 p1 W=2.4e-6 L=1e-6
mnway56_cell14 ML56 gate_way56_cell14 GND GND n1 W=1e-6 L=1e-6
mpway56_cell14 ML56 gate_way56_cell14 GND ML56 p1 W=2.4e-6 L=1e-6
mnway56_cell15 ML56 gate_way56_cell15 GND GND n1 W=1e-6 L=1e-6
mpway56_cell15 ML56 gate_way56_cell15 GND ML56 p1 W=2.4e-6 L=1e-6
mnway56_cell16 ML56 gate_way56_cell16 GND GND n1 W=1e-6 L=1e-6
mpway56_cell16 ML56 gate_way56_cell16 GND ML56 p1 W=2.4e-6 L=1e-6
mnway56_cell17 ML56 gate_way56_cell17 GND GND n1 W=1e-6 L=1e-6
mpway56_cell17 ML56 gate_way56_cell17 GND ML56 p1 W=2.4e-6 L=1e-6
mnway56_cell18 ML56 gate_way56_cell18 GND GND n1 W=1e-6 L=1e-6
mpway56_cell18 ML56 gate_way56_cell18 GND ML56 p1 W=2.4e-6 L=1e-6
mnway56_cell19 ML56 gate_way56_cell19 GND GND n1 W=1e-6 L=1e-6
mpway56_cell19 ML56 gate_way56_cell19 GND ML56 p1 W=2.4e-6 L=1e-6
mnway56_cell20 ML56 gate_way56_cell20 GND GND n1 W=1e-6 L=1e-6
mpway56_cell20 ML56 gate_way56_cell20 GND ML56 p1 W=2.4e-6 L=1e-6
mnway56_cell21 ML56 gate_way56_cell21 GND GND n1 W=1e-6 L=1e-6
mpway56_cell21 ML56 gate_way56_cell21 GND ML56 p1 W=2.4e-6 L=1e-6
mnway56_cell22 ML56 gate_way56_cell22 GND GND n1 W=1e-6 L=1e-6
mpway56_cell22 ML56 gate_way56_cell22 GND ML56 p1 W=2.4e-6 L=1e-6
mnway56_cell23 ML56 gate_way56_cell23 GND GND n1 W=1e-6 L=1e-6
mpway56_cell23 ML56 gate_way56_cell23 GND ML56 p1 W=2.4e-6 L=1e-6
mnway56_cell24 ML56 gate_way56_cell24 GND GND n1 W=1e-6 L=1e-6
mpway56_cell24 ML56 gate_way56_cell24 GND ML56 p1 W=2.4e-6 L=1e-6
mnway56_cell25 ML56 gate_way56_cell25 GND GND n1 W=1e-6 L=1e-6
mpway56_cell25 ML56 gate_way56_cell25 GND ML56 p1 W=2.4e-6 L=1e-6
mnway56_cell26 ML56 gate_way56_cell26 GND GND n1 W=1e-6 L=1e-6
mpway56_cell26 ML56 gate_way56_cell26 GND ML56 p1 W=2.4e-6 L=1e-6
mnway56_cell27 ML56 gate_way56_cell27 GND GND n1 W=1e-6 L=1e-6
mpway56_cell27 ML56 gate_way56_cell27 GND ML56 p1 W=2.4e-6 L=1e-6
mnway56_cell28 ML56 gate_way56_cell28 GND GND n1 W=1e-6 L=1e-6
mpway56_cell28 ML56 gate_way56_cell28 GND ML56 p1 W=2.4e-6 L=1e-6
mnway56_cell29 ML56 gate_way56_cell29 GND GND n1 W=1e-6 L=1e-6
mpway56_cell29 ML56 gate_way56_cell29 GND ML56 p1 W=2.4e-6 L=1e-6
mnway56_cell30 ML56 gate_way56_cell30 GND GND n1 W=1e-6 L=1e-6
mpway56_cell30 ML56 gate_way56_cell30 GND ML56 p1 W=2.4e-6 L=1e-6
mnway56_cell31 ML56 gate_way56_cell31 GND GND n1 W=1e-6 L=1e-6
mpway56_cell31 ML56 gate_way56_cell31 GND ML56 p1 W=2.4e-6 L=1e-6
mnway56_cell32 ML56 gate_way56_cell32 GND GND n1 W=1e-6 L=1e-6
mpway56_cell32 ML56 gate_way56_cell32 GND ML56 p1 W=2.4e-6 L=1e-6
mnway56_cell33 ML56 gate_way56_cell33 GND GND n1 W=1e-6 L=1e-6
mpway56_cell33 ML56 gate_way56_cell33 GND ML56 p1 W=2.4e-6 L=1e-6
mnway56_cell34 ML56 gate_way56_cell34 GND GND n1 W=1e-6 L=1e-6
mpway56_cell34 ML56 gate_way56_cell34 GND ML56 p1 W=2.4e-6 L=1e-6
mnway56_cell35 ML56 gate_way56_cell35 GND GND n1 W=1e-6 L=1e-6
mpway56_cell35 ML56 gate_way56_cell35 GND ML56 p1 W=2.4e-6 L=1e-6
mnway56_cell36 ML56 gate_way56_cell36 GND GND n1 W=1e-6 L=1e-6
mpway56_cell36 ML56 gate_way56_cell36 GND ML56 p1 W=2.4e-6 L=1e-6
mnway56_cell37 ML56 gate_way56_cell37 GND GND n1 W=1e-6 L=1e-6
mpway56_cell37 ML56 gate_way56_cell37 GND ML56 p1 W=2.4e-6 L=1e-6
mnway56_cell38 ML56 gate_way56_cell38 GND GND n1 W=1e-6 L=1e-6
mpway56_cell38 ML56 gate_way56_cell38 GND ML56 p1 W=2.4e-6 L=1e-6
mnway56_cell39 ML56 gate_way56_cell39 GND GND n1 W=1e-6 L=1e-6
mpway56_cell39 ML56 gate_way56_cell39 GND ML56 p1 W=2.4e-6 L=1e-6
mnway56_cell40 ML56 gate_way56_cell40 GND GND n1 W=1e-6 L=1e-6
mpway56_cell40 ML56 gate_way56_cell40 GND ML56 p1 W=2.4e-6 L=1e-6
mnway56_cell41 ML56 gate_way56_cell41 GND GND n1 W=1e-6 L=1e-6
mpway56_cell41 ML56 gate_way56_cell41 GND ML56 p1 W=2.4e-6 L=1e-6
mnway56_cell42 ML56 gate_way56_cell42 GND GND n1 W=1e-6 L=1e-6
mpway56_cell42 ML56 gate_way56_cell42 GND ML56 p1 W=2.4e-6 L=1e-6
mnway56_cell43 ML56 gate_way56_cell43 GND GND n1 W=1e-6 L=1e-6
mpway56_cell43 ML56 gate_way56_cell43 GND ML56 p1 W=2.4e-6 L=1e-6
mnway56_cell44 ML56 gate_way56_cell44 GND GND n1 W=1e-6 L=1e-6
mpway56_cell44 ML56 gate_way56_cell44 GND ML56 p1 W=2.4e-6 L=1e-6
mnway56_cell45 ML56 gate_way56_cell45 GND GND n1 W=1e-6 L=1e-6
mpway56_cell45 ML56 gate_way56_cell45 GND ML56 p1 W=2.4e-6 L=1e-6
mnway56_cell46 ML56 gate_way56_cell46 GND GND n1 W=1e-6 L=1e-6
mpway56_cell46 ML56 gate_way56_cell46 GND ML56 p1 W=2.4e-6 L=1e-6
mnway56_cell47 ML56 gate_way56_cell47 GND GND n1 W=1e-6 L=1e-6
mpway56_cell47 ML56 gate_way56_cell47 GND ML56 p1 W=2.4e-6 L=1e-6
mnway56_cell48 ML56 gate_way56_cell48 GND GND n1 W=1e-6 L=1e-6
mpway56_cell48 ML56 gate_way56_cell48 GND ML56 p1 W=2.4e-6 L=1e-6
mnway56_cell49 ML56 gate_way56_cell49 GND GND n1 W=1e-6 L=1e-6
mpway56_cell49 ML56 gate_way56_cell49 GND ML56 p1 W=2.4e-6 L=1e-6
mnway56_cell50 ML56 gate_way56_cell50 GND GND n1 W=1e-6 L=1e-6
mpway56_cell50 ML56 gate_way56_cell50 GND ML56 p1 W=2.4e-6 L=1e-6
mnway56_cell51 ML56 gate_way56_cell51 GND GND n1 W=1e-6 L=1e-6
mpway56_cell51 ML56 gate_way56_cell51 GND ML56 p1 W=2.4e-6 L=1e-6
mnway56_cell52 ML56 gate_way56_cell52 GND GND n1 W=1e-6 L=1e-6
mpway56_cell52 ML56 gate_way56_cell52 GND ML56 p1 W=2.4e-6 L=1e-6
mnway56_cell53 ML56 gate_way56_cell53 GND GND n1 W=1e-6 L=1e-6
mpway56_cell53 ML56 gate_way56_cell53 GND ML56 p1 W=2.4e-6 L=1e-6
mnway56_cell54 ML56 gate_way56_cell54 GND GND n1 W=1e-6 L=1e-6
mpway56_cell54 ML56 gate_way56_cell54 GND ML56 p1 W=2.4e-6 L=1e-6
mnway56_cell55 ML56 gate_way56_cell55 GND GND n1 W=1e-6 L=1e-6
mpway56_cell55 ML56 gate_way56_cell55 GND ML56 p1 W=2.4e-6 L=1e-6
mnway56_cell56 ML56 gate_way56_cell56 GND GND n1 W=1e-6 L=1e-6
mpway56_cell56 ML56 gate_way56_cell56 GND ML56 p1 W=2.4e-6 L=1e-6
mnway56_cell57 ML56 gate_way56_cell57 GND GND n1 W=1e-6 L=1e-6
mpway56_cell57 ML56 gate_way56_cell57 GND ML56 p1 W=2.4e-6 L=1e-6
mnway56_cell58 ML56 gate_way56_cell58 GND GND n1 W=1e-6 L=1e-6
mpway56_cell58 ML56 gate_way56_cell58 GND ML56 p1 W=2.4e-6 L=1e-6
mnway56_cell59 ML56 gate_way56_cell59 GND GND n1 W=1e-6 L=1e-6
mpway56_cell59 ML56 gate_way56_cell59 GND ML56 p1 W=2.4e-6 L=1e-6
mnway56_cell60 ML56 gate_way56_cell60 GND GND n1 W=1e-6 L=1e-6
mpway56_cell60 ML56 gate_way56_cell60 GND ML56 p1 W=2.4e-6 L=1e-6
mnway56_cell61 ML56 gate_way56_cell61 GND GND n1 W=1e-6 L=1e-6
mpway56_cell61 ML56 gate_way56_cell61 GND ML56 p1 W=2.4e-6 L=1e-6
mnway56_cell62 ML56 gate_way56_cell62 GND GND n1 W=1e-6 L=1e-6
mpway56_cell62 ML56 gate_way56_cell62 GND ML56 p1 W=2.4e-6 L=1e-6
mnway56_cell63 ML56 gate_way56_cell63 GND GND n1 W=1e-6 L=1e-6
mpway56_cell63 ML56 gate_way56_cell63 GND ML56 p1 W=2.4e-6 L=1e-6
mnway56_cell64 ML56 gate_way56_cell64 GND GND n1 W=1e-6 L=1e-6
mpway56_cell64 ML56 gate_way56_cell64 GND ML56 p1 W=2.4e-6 L=1e-6
mnway56_cell65 ML56 gate_way56_cell65 GND GND n1 W=1e-6 L=1e-6
mpway56_cell65 ML56 gate_way56_cell65 GND ML56 p1 W=2.4e-6 L=1e-6
mnway56_cell66 ML56 gate_way56_cell66 GND GND n1 W=1e-6 L=1e-6
mpway56_cell66 ML56 gate_way56_cell66 GND ML56 p1 W=2.4e-6 L=1e-6
mnway56_cell67 ML56 gate_way56_cell67 GND GND n1 W=1e-6 L=1e-6
mpway56_cell67 ML56 gate_way56_cell67 GND ML56 p1 W=2.4e-6 L=1e-6
mnway56_cell68 ML56 gate_way56_cell68 GND GND n1 W=1e-6 L=1e-6
mpway56_cell68 ML56 gate_way56_cell68 GND ML56 p1 W=2.4e-6 L=1e-6
mnway56_cell69 ML56 gate_way56_cell69 GND GND n1 W=1e-6 L=1e-6
mpway56_cell69 ML56 gate_way56_cell69 GND ML56 p1 W=2.4e-6 L=1e-6
mnway56_cell70 ML56 gate_way56_cell70 GND GND n1 W=1e-6 L=1e-6
mpway56_cell70 ML56 gate_way56_cell70 GND ML56 p1 W=2.4e-6 L=1e-6
mnway56_cell71 ML56 gate_way56_cell71 GND GND n1 W=1e-6 L=1e-6
mpway56_cell71 ML56 gate_way56_cell71 GND ML56 p1 W=2.4e-6 L=1e-6
mnway56_cell72 ML56 gate_way56_cell72 GND GND n1 W=1e-6 L=1e-6
mpway56_cell72 ML56 gate_way56_cell72 GND ML56 p1 W=2.4e-6 L=1e-6
mnway56_cell73 ML56 gate_way56_cell73 GND GND n1 W=1e-6 L=1e-6
mpway56_cell73 ML56 gate_way56_cell73 GND ML56 p1 W=2.4e-6 L=1e-6
mnway56_cell74 ML56 gate_way56_cell74 GND GND n1 W=1e-6 L=1e-6
mpway56_cell74 ML56 gate_way56_cell74 GND ML56 p1 W=2.4e-6 L=1e-6
mnway56_cell75 ML56 gate_way56_cell75 GND GND n1 W=1e-6 L=1e-6
mpway56_cell75 ML56 gate_way56_cell75 GND ML56 p1 W=2.4e-6 L=1e-6
mnway56_cell76 ML56 gate_way56_cell76 GND GND n1 W=1e-6 L=1e-6
mpway56_cell76 ML56 gate_way56_cell76 GND ML56 p1 W=2.4e-6 L=1e-6
mnway56_cell77 ML56 gate_way56_cell77 GND GND n1 W=1e-6 L=1e-6
mpway56_cell77 ML56 gate_way56_cell77 GND ML56 p1 W=2.4e-6 L=1e-6
mnway56_cell78 ML56 gate_way56_cell78 GND GND n1 W=1e-6 L=1e-6
mpway56_cell78 ML56 gate_way56_cell78 GND ML56 p1 W=2.4e-6 L=1e-6
mnway56_cell79 ML56 gate_way56_cell79 GND GND n1 W=1e-6 L=1e-6
mpway56_cell79 ML56 gate_way56_cell79 GND ML56 p1 W=2.4e-6 L=1e-6
mnway56_cell80 ML56 gate_way56_cell80 GND GND n1 W=1e-6 L=1e-6
mpway56_cell80 ML56 gate_way56_cell80 GND ML56 p1 W=2.4e-6 L=1e-6
mnway56_cell81 ML56 gate_way56_cell81 GND GND n1 W=1e-6 L=1e-6
mpway56_cell81 ML56 gate_way56_cell81 GND ML56 p1 W=2.4e-6 L=1e-6
mnway56_cell82 ML56 gate_way56_cell82 GND GND n1 W=1e-6 L=1e-6
mpway56_cell82 ML56 gate_way56_cell82 GND ML56 p1 W=2.4e-6 L=1e-6
mnway56_cell83 ML56 gate_way56_cell83 GND GND n1 W=1e-6 L=1e-6
mpway56_cell83 ML56 gate_way56_cell83 GND ML56 p1 W=2.4e-6 L=1e-6
mnway56_cell84 ML56 gate_way56_cell84 GND GND n1 W=1e-6 L=1e-6
mpway56_cell84 ML56 gate_way56_cell84 GND ML56 p1 W=2.4e-6 L=1e-6
mnway56_cell85 ML56 gate_way56_cell85 GND GND n1 W=1e-6 L=1e-6
mpway56_cell85 ML56 gate_way56_cell85 GND ML56 p1 W=2.4e-6 L=1e-6
mnway56_cell86 ML56 gate_way56_cell86 GND GND n1 W=1e-6 L=1e-6
mpway56_cell86 ML56 gate_way56_cell86 GND ML56 p1 W=2.4e-6 L=1e-6
mnway56_cell87 ML56 gate_way56_cell87 GND GND n1 W=1e-6 L=1e-6
mpway56_cell87 ML56 gate_way56_cell87 GND ML56 p1 W=2.4e-6 L=1e-6
mnway56_cell88 ML56 gate_way56_cell88 GND GND n1 W=1e-6 L=1e-6
mpway56_cell88 ML56 gate_way56_cell88 GND ML56 p1 W=2.4e-6 L=1e-6
mnway56_cell89 ML56 gate_way56_cell89 GND GND n1 W=1e-6 L=1e-6
mpway56_cell89 ML56 gate_way56_cell89 GND ML56 p1 W=2.4e-6 L=1e-6
mnway56_cell90 ML56 gate_way56_cell90 GND GND n1 W=1e-6 L=1e-6
mpway56_cell90 ML56 gate_way56_cell90 GND ML56 p1 W=2.4e-6 L=1e-6
mnway56_cell91 ML56 gate_way56_cell91 GND GND n1 W=1e-6 L=1e-6
mpway56_cell91 ML56 gate_way56_cell91 GND ML56 p1 W=2.4e-6 L=1e-6
mnway56_cell92 ML56 gate_way56_cell92 GND GND n1 W=1e-6 L=1e-6
mpway56_cell92 ML56 gate_way56_cell92 GND ML56 p1 W=2.4e-6 L=1e-6
mnway56_cell93 ML56 gate_way56_cell93 GND GND n1 W=1e-6 L=1e-6
mpway56_cell93 ML56 gate_way56_cell93 GND ML56 p1 W=2.4e-6 L=1e-6
mnway56_cell94 ML56 gate_way56_cell94 GND GND n1 W=1e-6 L=1e-6
mpway56_cell94 ML56 gate_way56_cell94 GND ML56 p1 W=2.4e-6 L=1e-6
mnway56_cell95 ML56 gate_way56_cell95 GND GND n1 W=1e-6 L=1e-6
mpway56_cell95 ML56 gate_way56_cell95 GND ML56 p1 W=2.4e-6 L=1e-6
mnway56_cell96 ML56 gate_way56_cell96 GND GND n1 W=1e-6 L=1e-6
mpway56_cell96 ML56 gate_way56_cell96 GND ML56 p1 W=2.4e-6 L=1e-6
mnway56_cell97 ML56 gate_way56_cell97 GND GND n1 W=1e-6 L=1e-6
mpway56_cell97 ML56 gate_way56_cell97 GND ML56 p1 W=2.4e-6 L=1e-6
mnway56_cell98 ML56 gate_way56_cell98 GND GND n1 W=1e-6 L=1e-6
mpway56_cell98 ML56 gate_way56_cell98 GND ML56 p1 W=2.4e-6 L=1e-6
mnway56_cell99 ML56 gate_way56_cell99 GND GND n1 W=1e-6 L=1e-6
mpway56_cell99 ML56 gate_way56_cell99 GND ML56 p1 W=2.4e-6 L=1e-6
mnway57_cell0 ML57 gate_way57_cell0 GND GND n1 W=1e-6 L=1e-6
mpway57_cell0 ML57 gate_way57_cell0 GND ML57 p1 W=2.4e-6 L=1e-6
mnway57_cell1 ML57 gate_way57_cell1 GND GND n1 W=1e-6 L=1e-6
mpway57_cell1 ML57 gate_way57_cell1 GND ML57 p1 W=2.4e-6 L=1e-6
mnway57_cell2 ML57 gate_way57_cell2 GND GND n1 W=1e-6 L=1e-6
mpway57_cell2 ML57 gate_way57_cell2 GND ML57 p1 W=2.4e-6 L=1e-6
mnway57_cell3 ML57 gate_way57_cell3 GND GND n1 W=1e-6 L=1e-6
mpway57_cell3 ML57 gate_way57_cell3 GND ML57 p1 W=2.4e-6 L=1e-6
mnway57_cell4 ML57 gate_way57_cell4 GND GND n1 W=1e-6 L=1e-6
mpway57_cell4 ML57 gate_way57_cell4 GND ML57 p1 W=2.4e-6 L=1e-6
mnway57_cell5 ML57 gate_way57_cell5 GND GND n1 W=1e-6 L=1e-6
mpway57_cell5 ML57 gate_way57_cell5 GND ML57 p1 W=2.4e-6 L=1e-6
mnway57_cell6 ML57 gate_way57_cell6 GND GND n1 W=1e-6 L=1e-6
mpway57_cell6 ML57 gate_way57_cell6 GND ML57 p1 W=2.4e-6 L=1e-6
mnway57_cell7 ML57 gate_way57_cell7 GND GND n1 W=1e-6 L=1e-6
mpway57_cell7 ML57 gate_way57_cell7 GND ML57 p1 W=2.4e-6 L=1e-6
mnway57_cell8 ML57 gate_way57_cell8 GND GND n1 W=1e-6 L=1e-6
mpway57_cell8 ML57 gate_way57_cell8 GND ML57 p1 W=2.4e-6 L=1e-6
mnway57_cell9 ML57 gate_way57_cell9 GND GND n1 W=1e-6 L=1e-6
mpway57_cell9 ML57 gate_way57_cell9 GND ML57 p1 W=2.4e-6 L=1e-6
mnway57_cell10 ML57 gate_way57_cell10 GND GND n1 W=1e-6 L=1e-6
mpway57_cell10 ML57 gate_way57_cell10 GND ML57 p1 W=2.4e-6 L=1e-6
mnway57_cell11 ML57 gate_way57_cell11 GND GND n1 W=1e-6 L=1e-6
mpway57_cell11 ML57 gate_way57_cell11 GND ML57 p1 W=2.4e-6 L=1e-6
mnway57_cell12 ML57 gate_way57_cell12 GND GND n1 W=1e-6 L=1e-6
mpway57_cell12 ML57 gate_way57_cell12 GND ML57 p1 W=2.4e-6 L=1e-6
mnway57_cell13 ML57 gate_way57_cell13 GND GND n1 W=1e-6 L=1e-6
mpway57_cell13 ML57 gate_way57_cell13 GND ML57 p1 W=2.4e-6 L=1e-6
mnway57_cell14 ML57 gate_way57_cell14 GND GND n1 W=1e-6 L=1e-6
mpway57_cell14 ML57 gate_way57_cell14 GND ML57 p1 W=2.4e-6 L=1e-6
mnway57_cell15 ML57 gate_way57_cell15 GND GND n1 W=1e-6 L=1e-6
mpway57_cell15 ML57 gate_way57_cell15 GND ML57 p1 W=2.4e-6 L=1e-6
mnway57_cell16 ML57 gate_way57_cell16 GND GND n1 W=1e-6 L=1e-6
mpway57_cell16 ML57 gate_way57_cell16 GND ML57 p1 W=2.4e-6 L=1e-6
mnway57_cell17 ML57 gate_way57_cell17 GND GND n1 W=1e-6 L=1e-6
mpway57_cell17 ML57 gate_way57_cell17 GND ML57 p1 W=2.4e-6 L=1e-6
mnway57_cell18 ML57 gate_way57_cell18 GND GND n1 W=1e-6 L=1e-6
mpway57_cell18 ML57 gate_way57_cell18 GND ML57 p1 W=2.4e-6 L=1e-6
mnway57_cell19 ML57 gate_way57_cell19 GND GND n1 W=1e-6 L=1e-6
mpway57_cell19 ML57 gate_way57_cell19 GND ML57 p1 W=2.4e-6 L=1e-6
mnway57_cell20 ML57 gate_way57_cell20 GND GND n1 W=1e-6 L=1e-6
mpway57_cell20 ML57 gate_way57_cell20 GND ML57 p1 W=2.4e-6 L=1e-6
mnway57_cell21 ML57 gate_way57_cell21 GND GND n1 W=1e-6 L=1e-6
mpway57_cell21 ML57 gate_way57_cell21 GND ML57 p1 W=2.4e-6 L=1e-6
mnway57_cell22 ML57 gate_way57_cell22 GND GND n1 W=1e-6 L=1e-6
mpway57_cell22 ML57 gate_way57_cell22 GND ML57 p1 W=2.4e-6 L=1e-6
mnway57_cell23 ML57 gate_way57_cell23 GND GND n1 W=1e-6 L=1e-6
mpway57_cell23 ML57 gate_way57_cell23 GND ML57 p1 W=2.4e-6 L=1e-6
mnway57_cell24 ML57 gate_way57_cell24 GND GND n1 W=1e-6 L=1e-6
mpway57_cell24 ML57 gate_way57_cell24 GND ML57 p1 W=2.4e-6 L=1e-6
mnway57_cell25 ML57 gate_way57_cell25 GND GND n1 W=1e-6 L=1e-6
mpway57_cell25 ML57 gate_way57_cell25 GND ML57 p1 W=2.4e-6 L=1e-6
mnway57_cell26 ML57 gate_way57_cell26 GND GND n1 W=1e-6 L=1e-6
mpway57_cell26 ML57 gate_way57_cell26 GND ML57 p1 W=2.4e-6 L=1e-6
mnway57_cell27 ML57 gate_way57_cell27 GND GND n1 W=1e-6 L=1e-6
mpway57_cell27 ML57 gate_way57_cell27 GND ML57 p1 W=2.4e-6 L=1e-6
mnway57_cell28 ML57 gate_way57_cell28 GND GND n1 W=1e-6 L=1e-6
mpway57_cell28 ML57 gate_way57_cell28 GND ML57 p1 W=2.4e-6 L=1e-6
mnway57_cell29 ML57 gate_way57_cell29 GND GND n1 W=1e-6 L=1e-6
mpway57_cell29 ML57 gate_way57_cell29 GND ML57 p1 W=2.4e-6 L=1e-6
mnway57_cell30 ML57 gate_way57_cell30 GND GND n1 W=1e-6 L=1e-6
mpway57_cell30 ML57 gate_way57_cell30 GND ML57 p1 W=2.4e-6 L=1e-6
mnway57_cell31 ML57 gate_way57_cell31 GND GND n1 W=1e-6 L=1e-6
mpway57_cell31 ML57 gate_way57_cell31 GND ML57 p1 W=2.4e-6 L=1e-6
mnway57_cell32 ML57 gate_way57_cell32 GND GND n1 W=1e-6 L=1e-6
mpway57_cell32 ML57 gate_way57_cell32 GND ML57 p1 W=2.4e-6 L=1e-6
mnway57_cell33 ML57 gate_way57_cell33 GND GND n1 W=1e-6 L=1e-6
mpway57_cell33 ML57 gate_way57_cell33 GND ML57 p1 W=2.4e-6 L=1e-6
mnway57_cell34 ML57 gate_way57_cell34 GND GND n1 W=1e-6 L=1e-6
mpway57_cell34 ML57 gate_way57_cell34 GND ML57 p1 W=2.4e-6 L=1e-6
mnway57_cell35 ML57 gate_way57_cell35 GND GND n1 W=1e-6 L=1e-6
mpway57_cell35 ML57 gate_way57_cell35 GND ML57 p1 W=2.4e-6 L=1e-6
mnway57_cell36 ML57 gate_way57_cell36 GND GND n1 W=1e-6 L=1e-6
mpway57_cell36 ML57 gate_way57_cell36 GND ML57 p1 W=2.4e-6 L=1e-6
mnway57_cell37 ML57 gate_way57_cell37 GND GND n1 W=1e-6 L=1e-6
mpway57_cell37 ML57 gate_way57_cell37 GND ML57 p1 W=2.4e-6 L=1e-6
mnway57_cell38 ML57 gate_way57_cell38 GND GND n1 W=1e-6 L=1e-6
mpway57_cell38 ML57 gate_way57_cell38 GND ML57 p1 W=2.4e-6 L=1e-6
mnway57_cell39 ML57 gate_way57_cell39 GND GND n1 W=1e-6 L=1e-6
mpway57_cell39 ML57 gate_way57_cell39 GND ML57 p1 W=2.4e-6 L=1e-6
mnway57_cell40 ML57 gate_way57_cell40 GND GND n1 W=1e-6 L=1e-6
mpway57_cell40 ML57 gate_way57_cell40 GND ML57 p1 W=2.4e-6 L=1e-6
mnway57_cell41 ML57 gate_way57_cell41 GND GND n1 W=1e-6 L=1e-6
mpway57_cell41 ML57 gate_way57_cell41 GND ML57 p1 W=2.4e-6 L=1e-6
mnway57_cell42 ML57 gate_way57_cell42 GND GND n1 W=1e-6 L=1e-6
mpway57_cell42 ML57 gate_way57_cell42 GND ML57 p1 W=2.4e-6 L=1e-6
mnway57_cell43 ML57 gate_way57_cell43 GND GND n1 W=1e-6 L=1e-6
mpway57_cell43 ML57 gate_way57_cell43 GND ML57 p1 W=2.4e-6 L=1e-6
mnway57_cell44 ML57 gate_way57_cell44 GND GND n1 W=1e-6 L=1e-6
mpway57_cell44 ML57 gate_way57_cell44 GND ML57 p1 W=2.4e-6 L=1e-6
mnway57_cell45 ML57 gate_way57_cell45 GND GND n1 W=1e-6 L=1e-6
mpway57_cell45 ML57 gate_way57_cell45 GND ML57 p1 W=2.4e-6 L=1e-6
mnway57_cell46 ML57 gate_way57_cell46 GND GND n1 W=1e-6 L=1e-6
mpway57_cell46 ML57 gate_way57_cell46 GND ML57 p1 W=2.4e-6 L=1e-6
mnway57_cell47 ML57 gate_way57_cell47 GND GND n1 W=1e-6 L=1e-6
mpway57_cell47 ML57 gate_way57_cell47 GND ML57 p1 W=2.4e-6 L=1e-6
mnway57_cell48 ML57 gate_way57_cell48 GND GND n1 W=1e-6 L=1e-6
mpway57_cell48 ML57 gate_way57_cell48 GND ML57 p1 W=2.4e-6 L=1e-6
mnway57_cell49 ML57 gate_way57_cell49 GND GND n1 W=1e-6 L=1e-6
mpway57_cell49 ML57 gate_way57_cell49 GND ML57 p1 W=2.4e-6 L=1e-6
mnway57_cell50 ML57 gate_way57_cell50 GND GND n1 W=1e-6 L=1e-6
mpway57_cell50 ML57 gate_way57_cell50 GND ML57 p1 W=2.4e-6 L=1e-6
mnway57_cell51 ML57 gate_way57_cell51 GND GND n1 W=1e-6 L=1e-6
mpway57_cell51 ML57 gate_way57_cell51 GND ML57 p1 W=2.4e-6 L=1e-6
mnway57_cell52 ML57 gate_way57_cell52 GND GND n1 W=1e-6 L=1e-6
mpway57_cell52 ML57 gate_way57_cell52 GND ML57 p1 W=2.4e-6 L=1e-6
mnway57_cell53 ML57 gate_way57_cell53 GND GND n1 W=1e-6 L=1e-6
mpway57_cell53 ML57 gate_way57_cell53 GND ML57 p1 W=2.4e-6 L=1e-6
mnway57_cell54 ML57 gate_way57_cell54 GND GND n1 W=1e-6 L=1e-6
mpway57_cell54 ML57 gate_way57_cell54 GND ML57 p1 W=2.4e-6 L=1e-6
mnway57_cell55 ML57 gate_way57_cell55 GND GND n1 W=1e-6 L=1e-6
mpway57_cell55 ML57 gate_way57_cell55 GND ML57 p1 W=2.4e-6 L=1e-6
mnway57_cell56 ML57 gate_way57_cell56 GND GND n1 W=1e-6 L=1e-6
mpway57_cell56 ML57 gate_way57_cell56 GND ML57 p1 W=2.4e-6 L=1e-6
mnway57_cell57 ML57 gate_way57_cell57 GND GND n1 W=1e-6 L=1e-6
mpway57_cell57 ML57 gate_way57_cell57 GND ML57 p1 W=2.4e-6 L=1e-6
mnway57_cell58 ML57 gate_way57_cell58 GND GND n1 W=1e-6 L=1e-6
mpway57_cell58 ML57 gate_way57_cell58 GND ML57 p1 W=2.4e-6 L=1e-6
mnway57_cell59 ML57 gate_way57_cell59 GND GND n1 W=1e-6 L=1e-6
mpway57_cell59 ML57 gate_way57_cell59 GND ML57 p1 W=2.4e-6 L=1e-6
mnway57_cell60 ML57 gate_way57_cell60 GND GND n1 W=1e-6 L=1e-6
mpway57_cell60 ML57 gate_way57_cell60 GND ML57 p1 W=2.4e-6 L=1e-6
mnway57_cell61 ML57 gate_way57_cell61 GND GND n1 W=1e-6 L=1e-6
mpway57_cell61 ML57 gate_way57_cell61 GND ML57 p1 W=2.4e-6 L=1e-6
mnway57_cell62 ML57 gate_way57_cell62 GND GND n1 W=1e-6 L=1e-6
mpway57_cell62 ML57 gate_way57_cell62 GND ML57 p1 W=2.4e-6 L=1e-6
mnway57_cell63 ML57 gate_way57_cell63 GND GND n1 W=1e-6 L=1e-6
mpway57_cell63 ML57 gate_way57_cell63 GND ML57 p1 W=2.4e-6 L=1e-6
mnway57_cell64 ML57 gate_way57_cell64 GND GND n1 W=1e-6 L=1e-6
mpway57_cell64 ML57 gate_way57_cell64 GND ML57 p1 W=2.4e-6 L=1e-6
mnway57_cell65 ML57 gate_way57_cell65 GND GND n1 W=1e-6 L=1e-6
mpway57_cell65 ML57 gate_way57_cell65 GND ML57 p1 W=2.4e-6 L=1e-6
mnway57_cell66 ML57 gate_way57_cell66 GND GND n1 W=1e-6 L=1e-6
mpway57_cell66 ML57 gate_way57_cell66 GND ML57 p1 W=2.4e-6 L=1e-6
mnway57_cell67 ML57 gate_way57_cell67 GND GND n1 W=1e-6 L=1e-6
mpway57_cell67 ML57 gate_way57_cell67 GND ML57 p1 W=2.4e-6 L=1e-6
mnway57_cell68 ML57 gate_way57_cell68 GND GND n1 W=1e-6 L=1e-6
mpway57_cell68 ML57 gate_way57_cell68 GND ML57 p1 W=2.4e-6 L=1e-6
mnway57_cell69 ML57 gate_way57_cell69 GND GND n1 W=1e-6 L=1e-6
mpway57_cell69 ML57 gate_way57_cell69 GND ML57 p1 W=2.4e-6 L=1e-6
mnway57_cell70 ML57 gate_way57_cell70 GND GND n1 W=1e-6 L=1e-6
mpway57_cell70 ML57 gate_way57_cell70 GND ML57 p1 W=2.4e-6 L=1e-6
mnway57_cell71 ML57 gate_way57_cell71 GND GND n1 W=1e-6 L=1e-6
mpway57_cell71 ML57 gate_way57_cell71 GND ML57 p1 W=2.4e-6 L=1e-6
mnway57_cell72 ML57 gate_way57_cell72 GND GND n1 W=1e-6 L=1e-6
mpway57_cell72 ML57 gate_way57_cell72 GND ML57 p1 W=2.4e-6 L=1e-6
mnway57_cell73 ML57 gate_way57_cell73 GND GND n1 W=1e-6 L=1e-6
mpway57_cell73 ML57 gate_way57_cell73 GND ML57 p1 W=2.4e-6 L=1e-6
mnway57_cell74 ML57 gate_way57_cell74 GND GND n1 W=1e-6 L=1e-6
mpway57_cell74 ML57 gate_way57_cell74 GND ML57 p1 W=2.4e-6 L=1e-6
mnway57_cell75 ML57 gate_way57_cell75 GND GND n1 W=1e-6 L=1e-6
mpway57_cell75 ML57 gate_way57_cell75 GND ML57 p1 W=2.4e-6 L=1e-6
mnway57_cell76 ML57 gate_way57_cell76 GND GND n1 W=1e-6 L=1e-6
mpway57_cell76 ML57 gate_way57_cell76 GND ML57 p1 W=2.4e-6 L=1e-6
mnway57_cell77 ML57 gate_way57_cell77 GND GND n1 W=1e-6 L=1e-6
mpway57_cell77 ML57 gate_way57_cell77 GND ML57 p1 W=2.4e-6 L=1e-6
mnway57_cell78 ML57 gate_way57_cell78 GND GND n1 W=1e-6 L=1e-6
mpway57_cell78 ML57 gate_way57_cell78 GND ML57 p1 W=2.4e-6 L=1e-6
mnway57_cell79 ML57 gate_way57_cell79 GND GND n1 W=1e-6 L=1e-6
mpway57_cell79 ML57 gate_way57_cell79 GND ML57 p1 W=2.4e-6 L=1e-6
mnway57_cell80 ML57 gate_way57_cell80 GND GND n1 W=1e-6 L=1e-6
mpway57_cell80 ML57 gate_way57_cell80 GND ML57 p1 W=2.4e-6 L=1e-6
mnway57_cell81 ML57 gate_way57_cell81 GND GND n1 W=1e-6 L=1e-6
mpway57_cell81 ML57 gate_way57_cell81 GND ML57 p1 W=2.4e-6 L=1e-6
mnway57_cell82 ML57 gate_way57_cell82 GND GND n1 W=1e-6 L=1e-6
mpway57_cell82 ML57 gate_way57_cell82 GND ML57 p1 W=2.4e-6 L=1e-6
mnway57_cell83 ML57 gate_way57_cell83 GND GND n1 W=1e-6 L=1e-6
mpway57_cell83 ML57 gate_way57_cell83 GND ML57 p1 W=2.4e-6 L=1e-6
mnway57_cell84 ML57 gate_way57_cell84 GND GND n1 W=1e-6 L=1e-6
mpway57_cell84 ML57 gate_way57_cell84 GND ML57 p1 W=2.4e-6 L=1e-6
mnway57_cell85 ML57 gate_way57_cell85 GND GND n1 W=1e-6 L=1e-6
mpway57_cell85 ML57 gate_way57_cell85 GND ML57 p1 W=2.4e-6 L=1e-6
mnway57_cell86 ML57 gate_way57_cell86 GND GND n1 W=1e-6 L=1e-6
mpway57_cell86 ML57 gate_way57_cell86 GND ML57 p1 W=2.4e-6 L=1e-6
mnway57_cell87 ML57 gate_way57_cell87 GND GND n1 W=1e-6 L=1e-6
mpway57_cell87 ML57 gate_way57_cell87 GND ML57 p1 W=2.4e-6 L=1e-6
mnway57_cell88 ML57 gate_way57_cell88 GND GND n1 W=1e-6 L=1e-6
mpway57_cell88 ML57 gate_way57_cell88 GND ML57 p1 W=2.4e-6 L=1e-6
mnway57_cell89 ML57 gate_way57_cell89 GND GND n1 W=1e-6 L=1e-6
mpway57_cell89 ML57 gate_way57_cell89 GND ML57 p1 W=2.4e-6 L=1e-6
mnway57_cell90 ML57 gate_way57_cell90 GND GND n1 W=1e-6 L=1e-6
mpway57_cell90 ML57 gate_way57_cell90 GND ML57 p1 W=2.4e-6 L=1e-6
mnway57_cell91 ML57 gate_way57_cell91 GND GND n1 W=1e-6 L=1e-6
mpway57_cell91 ML57 gate_way57_cell91 GND ML57 p1 W=2.4e-6 L=1e-6
mnway57_cell92 ML57 gate_way57_cell92 GND GND n1 W=1e-6 L=1e-6
mpway57_cell92 ML57 gate_way57_cell92 GND ML57 p1 W=2.4e-6 L=1e-6
mnway57_cell93 ML57 gate_way57_cell93 GND GND n1 W=1e-6 L=1e-6
mpway57_cell93 ML57 gate_way57_cell93 GND ML57 p1 W=2.4e-6 L=1e-6
mnway57_cell94 ML57 gate_way57_cell94 GND GND n1 W=1e-6 L=1e-6
mpway57_cell94 ML57 gate_way57_cell94 GND ML57 p1 W=2.4e-6 L=1e-6
mnway57_cell95 ML57 gate_way57_cell95 GND GND n1 W=1e-6 L=1e-6
mpway57_cell95 ML57 gate_way57_cell95 GND ML57 p1 W=2.4e-6 L=1e-6
mnway57_cell96 ML57 gate_way57_cell96 GND GND n1 W=1e-6 L=1e-6
mpway57_cell96 ML57 gate_way57_cell96 GND ML57 p1 W=2.4e-6 L=1e-6
mnway57_cell97 ML57 gate_way57_cell97 GND GND n1 W=1e-6 L=1e-6
mpway57_cell97 ML57 gate_way57_cell97 GND ML57 p1 W=2.4e-6 L=1e-6
mnway57_cell98 ML57 gate_way57_cell98 GND GND n1 W=1e-6 L=1e-6
mpway57_cell98 ML57 gate_way57_cell98 GND ML57 p1 W=2.4e-6 L=1e-6
mnway57_cell99 ML57 gate_way57_cell99 GND GND n1 W=1e-6 L=1e-6
mpway57_cell99 ML57 gate_way57_cell99 GND ML57 p1 W=2.4e-6 L=1e-6
mnway58_cell0 ML58 gate_way58_cell0 GND GND n1 W=1e-6 L=1e-6
mpway58_cell0 ML58 gate_way58_cell0 GND ML58 p1 W=2.4e-6 L=1e-6
mnway58_cell1 ML58 gate_way58_cell1 GND GND n1 W=1e-6 L=1e-6
mpway58_cell1 ML58 gate_way58_cell1 GND ML58 p1 W=2.4e-6 L=1e-6
mnway58_cell2 ML58 gate_way58_cell2 GND GND n1 W=1e-6 L=1e-6
mpway58_cell2 ML58 gate_way58_cell2 GND ML58 p1 W=2.4e-6 L=1e-6
mnway58_cell3 ML58 gate_way58_cell3 GND GND n1 W=1e-6 L=1e-6
mpway58_cell3 ML58 gate_way58_cell3 GND ML58 p1 W=2.4e-6 L=1e-6
mnway58_cell4 ML58 gate_way58_cell4 GND GND n1 W=1e-6 L=1e-6
mpway58_cell4 ML58 gate_way58_cell4 GND ML58 p1 W=2.4e-6 L=1e-6
mnway58_cell5 ML58 gate_way58_cell5 GND GND n1 W=1e-6 L=1e-6
mpway58_cell5 ML58 gate_way58_cell5 GND ML58 p1 W=2.4e-6 L=1e-6
mnway58_cell6 ML58 gate_way58_cell6 GND GND n1 W=1e-6 L=1e-6
mpway58_cell6 ML58 gate_way58_cell6 GND ML58 p1 W=2.4e-6 L=1e-6
mnway58_cell7 ML58 gate_way58_cell7 GND GND n1 W=1e-6 L=1e-6
mpway58_cell7 ML58 gate_way58_cell7 GND ML58 p1 W=2.4e-6 L=1e-6
mnway58_cell8 ML58 gate_way58_cell8 GND GND n1 W=1e-6 L=1e-6
mpway58_cell8 ML58 gate_way58_cell8 GND ML58 p1 W=2.4e-6 L=1e-6
mnway58_cell9 ML58 gate_way58_cell9 GND GND n1 W=1e-6 L=1e-6
mpway58_cell9 ML58 gate_way58_cell9 GND ML58 p1 W=2.4e-6 L=1e-6
mnway58_cell10 ML58 gate_way58_cell10 GND GND n1 W=1e-6 L=1e-6
mpway58_cell10 ML58 gate_way58_cell10 GND ML58 p1 W=2.4e-6 L=1e-6
mnway58_cell11 ML58 gate_way58_cell11 GND GND n1 W=1e-6 L=1e-6
mpway58_cell11 ML58 gate_way58_cell11 GND ML58 p1 W=2.4e-6 L=1e-6
mnway58_cell12 ML58 gate_way58_cell12 GND GND n1 W=1e-6 L=1e-6
mpway58_cell12 ML58 gate_way58_cell12 GND ML58 p1 W=2.4e-6 L=1e-6
mnway58_cell13 ML58 gate_way58_cell13 GND GND n1 W=1e-6 L=1e-6
mpway58_cell13 ML58 gate_way58_cell13 GND ML58 p1 W=2.4e-6 L=1e-6
mnway58_cell14 ML58 gate_way58_cell14 GND GND n1 W=1e-6 L=1e-6
mpway58_cell14 ML58 gate_way58_cell14 GND ML58 p1 W=2.4e-6 L=1e-6
mnway58_cell15 ML58 gate_way58_cell15 GND GND n1 W=1e-6 L=1e-6
mpway58_cell15 ML58 gate_way58_cell15 GND ML58 p1 W=2.4e-6 L=1e-6
mnway58_cell16 ML58 gate_way58_cell16 GND GND n1 W=1e-6 L=1e-6
mpway58_cell16 ML58 gate_way58_cell16 GND ML58 p1 W=2.4e-6 L=1e-6
mnway58_cell17 ML58 gate_way58_cell17 GND GND n1 W=1e-6 L=1e-6
mpway58_cell17 ML58 gate_way58_cell17 GND ML58 p1 W=2.4e-6 L=1e-6
mnway58_cell18 ML58 gate_way58_cell18 GND GND n1 W=1e-6 L=1e-6
mpway58_cell18 ML58 gate_way58_cell18 GND ML58 p1 W=2.4e-6 L=1e-6
mnway58_cell19 ML58 gate_way58_cell19 GND GND n1 W=1e-6 L=1e-6
mpway58_cell19 ML58 gate_way58_cell19 GND ML58 p1 W=2.4e-6 L=1e-6
mnway58_cell20 ML58 gate_way58_cell20 GND GND n1 W=1e-6 L=1e-6
mpway58_cell20 ML58 gate_way58_cell20 GND ML58 p1 W=2.4e-6 L=1e-6
mnway58_cell21 ML58 gate_way58_cell21 GND GND n1 W=1e-6 L=1e-6
mpway58_cell21 ML58 gate_way58_cell21 GND ML58 p1 W=2.4e-6 L=1e-6
mnway58_cell22 ML58 gate_way58_cell22 GND GND n1 W=1e-6 L=1e-6
mpway58_cell22 ML58 gate_way58_cell22 GND ML58 p1 W=2.4e-6 L=1e-6
mnway58_cell23 ML58 gate_way58_cell23 GND GND n1 W=1e-6 L=1e-6
mpway58_cell23 ML58 gate_way58_cell23 GND ML58 p1 W=2.4e-6 L=1e-6
mnway58_cell24 ML58 gate_way58_cell24 GND GND n1 W=1e-6 L=1e-6
mpway58_cell24 ML58 gate_way58_cell24 GND ML58 p1 W=2.4e-6 L=1e-6
mnway58_cell25 ML58 gate_way58_cell25 GND GND n1 W=1e-6 L=1e-6
mpway58_cell25 ML58 gate_way58_cell25 GND ML58 p1 W=2.4e-6 L=1e-6
mnway58_cell26 ML58 gate_way58_cell26 GND GND n1 W=1e-6 L=1e-6
mpway58_cell26 ML58 gate_way58_cell26 GND ML58 p1 W=2.4e-6 L=1e-6
mnway58_cell27 ML58 gate_way58_cell27 GND GND n1 W=1e-6 L=1e-6
mpway58_cell27 ML58 gate_way58_cell27 GND ML58 p1 W=2.4e-6 L=1e-6
mnway58_cell28 ML58 gate_way58_cell28 GND GND n1 W=1e-6 L=1e-6
mpway58_cell28 ML58 gate_way58_cell28 GND ML58 p1 W=2.4e-6 L=1e-6
mnway58_cell29 ML58 gate_way58_cell29 GND GND n1 W=1e-6 L=1e-6
mpway58_cell29 ML58 gate_way58_cell29 GND ML58 p1 W=2.4e-6 L=1e-6
mnway58_cell30 ML58 gate_way58_cell30 GND GND n1 W=1e-6 L=1e-6
mpway58_cell30 ML58 gate_way58_cell30 GND ML58 p1 W=2.4e-6 L=1e-6
mnway58_cell31 ML58 gate_way58_cell31 GND GND n1 W=1e-6 L=1e-6
mpway58_cell31 ML58 gate_way58_cell31 GND ML58 p1 W=2.4e-6 L=1e-6
mnway58_cell32 ML58 gate_way58_cell32 GND GND n1 W=1e-6 L=1e-6
mpway58_cell32 ML58 gate_way58_cell32 GND ML58 p1 W=2.4e-6 L=1e-6
mnway58_cell33 ML58 gate_way58_cell33 GND GND n1 W=1e-6 L=1e-6
mpway58_cell33 ML58 gate_way58_cell33 GND ML58 p1 W=2.4e-6 L=1e-6
mnway58_cell34 ML58 gate_way58_cell34 GND GND n1 W=1e-6 L=1e-6
mpway58_cell34 ML58 gate_way58_cell34 GND ML58 p1 W=2.4e-6 L=1e-6
mnway58_cell35 ML58 gate_way58_cell35 GND GND n1 W=1e-6 L=1e-6
mpway58_cell35 ML58 gate_way58_cell35 GND ML58 p1 W=2.4e-6 L=1e-6
mnway58_cell36 ML58 gate_way58_cell36 GND GND n1 W=1e-6 L=1e-6
mpway58_cell36 ML58 gate_way58_cell36 GND ML58 p1 W=2.4e-6 L=1e-6
mnway58_cell37 ML58 gate_way58_cell37 GND GND n1 W=1e-6 L=1e-6
mpway58_cell37 ML58 gate_way58_cell37 GND ML58 p1 W=2.4e-6 L=1e-6
mnway58_cell38 ML58 gate_way58_cell38 GND GND n1 W=1e-6 L=1e-6
mpway58_cell38 ML58 gate_way58_cell38 GND ML58 p1 W=2.4e-6 L=1e-6
mnway58_cell39 ML58 gate_way58_cell39 GND GND n1 W=1e-6 L=1e-6
mpway58_cell39 ML58 gate_way58_cell39 GND ML58 p1 W=2.4e-6 L=1e-6
mnway58_cell40 ML58 gate_way58_cell40 GND GND n1 W=1e-6 L=1e-6
mpway58_cell40 ML58 gate_way58_cell40 GND ML58 p1 W=2.4e-6 L=1e-6
mnway58_cell41 ML58 gate_way58_cell41 GND GND n1 W=1e-6 L=1e-6
mpway58_cell41 ML58 gate_way58_cell41 GND ML58 p1 W=2.4e-6 L=1e-6
mnway58_cell42 ML58 gate_way58_cell42 GND GND n1 W=1e-6 L=1e-6
mpway58_cell42 ML58 gate_way58_cell42 GND ML58 p1 W=2.4e-6 L=1e-6
mnway58_cell43 ML58 gate_way58_cell43 GND GND n1 W=1e-6 L=1e-6
mpway58_cell43 ML58 gate_way58_cell43 GND ML58 p1 W=2.4e-6 L=1e-6
mnway58_cell44 ML58 gate_way58_cell44 GND GND n1 W=1e-6 L=1e-6
mpway58_cell44 ML58 gate_way58_cell44 GND ML58 p1 W=2.4e-6 L=1e-6
mnway58_cell45 ML58 gate_way58_cell45 GND GND n1 W=1e-6 L=1e-6
mpway58_cell45 ML58 gate_way58_cell45 GND ML58 p1 W=2.4e-6 L=1e-6
mnway58_cell46 ML58 gate_way58_cell46 GND GND n1 W=1e-6 L=1e-6
mpway58_cell46 ML58 gate_way58_cell46 GND ML58 p1 W=2.4e-6 L=1e-6
mnway58_cell47 ML58 gate_way58_cell47 GND GND n1 W=1e-6 L=1e-6
mpway58_cell47 ML58 gate_way58_cell47 GND ML58 p1 W=2.4e-6 L=1e-6
mnway58_cell48 ML58 gate_way58_cell48 GND GND n1 W=1e-6 L=1e-6
mpway58_cell48 ML58 gate_way58_cell48 GND ML58 p1 W=2.4e-6 L=1e-6
mnway58_cell49 ML58 gate_way58_cell49 GND GND n1 W=1e-6 L=1e-6
mpway58_cell49 ML58 gate_way58_cell49 GND ML58 p1 W=2.4e-6 L=1e-6
mnway58_cell50 ML58 gate_way58_cell50 GND GND n1 W=1e-6 L=1e-6
mpway58_cell50 ML58 gate_way58_cell50 GND ML58 p1 W=2.4e-6 L=1e-6
mnway58_cell51 ML58 gate_way58_cell51 GND GND n1 W=1e-6 L=1e-6
mpway58_cell51 ML58 gate_way58_cell51 GND ML58 p1 W=2.4e-6 L=1e-6
mnway58_cell52 ML58 gate_way58_cell52 GND GND n1 W=1e-6 L=1e-6
mpway58_cell52 ML58 gate_way58_cell52 GND ML58 p1 W=2.4e-6 L=1e-6
mnway58_cell53 ML58 gate_way58_cell53 GND GND n1 W=1e-6 L=1e-6
mpway58_cell53 ML58 gate_way58_cell53 GND ML58 p1 W=2.4e-6 L=1e-6
mnway58_cell54 ML58 gate_way58_cell54 GND GND n1 W=1e-6 L=1e-6
mpway58_cell54 ML58 gate_way58_cell54 GND ML58 p1 W=2.4e-6 L=1e-6
mnway58_cell55 ML58 gate_way58_cell55 GND GND n1 W=1e-6 L=1e-6
mpway58_cell55 ML58 gate_way58_cell55 GND ML58 p1 W=2.4e-6 L=1e-6
mnway58_cell56 ML58 gate_way58_cell56 GND GND n1 W=1e-6 L=1e-6
mpway58_cell56 ML58 gate_way58_cell56 GND ML58 p1 W=2.4e-6 L=1e-6
mnway58_cell57 ML58 gate_way58_cell57 GND GND n1 W=1e-6 L=1e-6
mpway58_cell57 ML58 gate_way58_cell57 GND ML58 p1 W=2.4e-6 L=1e-6
mnway58_cell58 ML58 gate_way58_cell58 GND GND n1 W=1e-6 L=1e-6
mpway58_cell58 ML58 gate_way58_cell58 GND ML58 p1 W=2.4e-6 L=1e-6
mnway58_cell59 ML58 gate_way58_cell59 GND GND n1 W=1e-6 L=1e-6
mpway58_cell59 ML58 gate_way58_cell59 GND ML58 p1 W=2.4e-6 L=1e-6
mnway58_cell60 ML58 gate_way58_cell60 GND GND n1 W=1e-6 L=1e-6
mpway58_cell60 ML58 gate_way58_cell60 GND ML58 p1 W=2.4e-6 L=1e-6
mnway58_cell61 ML58 gate_way58_cell61 GND GND n1 W=1e-6 L=1e-6
mpway58_cell61 ML58 gate_way58_cell61 GND ML58 p1 W=2.4e-6 L=1e-6
mnway58_cell62 ML58 gate_way58_cell62 GND GND n1 W=1e-6 L=1e-6
mpway58_cell62 ML58 gate_way58_cell62 GND ML58 p1 W=2.4e-6 L=1e-6
mnway58_cell63 ML58 gate_way58_cell63 GND GND n1 W=1e-6 L=1e-6
mpway58_cell63 ML58 gate_way58_cell63 GND ML58 p1 W=2.4e-6 L=1e-6
mnway58_cell64 ML58 gate_way58_cell64 GND GND n1 W=1e-6 L=1e-6
mpway58_cell64 ML58 gate_way58_cell64 GND ML58 p1 W=2.4e-6 L=1e-6
mnway58_cell65 ML58 gate_way58_cell65 GND GND n1 W=1e-6 L=1e-6
mpway58_cell65 ML58 gate_way58_cell65 GND ML58 p1 W=2.4e-6 L=1e-6
mnway58_cell66 ML58 gate_way58_cell66 GND GND n1 W=1e-6 L=1e-6
mpway58_cell66 ML58 gate_way58_cell66 GND ML58 p1 W=2.4e-6 L=1e-6
mnway58_cell67 ML58 gate_way58_cell67 GND GND n1 W=1e-6 L=1e-6
mpway58_cell67 ML58 gate_way58_cell67 GND ML58 p1 W=2.4e-6 L=1e-6
mnway58_cell68 ML58 gate_way58_cell68 GND GND n1 W=1e-6 L=1e-6
mpway58_cell68 ML58 gate_way58_cell68 GND ML58 p1 W=2.4e-6 L=1e-6
mnway58_cell69 ML58 gate_way58_cell69 GND GND n1 W=1e-6 L=1e-6
mpway58_cell69 ML58 gate_way58_cell69 GND ML58 p1 W=2.4e-6 L=1e-6
mnway58_cell70 ML58 gate_way58_cell70 GND GND n1 W=1e-6 L=1e-6
mpway58_cell70 ML58 gate_way58_cell70 GND ML58 p1 W=2.4e-6 L=1e-6
mnway58_cell71 ML58 gate_way58_cell71 GND GND n1 W=1e-6 L=1e-6
mpway58_cell71 ML58 gate_way58_cell71 GND ML58 p1 W=2.4e-6 L=1e-6
mnway58_cell72 ML58 gate_way58_cell72 GND GND n1 W=1e-6 L=1e-6
mpway58_cell72 ML58 gate_way58_cell72 GND ML58 p1 W=2.4e-6 L=1e-6
mnway58_cell73 ML58 gate_way58_cell73 GND GND n1 W=1e-6 L=1e-6
mpway58_cell73 ML58 gate_way58_cell73 GND ML58 p1 W=2.4e-6 L=1e-6
mnway58_cell74 ML58 gate_way58_cell74 GND GND n1 W=1e-6 L=1e-6
mpway58_cell74 ML58 gate_way58_cell74 GND ML58 p1 W=2.4e-6 L=1e-6
mnway58_cell75 ML58 gate_way58_cell75 GND GND n1 W=1e-6 L=1e-6
mpway58_cell75 ML58 gate_way58_cell75 GND ML58 p1 W=2.4e-6 L=1e-6
mnway58_cell76 ML58 gate_way58_cell76 GND GND n1 W=1e-6 L=1e-6
mpway58_cell76 ML58 gate_way58_cell76 GND ML58 p1 W=2.4e-6 L=1e-6
mnway58_cell77 ML58 gate_way58_cell77 GND GND n1 W=1e-6 L=1e-6
mpway58_cell77 ML58 gate_way58_cell77 GND ML58 p1 W=2.4e-6 L=1e-6
mnway58_cell78 ML58 gate_way58_cell78 GND GND n1 W=1e-6 L=1e-6
mpway58_cell78 ML58 gate_way58_cell78 GND ML58 p1 W=2.4e-6 L=1e-6
mnway58_cell79 ML58 gate_way58_cell79 GND GND n1 W=1e-6 L=1e-6
mpway58_cell79 ML58 gate_way58_cell79 GND ML58 p1 W=2.4e-6 L=1e-6
mnway58_cell80 ML58 gate_way58_cell80 GND GND n1 W=1e-6 L=1e-6
mpway58_cell80 ML58 gate_way58_cell80 GND ML58 p1 W=2.4e-6 L=1e-6
mnway58_cell81 ML58 gate_way58_cell81 GND GND n1 W=1e-6 L=1e-6
mpway58_cell81 ML58 gate_way58_cell81 GND ML58 p1 W=2.4e-6 L=1e-6
mnway58_cell82 ML58 gate_way58_cell82 GND GND n1 W=1e-6 L=1e-6
mpway58_cell82 ML58 gate_way58_cell82 GND ML58 p1 W=2.4e-6 L=1e-6
mnway58_cell83 ML58 gate_way58_cell83 GND GND n1 W=1e-6 L=1e-6
mpway58_cell83 ML58 gate_way58_cell83 GND ML58 p1 W=2.4e-6 L=1e-6
mnway58_cell84 ML58 gate_way58_cell84 GND GND n1 W=1e-6 L=1e-6
mpway58_cell84 ML58 gate_way58_cell84 GND ML58 p1 W=2.4e-6 L=1e-6
mnway58_cell85 ML58 gate_way58_cell85 GND GND n1 W=1e-6 L=1e-6
mpway58_cell85 ML58 gate_way58_cell85 GND ML58 p1 W=2.4e-6 L=1e-6
mnway58_cell86 ML58 gate_way58_cell86 GND GND n1 W=1e-6 L=1e-6
mpway58_cell86 ML58 gate_way58_cell86 GND ML58 p1 W=2.4e-6 L=1e-6
mnway58_cell87 ML58 gate_way58_cell87 GND GND n1 W=1e-6 L=1e-6
mpway58_cell87 ML58 gate_way58_cell87 GND ML58 p1 W=2.4e-6 L=1e-6
mnway58_cell88 ML58 gate_way58_cell88 GND GND n1 W=1e-6 L=1e-6
mpway58_cell88 ML58 gate_way58_cell88 GND ML58 p1 W=2.4e-6 L=1e-6
mnway58_cell89 ML58 gate_way58_cell89 GND GND n1 W=1e-6 L=1e-6
mpway58_cell89 ML58 gate_way58_cell89 GND ML58 p1 W=2.4e-6 L=1e-6
mnway58_cell90 ML58 gate_way58_cell90 GND GND n1 W=1e-6 L=1e-6
mpway58_cell90 ML58 gate_way58_cell90 GND ML58 p1 W=2.4e-6 L=1e-6
mnway58_cell91 ML58 gate_way58_cell91 GND GND n1 W=1e-6 L=1e-6
mpway58_cell91 ML58 gate_way58_cell91 GND ML58 p1 W=2.4e-6 L=1e-6
mnway58_cell92 ML58 gate_way58_cell92 GND GND n1 W=1e-6 L=1e-6
mpway58_cell92 ML58 gate_way58_cell92 GND ML58 p1 W=2.4e-6 L=1e-6
mnway58_cell93 ML58 gate_way58_cell93 GND GND n1 W=1e-6 L=1e-6
mpway58_cell93 ML58 gate_way58_cell93 GND ML58 p1 W=2.4e-6 L=1e-6
mnway58_cell94 ML58 gate_way58_cell94 GND GND n1 W=1e-6 L=1e-6
mpway58_cell94 ML58 gate_way58_cell94 GND ML58 p1 W=2.4e-6 L=1e-6
mnway58_cell95 ML58 gate_way58_cell95 GND GND n1 W=1e-6 L=1e-6
mpway58_cell95 ML58 gate_way58_cell95 GND ML58 p1 W=2.4e-6 L=1e-6
mnway58_cell96 ML58 gate_way58_cell96 GND GND n1 W=1e-6 L=1e-6
mpway58_cell96 ML58 gate_way58_cell96 GND ML58 p1 W=2.4e-6 L=1e-6
mnway58_cell97 ML58 gate_way58_cell97 GND GND n1 W=1e-6 L=1e-6
mpway58_cell97 ML58 gate_way58_cell97 GND ML58 p1 W=2.4e-6 L=1e-6
mnway58_cell98 ML58 gate_way58_cell98 GND GND n1 W=1e-6 L=1e-6
mpway58_cell98 ML58 gate_way58_cell98 GND ML58 p1 W=2.4e-6 L=1e-6
mnway58_cell99 ML58 gate_way58_cell99 GND GND n1 W=1e-6 L=1e-6
mpway58_cell99 ML58 gate_way58_cell99 GND ML58 p1 W=2.4e-6 L=1e-6
mnway59_cell0 ML59 gate_way59_cell0 GND GND n1 W=1e-6 L=1e-6
mpway59_cell0 ML59 gate_way59_cell0 GND ML59 p1 W=2.4e-6 L=1e-6
mnway59_cell1 ML59 gate_way59_cell1 GND GND n1 W=1e-6 L=1e-6
mpway59_cell1 ML59 gate_way59_cell1 GND ML59 p1 W=2.4e-6 L=1e-6
mnway59_cell2 ML59 gate_way59_cell2 GND GND n1 W=1e-6 L=1e-6
mpway59_cell2 ML59 gate_way59_cell2 GND ML59 p1 W=2.4e-6 L=1e-6
mnway59_cell3 ML59 gate_way59_cell3 GND GND n1 W=1e-6 L=1e-6
mpway59_cell3 ML59 gate_way59_cell3 GND ML59 p1 W=2.4e-6 L=1e-6
mnway59_cell4 ML59 gate_way59_cell4 GND GND n1 W=1e-6 L=1e-6
mpway59_cell4 ML59 gate_way59_cell4 GND ML59 p1 W=2.4e-6 L=1e-6
mnway59_cell5 ML59 gate_way59_cell5 GND GND n1 W=1e-6 L=1e-6
mpway59_cell5 ML59 gate_way59_cell5 GND ML59 p1 W=2.4e-6 L=1e-6
mnway59_cell6 ML59 gate_way59_cell6 GND GND n1 W=1e-6 L=1e-6
mpway59_cell6 ML59 gate_way59_cell6 GND ML59 p1 W=2.4e-6 L=1e-6
mnway59_cell7 ML59 gate_way59_cell7 GND GND n1 W=1e-6 L=1e-6
mpway59_cell7 ML59 gate_way59_cell7 GND ML59 p1 W=2.4e-6 L=1e-6
mnway59_cell8 ML59 gate_way59_cell8 GND GND n1 W=1e-6 L=1e-6
mpway59_cell8 ML59 gate_way59_cell8 GND ML59 p1 W=2.4e-6 L=1e-6
mnway59_cell9 ML59 gate_way59_cell9 GND GND n1 W=1e-6 L=1e-6
mpway59_cell9 ML59 gate_way59_cell9 GND ML59 p1 W=2.4e-6 L=1e-6
mnway59_cell10 ML59 gate_way59_cell10 GND GND n1 W=1e-6 L=1e-6
mpway59_cell10 ML59 gate_way59_cell10 GND ML59 p1 W=2.4e-6 L=1e-6
mnway59_cell11 ML59 gate_way59_cell11 GND GND n1 W=1e-6 L=1e-6
mpway59_cell11 ML59 gate_way59_cell11 GND ML59 p1 W=2.4e-6 L=1e-6
mnway59_cell12 ML59 gate_way59_cell12 GND GND n1 W=1e-6 L=1e-6
mpway59_cell12 ML59 gate_way59_cell12 GND ML59 p1 W=2.4e-6 L=1e-6
mnway59_cell13 ML59 gate_way59_cell13 GND GND n1 W=1e-6 L=1e-6
mpway59_cell13 ML59 gate_way59_cell13 GND ML59 p1 W=2.4e-6 L=1e-6
mnway59_cell14 ML59 gate_way59_cell14 GND GND n1 W=1e-6 L=1e-6
mpway59_cell14 ML59 gate_way59_cell14 GND ML59 p1 W=2.4e-6 L=1e-6
mnway59_cell15 ML59 gate_way59_cell15 GND GND n1 W=1e-6 L=1e-6
mpway59_cell15 ML59 gate_way59_cell15 GND ML59 p1 W=2.4e-6 L=1e-6
mnway59_cell16 ML59 gate_way59_cell16 GND GND n1 W=1e-6 L=1e-6
mpway59_cell16 ML59 gate_way59_cell16 GND ML59 p1 W=2.4e-6 L=1e-6
mnway59_cell17 ML59 gate_way59_cell17 GND GND n1 W=1e-6 L=1e-6
mpway59_cell17 ML59 gate_way59_cell17 GND ML59 p1 W=2.4e-6 L=1e-6
mnway59_cell18 ML59 gate_way59_cell18 GND GND n1 W=1e-6 L=1e-6
mpway59_cell18 ML59 gate_way59_cell18 GND ML59 p1 W=2.4e-6 L=1e-6
mnway59_cell19 ML59 gate_way59_cell19 GND GND n1 W=1e-6 L=1e-6
mpway59_cell19 ML59 gate_way59_cell19 GND ML59 p1 W=2.4e-6 L=1e-6
mnway59_cell20 ML59 gate_way59_cell20 GND GND n1 W=1e-6 L=1e-6
mpway59_cell20 ML59 gate_way59_cell20 GND ML59 p1 W=2.4e-6 L=1e-6
mnway59_cell21 ML59 gate_way59_cell21 GND GND n1 W=1e-6 L=1e-6
mpway59_cell21 ML59 gate_way59_cell21 GND ML59 p1 W=2.4e-6 L=1e-6
mnway59_cell22 ML59 gate_way59_cell22 GND GND n1 W=1e-6 L=1e-6
mpway59_cell22 ML59 gate_way59_cell22 GND ML59 p1 W=2.4e-6 L=1e-6
mnway59_cell23 ML59 gate_way59_cell23 GND GND n1 W=1e-6 L=1e-6
mpway59_cell23 ML59 gate_way59_cell23 GND ML59 p1 W=2.4e-6 L=1e-6
mnway59_cell24 ML59 gate_way59_cell24 GND GND n1 W=1e-6 L=1e-6
mpway59_cell24 ML59 gate_way59_cell24 GND ML59 p1 W=2.4e-6 L=1e-6
mnway59_cell25 ML59 gate_way59_cell25 GND GND n1 W=1e-6 L=1e-6
mpway59_cell25 ML59 gate_way59_cell25 GND ML59 p1 W=2.4e-6 L=1e-6
mnway59_cell26 ML59 gate_way59_cell26 GND GND n1 W=1e-6 L=1e-6
mpway59_cell26 ML59 gate_way59_cell26 GND ML59 p1 W=2.4e-6 L=1e-6
mnway59_cell27 ML59 gate_way59_cell27 GND GND n1 W=1e-6 L=1e-6
mpway59_cell27 ML59 gate_way59_cell27 GND ML59 p1 W=2.4e-6 L=1e-6
mnway59_cell28 ML59 gate_way59_cell28 GND GND n1 W=1e-6 L=1e-6
mpway59_cell28 ML59 gate_way59_cell28 GND ML59 p1 W=2.4e-6 L=1e-6
mnway59_cell29 ML59 gate_way59_cell29 GND GND n1 W=1e-6 L=1e-6
mpway59_cell29 ML59 gate_way59_cell29 GND ML59 p1 W=2.4e-6 L=1e-6
mnway59_cell30 ML59 gate_way59_cell30 GND GND n1 W=1e-6 L=1e-6
mpway59_cell30 ML59 gate_way59_cell30 GND ML59 p1 W=2.4e-6 L=1e-6
mnway59_cell31 ML59 gate_way59_cell31 GND GND n1 W=1e-6 L=1e-6
mpway59_cell31 ML59 gate_way59_cell31 GND ML59 p1 W=2.4e-6 L=1e-6
mnway59_cell32 ML59 gate_way59_cell32 GND GND n1 W=1e-6 L=1e-6
mpway59_cell32 ML59 gate_way59_cell32 GND ML59 p1 W=2.4e-6 L=1e-6
mnway59_cell33 ML59 gate_way59_cell33 GND GND n1 W=1e-6 L=1e-6
mpway59_cell33 ML59 gate_way59_cell33 GND ML59 p1 W=2.4e-6 L=1e-6
mnway59_cell34 ML59 gate_way59_cell34 GND GND n1 W=1e-6 L=1e-6
mpway59_cell34 ML59 gate_way59_cell34 GND ML59 p1 W=2.4e-6 L=1e-6
mnway59_cell35 ML59 gate_way59_cell35 GND GND n1 W=1e-6 L=1e-6
mpway59_cell35 ML59 gate_way59_cell35 GND ML59 p1 W=2.4e-6 L=1e-6
mnway59_cell36 ML59 gate_way59_cell36 GND GND n1 W=1e-6 L=1e-6
mpway59_cell36 ML59 gate_way59_cell36 GND ML59 p1 W=2.4e-6 L=1e-6
mnway59_cell37 ML59 gate_way59_cell37 GND GND n1 W=1e-6 L=1e-6
mpway59_cell37 ML59 gate_way59_cell37 GND ML59 p1 W=2.4e-6 L=1e-6
mnway59_cell38 ML59 gate_way59_cell38 GND GND n1 W=1e-6 L=1e-6
mpway59_cell38 ML59 gate_way59_cell38 GND ML59 p1 W=2.4e-6 L=1e-6
mnway59_cell39 ML59 gate_way59_cell39 GND GND n1 W=1e-6 L=1e-6
mpway59_cell39 ML59 gate_way59_cell39 GND ML59 p1 W=2.4e-6 L=1e-6
mnway59_cell40 ML59 gate_way59_cell40 GND GND n1 W=1e-6 L=1e-6
mpway59_cell40 ML59 gate_way59_cell40 GND ML59 p1 W=2.4e-6 L=1e-6
mnway59_cell41 ML59 gate_way59_cell41 GND GND n1 W=1e-6 L=1e-6
mpway59_cell41 ML59 gate_way59_cell41 GND ML59 p1 W=2.4e-6 L=1e-6
mnway59_cell42 ML59 gate_way59_cell42 GND GND n1 W=1e-6 L=1e-6
mpway59_cell42 ML59 gate_way59_cell42 GND ML59 p1 W=2.4e-6 L=1e-6
mnway59_cell43 ML59 gate_way59_cell43 GND GND n1 W=1e-6 L=1e-6
mpway59_cell43 ML59 gate_way59_cell43 GND ML59 p1 W=2.4e-6 L=1e-6
mnway59_cell44 ML59 gate_way59_cell44 GND GND n1 W=1e-6 L=1e-6
mpway59_cell44 ML59 gate_way59_cell44 GND ML59 p1 W=2.4e-6 L=1e-6
mnway59_cell45 ML59 gate_way59_cell45 GND GND n1 W=1e-6 L=1e-6
mpway59_cell45 ML59 gate_way59_cell45 GND ML59 p1 W=2.4e-6 L=1e-6
mnway59_cell46 ML59 gate_way59_cell46 GND GND n1 W=1e-6 L=1e-6
mpway59_cell46 ML59 gate_way59_cell46 GND ML59 p1 W=2.4e-6 L=1e-6
mnway59_cell47 ML59 gate_way59_cell47 GND GND n1 W=1e-6 L=1e-6
mpway59_cell47 ML59 gate_way59_cell47 GND ML59 p1 W=2.4e-6 L=1e-6
mnway59_cell48 ML59 gate_way59_cell48 GND GND n1 W=1e-6 L=1e-6
mpway59_cell48 ML59 gate_way59_cell48 GND ML59 p1 W=2.4e-6 L=1e-6
mnway59_cell49 ML59 gate_way59_cell49 GND GND n1 W=1e-6 L=1e-6
mpway59_cell49 ML59 gate_way59_cell49 GND ML59 p1 W=2.4e-6 L=1e-6
mnway59_cell50 ML59 gate_way59_cell50 GND GND n1 W=1e-6 L=1e-6
mpway59_cell50 ML59 gate_way59_cell50 GND ML59 p1 W=2.4e-6 L=1e-6
mnway59_cell51 ML59 gate_way59_cell51 GND GND n1 W=1e-6 L=1e-6
mpway59_cell51 ML59 gate_way59_cell51 GND ML59 p1 W=2.4e-6 L=1e-6
mnway59_cell52 ML59 gate_way59_cell52 GND GND n1 W=1e-6 L=1e-6
mpway59_cell52 ML59 gate_way59_cell52 GND ML59 p1 W=2.4e-6 L=1e-6
mnway59_cell53 ML59 gate_way59_cell53 GND GND n1 W=1e-6 L=1e-6
mpway59_cell53 ML59 gate_way59_cell53 GND ML59 p1 W=2.4e-6 L=1e-6
mnway59_cell54 ML59 gate_way59_cell54 GND GND n1 W=1e-6 L=1e-6
mpway59_cell54 ML59 gate_way59_cell54 GND ML59 p1 W=2.4e-6 L=1e-6
mnway59_cell55 ML59 gate_way59_cell55 GND GND n1 W=1e-6 L=1e-6
mpway59_cell55 ML59 gate_way59_cell55 GND ML59 p1 W=2.4e-6 L=1e-6
mnway59_cell56 ML59 gate_way59_cell56 GND GND n1 W=1e-6 L=1e-6
mpway59_cell56 ML59 gate_way59_cell56 GND ML59 p1 W=2.4e-6 L=1e-6
mnway59_cell57 ML59 gate_way59_cell57 GND GND n1 W=1e-6 L=1e-6
mpway59_cell57 ML59 gate_way59_cell57 GND ML59 p1 W=2.4e-6 L=1e-6
mnway59_cell58 ML59 gate_way59_cell58 GND GND n1 W=1e-6 L=1e-6
mpway59_cell58 ML59 gate_way59_cell58 GND ML59 p1 W=2.4e-6 L=1e-6
mnway59_cell59 ML59 gate_way59_cell59 GND GND n1 W=1e-6 L=1e-6
mpway59_cell59 ML59 gate_way59_cell59 GND ML59 p1 W=2.4e-6 L=1e-6
mnway59_cell60 ML59 gate_way59_cell60 GND GND n1 W=1e-6 L=1e-6
mpway59_cell60 ML59 gate_way59_cell60 GND ML59 p1 W=2.4e-6 L=1e-6
mnway59_cell61 ML59 gate_way59_cell61 GND GND n1 W=1e-6 L=1e-6
mpway59_cell61 ML59 gate_way59_cell61 GND ML59 p1 W=2.4e-6 L=1e-6
mnway59_cell62 ML59 gate_way59_cell62 GND GND n1 W=1e-6 L=1e-6
mpway59_cell62 ML59 gate_way59_cell62 GND ML59 p1 W=2.4e-6 L=1e-6
mnway59_cell63 ML59 gate_way59_cell63 GND GND n1 W=1e-6 L=1e-6
mpway59_cell63 ML59 gate_way59_cell63 GND ML59 p1 W=2.4e-6 L=1e-6
mnway59_cell64 ML59 gate_way59_cell64 GND GND n1 W=1e-6 L=1e-6
mpway59_cell64 ML59 gate_way59_cell64 GND ML59 p1 W=2.4e-6 L=1e-6
mnway59_cell65 ML59 gate_way59_cell65 GND GND n1 W=1e-6 L=1e-6
mpway59_cell65 ML59 gate_way59_cell65 GND ML59 p1 W=2.4e-6 L=1e-6
mnway59_cell66 ML59 gate_way59_cell66 GND GND n1 W=1e-6 L=1e-6
mpway59_cell66 ML59 gate_way59_cell66 GND ML59 p1 W=2.4e-6 L=1e-6
mnway59_cell67 ML59 gate_way59_cell67 GND GND n1 W=1e-6 L=1e-6
mpway59_cell67 ML59 gate_way59_cell67 GND ML59 p1 W=2.4e-6 L=1e-6
mnway59_cell68 ML59 gate_way59_cell68 GND GND n1 W=1e-6 L=1e-6
mpway59_cell68 ML59 gate_way59_cell68 GND ML59 p1 W=2.4e-6 L=1e-6
mnway59_cell69 ML59 gate_way59_cell69 GND GND n1 W=1e-6 L=1e-6
mpway59_cell69 ML59 gate_way59_cell69 GND ML59 p1 W=2.4e-6 L=1e-6
mnway59_cell70 ML59 gate_way59_cell70 GND GND n1 W=1e-6 L=1e-6
mpway59_cell70 ML59 gate_way59_cell70 GND ML59 p1 W=2.4e-6 L=1e-6
mnway59_cell71 ML59 gate_way59_cell71 GND GND n1 W=1e-6 L=1e-6
mpway59_cell71 ML59 gate_way59_cell71 GND ML59 p1 W=2.4e-6 L=1e-6
mnway59_cell72 ML59 gate_way59_cell72 GND GND n1 W=1e-6 L=1e-6
mpway59_cell72 ML59 gate_way59_cell72 GND ML59 p1 W=2.4e-6 L=1e-6
mnway59_cell73 ML59 gate_way59_cell73 GND GND n1 W=1e-6 L=1e-6
mpway59_cell73 ML59 gate_way59_cell73 GND ML59 p1 W=2.4e-6 L=1e-6
mnway59_cell74 ML59 gate_way59_cell74 GND GND n1 W=1e-6 L=1e-6
mpway59_cell74 ML59 gate_way59_cell74 GND ML59 p1 W=2.4e-6 L=1e-6
mnway59_cell75 ML59 gate_way59_cell75 GND GND n1 W=1e-6 L=1e-6
mpway59_cell75 ML59 gate_way59_cell75 GND ML59 p1 W=2.4e-6 L=1e-6
mnway59_cell76 ML59 gate_way59_cell76 GND GND n1 W=1e-6 L=1e-6
mpway59_cell76 ML59 gate_way59_cell76 GND ML59 p1 W=2.4e-6 L=1e-6
mnway59_cell77 ML59 gate_way59_cell77 GND GND n1 W=1e-6 L=1e-6
mpway59_cell77 ML59 gate_way59_cell77 GND ML59 p1 W=2.4e-6 L=1e-6
mnway59_cell78 ML59 gate_way59_cell78 GND GND n1 W=1e-6 L=1e-6
mpway59_cell78 ML59 gate_way59_cell78 GND ML59 p1 W=2.4e-6 L=1e-6
mnway59_cell79 ML59 gate_way59_cell79 GND GND n1 W=1e-6 L=1e-6
mpway59_cell79 ML59 gate_way59_cell79 GND ML59 p1 W=2.4e-6 L=1e-6
mnway59_cell80 ML59 gate_way59_cell80 GND GND n1 W=1e-6 L=1e-6
mpway59_cell80 ML59 gate_way59_cell80 GND ML59 p1 W=2.4e-6 L=1e-6
mnway59_cell81 ML59 gate_way59_cell81 GND GND n1 W=1e-6 L=1e-6
mpway59_cell81 ML59 gate_way59_cell81 GND ML59 p1 W=2.4e-6 L=1e-6
mnway59_cell82 ML59 gate_way59_cell82 GND GND n1 W=1e-6 L=1e-6
mpway59_cell82 ML59 gate_way59_cell82 GND ML59 p1 W=2.4e-6 L=1e-6
mnway59_cell83 ML59 gate_way59_cell83 GND GND n1 W=1e-6 L=1e-6
mpway59_cell83 ML59 gate_way59_cell83 GND ML59 p1 W=2.4e-6 L=1e-6
mnway59_cell84 ML59 gate_way59_cell84 GND GND n1 W=1e-6 L=1e-6
mpway59_cell84 ML59 gate_way59_cell84 GND ML59 p1 W=2.4e-6 L=1e-6
mnway59_cell85 ML59 gate_way59_cell85 GND GND n1 W=1e-6 L=1e-6
mpway59_cell85 ML59 gate_way59_cell85 GND ML59 p1 W=2.4e-6 L=1e-6
mnway59_cell86 ML59 gate_way59_cell86 GND GND n1 W=1e-6 L=1e-6
mpway59_cell86 ML59 gate_way59_cell86 GND ML59 p1 W=2.4e-6 L=1e-6
mnway59_cell87 ML59 gate_way59_cell87 GND GND n1 W=1e-6 L=1e-6
mpway59_cell87 ML59 gate_way59_cell87 GND ML59 p1 W=2.4e-6 L=1e-6
mnway59_cell88 ML59 gate_way59_cell88 GND GND n1 W=1e-6 L=1e-6
mpway59_cell88 ML59 gate_way59_cell88 GND ML59 p1 W=2.4e-6 L=1e-6
mnway59_cell89 ML59 gate_way59_cell89 GND GND n1 W=1e-6 L=1e-6
mpway59_cell89 ML59 gate_way59_cell89 GND ML59 p1 W=2.4e-6 L=1e-6
mnway59_cell90 ML59 gate_way59_cell90 GND GND n1 W=1e-6 L=1e-6
mpway59_cell90 ML59 gate_way59_cell90 GND ML59 p1 W=2.4e-6 L=1e-6
mnway59_cell91 ML59 gate_way59_cell91 GND GND n1 W=1e-6 L=1e-6
mpway59_cell91 ML59 gate_way59_cell91 GND ML59 p1 W=2.4e-6 L=1e-6
mnway59_cell92 ML59 gate_way59_cell92 GND GND n1 W=1e-6 L=1e-6
mpway59_cell92 ML59 gate_way59_cell92 GND ML59 p1 W=2.4e-6 L=1e-6
mnway59_cell93 ML59 gate_way59_cell93 GND GND n1 W=1e-6 L=1e-6
mpway59_cell93 ML59 gate_way59_cell93 GND ML59 p1 W=2.4e-6 L=1e-6
mnway59_cell94 ML59 gate_way59_cell94 GND GND n1 W=1e-6 L=1e-6
mpway59_cell94 ML59 gate_way59_cell94 GND ML59 p1 W=2.4e-6 L=1e-6
mnway59_cell95 ML59 gate_way59_cell95 GND GND n1 W=1e-6 L=1e-6
mpway59_cell95 ML59 gate_way59_cell95 GND ML59 p1 W=2.4e-6 L=1e-6
mnway59_cell96 ML59 gate_way59_cell96 GND GND n1 W=1e-6 L=1e-6
mpway59_cell96 ML59 gate_way59_cell96 GND ML59 p1 W=2.4e-6 L=1e-6
mnway59_cell97 ML59 gate_way59_cell97 GND GND n1 W=1e-6 L=1e-6
mpway59_cell97 ML59 gate_way59_cell97 GND ML59 p1 W=2.4e-6 L=1e-6
mnway59_cell98 ML59 gate_way59_cell98 GND GND n1 W=1e-6 L=1e-6
mpway59_cell98 ML59 gate_way59_cell98 GND ML59 p1 W=2.4e-6 L=1e-6
mnway59_cell99 ML59 gate_way59_cell99 GND GND n1 W=1e-6 L=1e-6
mpway59_cell99 ML59 gate_way59_cell99 GND ML59 p1 W=2.4e-6 L=1e-6
mnway60_cell0 ML60 gate_way60_cell0 GND GND n1 W=1e-6 L=1e-6
mpway60_cell0 ML60 gate_way60_cell0 GND ML60 p1 W=2.4e-6 L=1e-6
mnway60_cell1 ML60 gate_way60_cell1 GND GND n1 W=1e-6 L=1e-6
mpway60_cell1 ML60 gate_way60_cell1 GND ML60 p1 W=2.4e-6 L=1e-6
mnway60_cell2 ML60 gate_way60_cell2 GND GND n1 W=1e-6 L=1e-6
mpway60_cell2 ML60 gate_way60_cell2 GND ML60 p1 W=2.4e-6 L=1e-6
mnway60_cell3 ML60 gate_way60_cell3 GND GND n1 W=1e-6 L=1e-6
mpway60_cell3 ML60 gate_way60_cell3 GND ML60 p1 W=2.4e-6 L=1e-6
mnway60_cell4 ML60 gate_way60_cell4 GND GND n1 W=1e-6 L=1e-6
mpway60_cell4 ML60 gate_way60_cell4 GND ML60 p1 W=2.4e-6 L=1e-6
mnway60_cell5 ML60 gate_way60_cell5 GND GND n1 W=1e-6 L=1e-6
mpway60_cell5 ML60 gate_way60_cell5 GND ML60 p1 W=2.4e-6 L=1e-6
mnway60_cell6 ML60 gate_way60_cell6 GND GND n1 W=1e-6 L=1e-6
mpway60_cell6 ML60 gate_way60_cell6 GND ML60 p1 W=2.4e-6 L=1e-6
mnway60_cell7 ML60 gate_way60_cell7 GND GND n1 W=1e-6 L=1e-6
mpway60_cell7 ML60 gate_way60_cell7 GND ML60 p1 W=2.4e-6 L=1e-6
mnway60_cell8 ML60 gate_way60_cell8 GND GND n1 W=1e-6 L=1e-6
mpway60_cell8 ML60 gate_way60_cell8 GND ML60 p1 W=2.4e-6 L=1e-6
mnway60_cell9 ML60 gate_way60_cell9 GND GND n1 W=1e-6 L=1e-6
mpway60_cell9 ML60 gate_way60_cell9 GND ML60 p1 W=2.4e-6 L=1e-6
mnway60_cell10 ML60 gate_way60_cell10 GND GND n1 W=1e-6 L=1e-6
mpway60_cell10 ML60 gate_way60_cell10 GND ML60 p1 W=2.4e-6 L=1e-6
mnway60_cell11 ML60 gate_way60_cell11 GND GND n1 W=1e-6 L=1e-6
mpway60_cell11 ML60 gate_way60_cell11 GND ML60 p1 W=2.4e-6 L=1e-6
mnway60_cell12 ML60 gate_way60_cell12 GND GND n1 W=1e-6 L=1e-6
mpway60_cell12 ML60 gate_way60_cell12 GND ML60 p1 W=2.4e-6 L=1e-6
mnway60_cell13 ML60 gate_way60_cell13 GND GND n1 W=1e-6 L=1e-6
mpway60_cell13 ML60 gate_way60_cell13 GND ML60 p1 W=2.4e-6 L=1e-6
mnway60_cell14 ML60 gate_way60_cell14 GND GND n1 W=1e-6 L=1e-6
mpway60_cell14 ML60 gate_way60_cell14 GND ML60 p1 W=2.4e-6 L=1e-6
mnway60_cell15 ML60 gate_way60_cell15 GND GND n1 W=1e-6 L=1e-6
mpway60_cell15 ML60 gate_way60_cell15 GND ML60 p1 W=2.4e-6 L=1e-6
mnway60_cell16 ML60 gate_way60_cell16 GND GND n1 W=1e-6 L=1e-6
mpway60_cell16 ML60 gate_way60_cell16 GND ML60 p1 W=2.4e-6 L=1e-6
mnway60_cell17 ML60 gate_way60_cell17 GND GND n1 W=1e-6 L=1e-6
mpway60_cell17 ML60 gate_way60_cell17 GND ML60 p1 W=2.4e-6 L=1e-6
mnway60_cell18 ML60 gate_way60_cell18 GND GND n1 W=1e-6 L=1e-6
mpway60_cell18 ML60 gate_way60_cell18 GND ML60 p1 W=2.4e-6 L=1e-6
mnway60_cell19 ML60 gate_way60_cell19 GND GND n1 W=1e-6 L=1e-6
mpway60_cell19 ML60 gate_way60_cell19 GND ML60 p1 W=2.4e-6 L=1e-6
mnway60_cell20 ML60 gate_way60_cell20 GND GND n1 W=1e-6 L=1e-6
mpway60_cell20 ML60 gate_way60_cell20 GND ML60 p1 W=2.4e-6 L=1e-6
mnway60_cell21 ML60 gate_way60_cell21 GND GND n1 W=1e-6 L=1e-6
mpway60_cell21 ML60 gate_way60_cell21 GND ML60 p1 W=2.4e-6 L=1e-6
mnway60_cell22 ML60 gate_way60_cell22 GND GND n1 W=1e-6 L=1e-6
mpway60_cell22 ML60 gate_way60_cell22 GND ML60 p1 W=2.4e-6 L=1e-6
mnway60_cell23 ML60 gate_way60_cell23 GND GND n1 W=1e-6 L=1e-6
mpway60_cell23 ML60 gate_way60_cell23 GND ML60 p1 W=2.4e-6 L=1e-6
mnway60_cell24 ML60 gate_way60_cell24 GND GND n1 W=1e-6 L=1e-6
mpway60_cell24 ML60 gate_way60_cell24 GND ML60 p1 W=2.4e-6 L=1e-6
mnway60_cell25 ML60 gate_way60_cell25 GND GND n1 W=1e-6 L=1e-6
mpway60_cell25 ML60 gate_way60_cell25 GND ML60 p1 W=2.4e-6 L=1e-6
mnway60_cell26 ML60 gate_way60_cell26 GND GND n1 W=1e-6 L=1e-6
mpway60_cell26 ML60 gate_way60_cell26 GND ML60 p1 W=2.4e-6 L=1e-6
mnway60_cell27 ML60 gate_way60_cell27 GND GND n1 W=1e-6 L=1e-6
mpway60_cell27 ML60 gate_way60_cell27 GND ML60 p1 W=2.4e-6 L=1e-6
mnway60_cell28 ML60 gate_way60_cell28 GND GND n1 W=1e-6 L=1e-6
mpway60_cell28 ML60 gate_way60_cell28 GND ML60 p1 W=2.4e-6 L=1e-6
mnway60_cell29 ML60 gate_way60_cell29 GND GND n1 W=1e-6 L=1e-6
mpway60_cell29 ML60 gate_way60_cell29 GND ML60 p1 W=2.4e-6 L=1e-6
mnway60_cell30 ML60 gate_way60_cell30 GND GND n1 W=1e-6 L=1e-6
mpway60_cell30 ML60 gate_way60_cell30 GND ML60 p1 W=2.4e-6 L=1e-6
mnway60_cell31 ML60 gate_way60_cell31 GND GND n1 W=1e-6 L=1e-6
mpway60_cell31 ML60 gate_way60_cell31 GND ML60 p1 W=2.4e-6 L=1e-6
mnway60_cell32 ML60 gate_way60_cell32 GND GND n1 W=1e-6 L=1e-6
mpway60_cell32 ML60 gate_way60_cell32 GND ML60 p1 W=2.4e-6 L=1e-6
mnway60_cell33 ML60 gate_way60_cell33 GND GND n1 W=1e-6 L=1e-6
mpway60_cell33 ML60 gate_way60_cell33 GND ML60 p1 W=2.4e-6 L=1e-6
mnway60_cell34 ML60 gate_way60_cell34 GND GND n1 W=1e-6 L=1e-6
mpway60_cell34 ML60 gate_way60_cell34 GND ML60 p1 W=2.4e-6 L=1e-6
mnway60_cell35 ML60 gate_way60_cell35 GND GND n1 W=1e-6 L=1e-6
mpway60_cell35 ML60 gate_way60_cell35 GND ML60 p1 W=2.4e-6 L=1e-6
mnway60_cell36 ML60 gate_way60_cell36 GND GND n1 W=1e-6 L=1e-6
mpway60_cell36 ML60 gate_way60_cell36 GND ML60 p1 W=2.4e-6 L=1e-6
mnway60_cell37 ML60 gate_way60_cell37 GND GND n1 W=1e-6 L=1e-6
mpway60_cell37 ML60 gate_way60_cell37 GND ML60 p1 W=2.4e-6 L=1e-6
mnway60_cell38 ML60 gate_way60_cell38 GND GND n1 W=1e-6 L=1e-6
mpway60_cell38 ML60 gate_way60_cell38 GND ML60 p1 W=2.4e-6 L=1e-6
mnway60_cell39 ML60 gate_way60_cell39 GND GND n1 W=1e-6 L=1e-6
mpway60_cell39 ML60 gate_way60_cell39 GND ML60 p1 W=2.4e-6 L=1e-6
mnway60_cell40 ML60 gate_way60_cell40 GND GND n1 W=1e-6 L=1e-6
mpway60_cell40 ML60 gate_way60_cell40 GND ML60 p1 W=2.4e-6 L=1e-6
mnway60_cell41 ML60 gate_way60_cell41 GND GND n1 W=1e-6 L=1e-6
mpway60_cell41 ML60 gate_way60_cell41 GND ML60 p1 W=2.4e-6 L=1e-6
mnway60_cell42 ML60 gate_way60_cell42 GND GND n1 W=1e-6 L=1e-6
mpway60_cell42 ML60 gate_way60_cell42 GND ML60 p1 W=2.4e-6 L=1e-6
mnway60_cell43 ML60 gate_way60_cell43 GND GND n1 W=1e-6 L=1e-6
mpway60_cell43 ML60 gate_way60_cell43 GND ML60 p1 W=2.4e-6 L=1e-6
mnway60_cell44 ML60 gate_way60_cell44 GND GND n1 W=1e-6 L=1e-6
mpway60_cell44 ML60 gate_way60_cell44 GND ML60 p1 W=2.4e-6 L=1e-6
mnway60_cell45 ML60 gate_way60_cell45 GND GND n1 W=1e-6 L=1e-6
mpway60_cell45 ML60 gate_way60_cell45 GND ML60 p1 W=2.4e-6 L=1e-6
mnway60_cell46 ML60 gate_way60_cell46 GND GND n1 W=1e-6 L=1e-6
mpway60_cell46 ML60 gate_way60_cell46 GND ML60 p1 W=2.4e-6 L=1e-6
mnway60_cell47 ML60 gate_way60_cell47 GND GND n1 W=1e-6 L=1e-6
mpway60_cell47 ML60 gate_way60_cell47 GND ML60 p1 W=2.4e-6 L=1e-6
mnway60_cell48 ML60 gate_way60_cell48 GND GND n1 W=1e-6 L=1e-6
mpway60_cell48 ML60 gate_way60_cell48 GND ML60 p1 W=2.4e-6 L=1e-6
mnway60_cell49 ML60 gate_way60_cell49 GND GND n1 W=1e-6 L=1e-6
mpway60_cell49 ML60 gate_way60_cell49 GND ML60 p1 W=2.4e-6 L=1e-6
mnway60_cell50 ML60 gate_way60_cell50 GND GND n1 W=1e-6 L=1e-6
mpway60_cell50 ML60 gate_way60_cell50 GND ML60 p1 W=2.4e-6 L=1e-6
mnway60_cell51 ML60 gate_way60_cell51 GND GND n1 W=1e-6 L=1e-6
mpway60_cell51 ML60 gate_way60_cell51 GND ML60 p1 W=2.4e-6 L=1e-6
mnway60_cell52 ML60 gate_way60_cell52 GND GND n1 W=1e-6 L=1e-6
mpway60_cell52 ML60 gate_way60_cell52 GND ML60 p1 W=2.4e-6 L=1e-6
mnway60_cell53 ML60 gate_way60_cell53 GND GND n1 W=1e-6 L=1e-6
mpway60_cell53 ML60 gate_way60_cell53 GND ML60 p1 W=2.4e-6 L=1e-6
mnway60_cell54 ML60 gate_way60_cell54 GND GND n1 W=1e-6 L=1e-6
mpway60_cell54 ML60 gate_way60_cell54 GND ML60 p1 W=2.4e-6 L=1e-6
mnway60_cell55 ML60 gate_way60_cell55 GND GND n1 W=1e-6 L=1e-6
mpway60_cell55 ML60 gate_way60_cell55 GND ML60 p1 W=2.4e-6 L=1e-6
mnway60_cell56 ML60 gate_way60_cell56 GND GND n1 W=1e-6 L=1e-6
mpway60_cell56 ML60 gate_way60_cell56 GND ML60 p1 W=2.4e-6 L=1e-6
mnway60_cell57 ML60 gate_way60_cell57 GND GND n1 W=1e-6 L=1e-6
mpway60_cell57 ML60 gate_way60_cell57 GND ML60 p1 W=2.4e-6 L=1e-6
mnway60_cell58 ML60 gate_way60_cell58 GND GND n1 W=1e-6 L=1e-6
mpway60_cell58 ML60 gate_way60_cell58 GND ML60 p1 W=2.4e-6 L=1e-6
mnway60_cell59 ML60 gate_way60_cell59 GND GND n1 W=1e-6 L=1e-6
mpway60_cell59 ML60 gate_way60_cell59 GND ML60 p1 W=2.4e-6 L=1e-6
mnway60_cell60 ML60 gate_way60_cell60 GND GND n1 W=1e-6 L=1e-6
mpway60_cell60 ML60 gate_way60_cell60 GND ML60 p1 W=2.4e-6 L=1e-6
mnway60_cell61 ML60 gate_way60_cell61 GND GND n1 W=1e-6 L=1e-6
mpway60_cell61 ML60 gate_way60_cell61 GND ML60 p1 W=2.4e-6 L=1e-6
mnway60_cell62 ML60 gate_way60_cell62 GND GND n1 W=1e-6 L=1e-6
mpway60_cell62 ML60 gate_way60_cell62 GND ML60 p1 W=2.4e-6 L=1e-6
mnway60_cell63 ML60 gate_way60_cell63 GND GND n1 W=1e-6 L=1e-6
mpway60_cell63 ML60 gate_way60_cell63 GND ML60 p1 W=2.4e-6 L=1e-6
mnway60_cell64 ML60 gate_way60_cell64 GND GND n1 W=1e-6 L=1e-6
mpway60_cell64 ML60 gate_way60_cell64 GND ML60 p1 W=2.4e-6 L=1e-6
mnway60_cell65 ML60 gate_way60_cell65 GND GND n1 W=1e-6 L=1e-6
mpway60_cell65 ML60 gate_way60_cell65 GND ML60 p1 W=2.4e-6 L=1e-6
mnway60_cell66 ML60 gate_way60_cell66 GND GND n1 W=1e-6 L=1e-6
mpway60_cell66 ML60 gate_way60_cell66 GND ML60 p1 W=2.4e-6 L=1e-6
mnway60_cell67 ML60 gate_way60_cell67 GND GND n1 W=1e-6 L=1e-6
mpway60_cell67 ML60 gate_way60_cell67 GND ML60 p1 W=2.4e-6 L=1e-6
mnway60_cell68 ML60 gate_way60_cell68 GND GND n1 W=1e-6 L=1e-6
mpway60_cell68 ML60 gate_way60_cell68 GND ML60 p1 W=2.4e-6 L=1e-6
mnway60_cell69 ML60 gate_way60_cell69 GND GND n1 W=1e-6 L=1e-6
mpway60_cell69 ML60 gate_way60_cell69 GND ML60 p1 W=2.4e-6 L=1e-6
mnway60_cell70 ML60 gate_way60_cell70 GND GND n1 W=1e-6 L=1e-6
mpway60_cell70 ML60 gate_way60_cell70 GND ML60 p1 W=2.4e-6 L=1e-6
mnway60_cell71 ML60 gate_way60_cell71 GND GND n1 W=1e-6 L=1e-6
mpway60_cell71 ML60 gate_way60_cell71 GND ML60 p1 W=2.4e-6 L=1e-6
mnway60_cell72 ML60 gate_way60_cell72 GND GND n1 W=1e-6 L=1e-6
mpway60_cell72 ML60 gate_way60_cell72 GND ML60 p1 W=2.4e-6 L=1e-6
mnway60_cell73 ML60 gate_way60_cell73 GND GND n1 W=1e-6 L=1e-6
mpway60_cell73 ML60 gate_way60_cell73 GND ML60 p1 W=2.4e-6 L=1e-6
mnway60_cell74 ML60 gate_way60_cell74 GND GND n1 W=1e-6 L=1e-6
mpway60_cell74 ML60 gate_way60_cell74 GND ML60 p1 W=2.4e-6 L=1e-6
mnway60_cell75 ML60 gate_way60_cell75 GND GND n1 W=1e-6 L=1e-6
mpway60_cell75 ML60 gate_way60_cell75 GND ML60 p1 W=2.4e-6 L=1e-6
mnway60_cell76 ML60 gate_way60_cell76 GND GND n1 W=1e-6 L=1e-6
mpway60_cell76 ML60 gate_way60_cell76 GND ML60 p1 W=2.4e-6 L=1e-6
mnway60_cell77 ML60 gate_way60_cell77 GND GND n1 W=1e-6 L=1e-6
mpway60_cell77 ML60 gate_way60_cell77 GND ML60 p1 W=2.4e-6 L=1e-6
mnway60_cell78 ML60 gate_way60_cell78 GND GND n1 W=1e-6 L=1e-6
mpway60_cell78 ML60 gate_way60_cell78 GND ML60 p1 W=2.4e-6 L=1e-6
mnway60_cell79 ML60 gate_way60_cell79 GND GND n1 W=1e-6 L=1e-6
mpway60_cell79 ML60 gate_way60_cell79 GND ML60 p1 W=2.4e-6 L=1e-6
mnway60_cell80 ML60 gate_way60_cell80 GND GND n1 W=1e-6 L=1e-6
mpway60_cell80 ML60 gate_way60_cell80 GND ML60 p1 W=2.4e-6 L=1e-6
mnway60_cell81 ML60 gate_way60_cell81 GND GND n1 W=1e-6 L=1e-6
mpway60_cell81 ML60 gate_way60_cell81 GND ML60 p1 W=2.4e-6 L=1e-6
mnway60_cell82 ML60 gate_way60_cell82 GND GND n1 W=1e-6 L=1e-6
mpway60_cell82 ML60 gate_way60_cell82 GND ML60 p1 W=2.4e-6 L=1e-6
mnway60_cell83 ML60 gate_way60_cell83 GND GND n1 W=1e-6 L=1e-6
mpway60_cell83 ML60 gate_way60_cell83 GND ML60 p1 W=2.4e-6 L=1e-6
mnway60_cell84 ML60 gate_way60_cell84 GND GND n1 W=1e-6 L=1e-6
mpway60_cell84 ML60 gate_way60_cell84 GND ML60 p1 W=2.4e-6 L=1e-6
mnway60_cell85 ML60 gate_way60_cell85 GND GND n1 W=1e-6 L=1e-6
mpway60_cell85 ML60 gate_way60_cell85 GND ML60 p1 W=2.4e-6 L=1e-6
mnway60_cell86 ML60 gate_way60_cell86 GND GND n1 W=1e-6 L=1e-6
mpway60_cell86 ML60 gate_way60_cell86 GND ML60 p1 W=2.4e-6 L=1e-6
mnway60_cell87 ML60 gate_way60_cell87 GND GND n1 W=1e-6 L=1e-6
mpway60_cell87 ML60 gate_way60_cell87 GND ML60 p1 W=2.4e-6 L=1e-6
mnway60_cell88 ML60 gate_way60_cell88 GND GND n1 W=1e-6 L=1e-6
mpway60_cell88 ML60 gate_way60_cell88 GND ML60 p1 W=2.4e-6 L=1e-6
mnway60_cell89 ML60 gate_way60_cell89 GND GND n1 W=1e-6 L=1e-6
mpway60_cell89 ML60 gate_way60_cell89 GND ML60 p1 W=2.4e-6 L=1e-6
mnway60_cell90 ML60 gate_way60_cell90 GND GND n1 W=1e-6 L=1e-6
mpway60_cell90 ML60 gate_way60_cell90 GND ML60 p1 W=2.4e-6 L=1e-6
mnway60_cell91 ML60 gate_way60_cell91 GND GND n1 W=1e-6 L=1e-6
mpway60_cell91 ML60 gate_way60_cell91 GND ML60 p1 W=2.4e-6 L=1e-6
mnway60_cell92 ML60 gate_way60_cell92 GND GND n1 W=1e-6 L=1e-6
mpway60_cell92 ML60 gate_way60_cell92 GND ML60 p1 W=2.4e-6 L=1e-6
mnway60_cell93 ML60 gate_way60_cell93 GND GND n1 W=1e-6 L=1e-6
mpway60_cell93 ML60 gate_way60_cell93 GND ML60 p1 W=2.4e-6 L=1e-6
mnway60_cell94 ML60 gate_way60_cell94 GND GND n1 W=1e-6 L=1e-6
mpway60_cell94 ML60 gate_way60_cell94 GND ML60 p1 W=2.4e-6 L=1e-6
mnway60_cell95 ML60 gate_way60_cell95 GND GND n1 W=1e-6 L=1e-6
mpway60_cell95 ML60 gate_way60_cell95 GND ML60 p1 W=2.4e-6 L=1e-6
mnway60_cell96 ML60 gate_way60_cell96 GND GND n1 W=1e-6 L=1e-6
mpway60_cell96 ML60 gate_way60_cell96 GND ML60 p1 W=2.4e-6 L=1e-6
mnway60_cell97 ML60 gate_way60_cell97 GND GND n1 W=1e-6 L=1e-6
mpway60_cell97 ML60 gate_way60_cell97 GND ML60 p1 W=2.4e-6 L=1e-6
mnway60_cell98 ML60 gate_way60_cell98 GND GND n1 W=1e-6 L=1e-6
mpway60_cell98 ML60 gate_way60_cell98 GND ML60 p1 W=2.4e-6 L=1e-6
mnway60_cell99 ML60 gate_way60_cell99 GND GND n1 W=1e-6 L=1e-6
mpway60_cell99 ML60 gate_way60_cell99 GND ML60 p1 W=2.4e-6 L=1e-6
mnway61_cell0 ML61 gate_way61_cell0 GND GND n1 W=1e-6 L=1e-6
mpway61_cell0 ML61 gate_way61_cell0 GND ML61 p1 W=2.4e-6 L=1e-6
mnway61_cell1 ML61 gate_way61_cell1 GND GND n1 W=1e-6 L=1e-6
mpway61_cell1 ML61 gate_way61_cell1 GND ML61 p1 W=2.4e-6 L=1e-6
mnway61_cell2 ML61 gate_way61_cell2 GND GND n1 W=1e-6 L=1e-6
mpway61_cell2 ML61 gate_way61_cell2 GND ML61 p1 W=2.4e-6 L=1e-6
mnway61_cell3 ML61 gate_way61_cell3 GND GND n1 W=1e-6 L=1e-6
mpway61_cell3 ML61 gate_way61_cell3 GND ML61 p1 W=2.4e-6 L=1e-6
mnway61_cell4 ML61 gate_way61_cell4 GND GND n1 W=1e-6 L=1e-6
mpway61_cell4 ML61 gate_way61_cell4 GND ML61 p1 W=2.4e-6 L=1e-6
mnway61_cell5 ML61 gate_way61_cell5 GND GND n1 W=1e-6 L=1e-6
mpway61_cell5 ML61 gate_way61_cell5 GND ML61 p1 W=2.4e-6 L=1e-6
mnway61_cell6 ML61 gate_way61_cell6 GND GND n1 W=1e-6 L=1e-6
mpway61_cell6 ML61 gate_way61_cell6 GND ML61 p1 W=2.4e-6 L=1e-6
mnway61_cell7 ML61 gate_way61_cell7 GND GND n1 W=1e-6 L=1e-6
mpway61_cell7 ML61 gate_way61_cell7 GND ML61 p1 W=2.4e-6 L=1e-6
mnway61_cell8 ML61 gate_way61_cell8 GND GND n1 W=1e-6 L=1e-6
mpway61_cell8 ML61 gate_way61_cell8 GND ML61 p1 W=2.4e-6 L=1e-6
mnway61_cell9 ML61 gate_way61_cell9 GND GND n1 W=1e-6 L=1e-6
mpway61_cell9 ML61 gate_way61_cell9 GND ML61 p1 W=2.4e-6 L=1e-6
mnway61_cell10 ML61 gate_way61_cell10 GND GND n1 W=1e-6 L=1e-6
mpway61_cell10 ML61 gate_way61_cell10 GND ML61 p1 W=2.4e-6 L=1e-6
mnway61_cell11 ML61 gate_way61_cell11 GND GND n1 W=1e-6 L=1e-6
mpway61_cell11 ML61 gate_way61_cell11 GND ML61 p1 W=2.4e-6 L=1e-6
mnway61_cell12 ML61 gate_way61_cell12 GND GND n1 W=1e-6 L=1e-6
mpway61_cell12 ML61 gate_way61_cell12 GND ML61 p1 W=2.4e-6 L=1e-6
mnway61_cell13 ML61 gate_way61_cell13 GND GND n1 W=1e-6 L=1e-6
mpway61_cell13 ML61 gate_way61_cell13 GND ML61 p1 W=2.4e-6 L=1e-6
mnway61_cell14 ML61 gate_way61_cell14 GND GND n1 W=1e-6 L=1e-6
mpway61_cell14 ML61 gate_way61_cell14 GND ML61 p1 W=2.4e-6 L=1e-6
mnway61_cell15 ML61 gate_way61_cell15 GND GND n1 W=1e-6 L=1e-6
mpway61_cell15 ML61 gate_way61_cell15 GND ML61 p1 W=2.4e-6 L=1e-6
mnway61_cell16 ML61 gate_way61_cell16 GND GND n1 W=1e-6 L=1e-6
mpway61_cell16 ML61 gate_way61_cell16 GND ML61 p1 W=2.4e-6 L=1e-6
mnway61_cell17 ML61 gate_way61_cell17 GND GND n1 W=1e-6 L=1e-6
mpway61_cell17 ML61 gate_way61_cell17 GND ML61 p1 W=2.4e-6 L=1e-6
mnway61_cell18 ML61 gate_way61_cell18 GND GND n1 W=1e-6 L=1e-6
mpway61_cell18 ML61 gate_way61_cell18 GND ML61 p1 W=2.4e-6 L=1e-6
mnway61_cell19 ML61 gate_way61_cell19 GND GND n1 W=1e-6 L=1e-6
mpway61_cell19 ML61 gate_way61_cell19 GND ML61 p1 W=2.4e-6 L=1e-6
mnway61_cell20 ML61 gate_way61_cell20 GND GND n1 W=1e-6 L=1e-6
mpway61_cell20 ML61 gate_way61_cell20 GND ML61 p1 W=2.4e-6 L=1e-6
mnway61_cell21 ML61 gate_way61_cell21 GND GND n1 W=1e-6 L=1e-6
mpway61_cell21 ML61 gate_way61_cell21 GND ML61 p1 W=2.4e-6 L=1e-6
mnway61_cell22 ML61 gate_way61_cell22 GND GND n1 W=1e-6 L=1e-6
mpway61_cell22 ML61 gate_way61_cell22 GND ML61 p1 W=2.4e-6 L=1e-6
mnway61_cell23 ML61 gate_way61_cell23 GND GND n1 W=1e-6 L=1e-6
mpway61_cell23 ML61 gate_way61_cell23 GND ML61 p1 W=2.4e-6 L=1e-6
mnway61_cell24 ML61 gate_way61_cell24 GND GND n1 W=1e-6 L=1e-6
mpway61_cell24 ML61 gate_way61_cell24 GND ML61 p1 W=2.4e-6 L=1e-6
mnway61_cell25 ML61 gate_way61_cell25 GND GND n1 W=1e-6 L=1e-6
mpway61_cell25 ML61 gate_way61_cell25 GND ML61 p1 W=2.4e-6 L=1e-6
mnway61_cell26 ML61 gate_way61_cell26 GND GND n1 W=1e-6 L=1e-6
mpway61_cell26 ML61 gate_way61_cell26 GND ML61 p1 W=2.4e-6 L=1e-6
mnway61_cell27 ML61 gate_way61_cell27 GND GND n1 W=1e-6 L=1e-6
mpway61_cell27 ML61 gate_way61_cell27 GND ML61 p1 W=2.4e-6 L=1e-6
mnway61_cell28 ML61 gate_way61_cell28 GND GND n1 W=1e-6 L=1e-6
mpway61_cell28 ML61 gate_way61_cell28 GND ML61 p1 W=2.4e-6 L=1e-6
mnway61_cell29 ML61 gate_way61_cell29 GND GND n1 W=1e-6 L=1e-6
mpway61_cell29 ML61 gate_way61_cell29 GND ML61 p1 W=2.4e-6 L=1e-6
mnway61_cell30 ML61 gate_way61_cell30 GND GND n1 W=1e-6 L=1e-6
mpway61_cell30 ML61 gate_way61_cell30 GND ML61 p1 W=2.4e-6 L=1e-6
mnway61_cell31 ML61 gate_way61_cell31 GND GND n1 W=1e-6 L=1e-6
mpway61_cell31 ML61 gate_way61_cell31 GND ML61 p1 W=2.4e-6 L=1e-6
mnway61_cell32 ML61 gate_way61_cell32 GND GND n1 W=1e-6 L=1e-6
mpway61_cell32 ML61 gate_way61_cell32 GND ML61 p1 W=2.4e-6 L=1e-6
mnway61_cell33 ML61 gate_way61_cell33 GND GND n1 W=1e-6 L=1e-6
mpway61_cell33 ML61 gate_way61_cell33 GND ML61 p1 W=2.4e-6 L=1e-6
mnway61_cell34 ML61 gate_way61_cell34 GND GND n1 W=1e-6 L=1e-6
mpway61_cell34 ML61 gate_way61_cell34 GND ML61 p1 W=2.4e-6 L=1e-6
mnway61_cell35 ML61 gate_way61_cell35 GND GND n1 W=1e-6 L=1e-6
mpway61_cell35 ML61 gate_way61_cell35 GND ML61 p1 W=2.4e-6 L=1e-6
mnway61_cell36 ML61 gate_way61_cell36 GND GND n1 W=1e-6 L=1e-6
mpway61_cell36 ML61 gate_way61_cell36 GND ML61 p1 W=2.4e-6 L=1e-6
mnway61_cell37 ML61 gate_way61_cell37 GND GND n1 W=1e-6 L=1e-6
mpway61_cell37 ML61 gate_way61_cell37 GND ML61 p1 W=2.4e-6 L=1e-6
mnway61_cell38 ML61 gate_way61_cell38 GND GND n1 W=1e-6 L=1e-6
mpway61_cell38 ML61 gate_way61_cell38 GND ML61 p1 W=2.4e-6 L=1e-6
mnway61_cell39 ML61 gate_way61_cell39 GND GND n1 W=1e-6 L=1e-6
mpway61_cell39 ML61 gate_way61_cell39 GND ML61 p1 W=2.4e-6 L=1e-6
mnway61_cell40 ML61 gate_way61_cell40 GND GND n1 W=1e-6 L=1e-6
mpway61_cell40 ML61 gate_way61_cell40 GND ML61 p1 W=2.4e-6 L=1e-6
mnway61_cell41 ML61 gate_way61_cell41 GND GND n1 W=1e-6 L=1e-6
mpway61_cell41 ML61 gate_way61_cell41 GND ML61 p1 W=2.4e-6 L=1e-6
mnway61_cell42 ML61 gate_way61_cell42 GND GND n1 W=1e-6 L=1e-6
mpway61_cell42 ML61 gate_way61_cell42 GND ML61 p1 W=2.4e-6 L=1e-6
mnway61_cell43 ML61 gate_way61_cell43 GND GND n1 W=1e-6 L=1e-6
mpway61_cell43 ML61 gate_way61_cell43 GND ML61 p1 W=2.4e-6 L=1e-6
mnway61_cell44 ML61 gate_way61_cell44 GND GND n1 W=1e-6 L=1e-6
mpway61_cell44 ML61 gate_way61_cell44 GND ML61 p1 W=2.4e-6 L=1e-6
mnway61_cell45 ML61 gate_way61_cell45 GND GND n1 W=1e-6 L=1e-6
mpway61_cell45 ML61 gate_way61_cell45 GND ML61 p1 W=2.4e-6 L=1e-6
mnway61_cell46 ML61 gate_way61_cell46 GND GND n1 W=1e-6 L=1e-6
mpway61_cell46 ML61 gate_way61_cell46 GND ML61 p1 W=2.4e-6 L=1e-6
mnway61_cell47 ML61 gate_way61_cell47 GND GND n1 W=1e-6 L=1e-6
mpway61_cell47 ML61 gate_way61_cell47 GND ML61 p1 W=2.4e-6 L=1e-6
mnway61_cell48 ML61 gate_way61_cell48 GND GND n1 W=1e-6 L=1e-6
mpway61_cell48 ML61 gate_way61_cell48 GND ML61 p1 W=2.4e-6 L=1e-6
mnway61_cell49 ML61 gate_way61_cell49 GND GND n1 W=1e-6 L=1e-6
mpway61_cell49 ML61 gate_way61_cell49 GND ML61 p1 W=2.4e-6 L=1e-6
mnway61_cell50 ML61 gate_way61_cell50 GND GND n1 W=1e-6 L=1e-6
mpway61_cell50 ML61 gate_way61_cell50 GND ML61 p1 W=2.4e-6 L=1e-6
mnway61_cell51 ML61 gate_way61_cell51 GND GND n1 W=1e-6 L=1e-6
mpway61_cell51 ML61 gate_way61_cell51 GND ML61 p1 W=2.4e-6 L=1e-6
mnway61_cell52 ML61 gate_way61_cell52 GND GND n1 W=1e-6 L=1e-6
mpway61_cell52 ML61 gate_way61_cell52 GND ML61 p1 W=2.4e-6 L=1e-6
mnway61_cell53 ML61 gate_way61_cell53 GND GND n1 W=1e-6 L=1e-6
mpway61_cell53 ML61 gate_way61_cell53 GND ML61 p1 W=2.4e-6 L=1e-6
mnway61_cell54 ML61 gate_way61_cell54 GND GND n1 W=1e-6 L=1e-6
mpway61_cell54 ML61 gate_way61_cell54 GND ML61 p1 W=2.4e-6 L=1e-6
mnway61_cell55 ML61 gate_way61_cell55 GND GND n1 W=1e-6 L=1e-6
mpway61_cell55 ML61 gate_way61_cell55 GND ML61 p1 W=2.4e-6 L=1e-6
mnway61_cell56 ML61 gate_way61_cell56 GND GND n1 W=1e-6 L=1e-6
mpway61_cell56 ML61 gate_way61_cell56 GND ML61 p1 W=2.4e-6 L=1e-6
mnway61_cell57 ML61 gate_way61_cell57 GND GND n1 W=1e-6 L=1e-6
mpway61_cell57 ML61 gate_way61_cell57 GND ML61 p1 W=2.4e-6 L=1e-6
mnway61_cell58 ML61 gate_way61_cell58 GND GND n1 W=1e-6 L=1e-6
mpway61_cell58 ML61 gate_way61_cell58 GND ML61 p1 W=2.4e-6 L=1e-6
mnway61_cell59 ML61 gate_way61_cell59 GND GND n1 W=1e-6 L=1e-6
mpway61_cell59 ML61 gate_way61_cell59 GND ML61 p1 W=2.4e-6 L=1e-6
mnway61_cell60 ML61 gate_way61_cell60 GND GND n1 W=1e-6 L=1e-6
mpway61_cell60 ML61 gate_way61_cell60 GND ML61 p1 W=2.4e-6 L=1e-6
mnway61_cell61 ML61 gate_way61_cell61 GND GND n1 W=1e-6 L=1e-6
mpway61_cell61 ML61 gate_way61_cell61 GND ML61 p1 W=2.4e-6 L=1e-6
mnway61_cell62 ML61 gate_way61_cell62 GND GND n1 W=1e-6 L=1e-6
mpway61_cell62 ML61 gate_way61_cell62 GND ML61 p1 W=2.4e-6 L=1e-6
mnway61_cell63 ML61 gate_way61_cell63 GND GND n1 W=1e-6 L=1e-6
mpway61_cell63 ML61 gate_way61_cell63 GND ML61 p1 W=2.4e-6 L=1e-6
mnway61_cell64 ML61 gate_way61_cell64 GND GND n1 W=1e-6 L=1e-6
mpway61_cell64 ML61 gate_way61_cell64 GND ML61 p1 W=2.4e-6 L=1e-6
mnway61_cell65 ML61 gate_way61_cell65 GND GND n1 W=1e-6 L=1e-6
mpway61_cell65 ML61 gate_way61_cell65 GND ML61 p1 W=2.4e-6 L=1e-6
mnway61_cell66 ML61 gate_way61_cell66 GND GND n1 W=1e-6 L=1e-6
mpway61_cell66 ML61 gate_way61_cell66 GND ML61 p1 W=2.4e-6 L=1e-6
mnway61_cell67 ML61 gate_way61_cell67 GND GND n1 W=1e-6 L=1e-6
mpway61_cell67 ML61 gate_way61_cell67 GND ML61 p1 W=2.4e-6 L=1e-6
mnway61_cell68 ML61 gate_way61_cell68 GND GND n1 W=1e-6 L=1e-6
mpway61_cell68 ML61 gate_way61_cell68 GND ML61 p1 W=2.4e-6 L=1e-6
mnway61_cell69 ML61 gate_way61_cell69 GND GND n1 W=1e-6 L=1e-6
mpway61_cell69 ML61 gate_way61_cell69 GND ML61 p1 W=2.4e-6 L=1e-6
mnway61_cell70 ML61 gate_way61_cell70 GND GND n1 W=1e-6 L=1e-6
mpway61_cell70 ML61 gate_way61_cell70 GND ML61 p1 W=2.4e-6 L=1e-6
mnway61_cell71 ML61 gate_way61_cell71 GND GND n1 W=1e-6 L=1e-6
mpway61_cell71 ML61 gate_way61_cell71 GND ML61 p1 W=2.4e-6 L=1e-6
mnway61_cell72 ML61 gate_way61_cell72 GND GND n1 W=1e-6 L=1e-6
mpway61_cell72 ML61 gate_way61_cell72 GND ML61 p1 W=2.4e-6 L=1e-6
mnway61_cell73 ML61 gate_way61_cell73 GND GND n1 W=1e-6 L=1e-6
mpway61_cell73 ML61 gate_way61_cell73 GND ML61 p1 W=2.4e-6 L=1e-6
mnway61_cell74 ML61 gate_way61_cell74 GND GND n1 W=1e-6 L=1e-6
mpway61_cell74 ML61 gate_way61_cell74 GND ML61 p1 W=2.4e-6 L=1e-6
mnway61_cell75 ML61 gate_way61_cell75 GND GND n1 W=1e-6 L=1e-6
mpway61_cell75 ML61 gate_way61_cell75 GND ML61 p1 W=2.4e-6 L=1e-6
mnway61_cell76 ML61 gate_way61_cell76 GND GND n1 W=1e-6 L=1e-6
mpway61_cell76 ML61 gate_way61_cell76 GND ML61 p1 W=2.4e-6 L=1e-6
mnway61_cell77 ML61 gate_way61_cell77 GND GND n1 W=1e-6 L=1e-6
mpway61_cell77 ML61 gate_way61_cell77 GND ML61 p1 W=2.4e-6 L=1e-6
mnway61_cell78 ML61 gate_way61_cell78 GND GND n1 W=1e-6 L=1e-6
mpway61_cell78 ML61 gate_way61_cell78 GND ML61 p1 W=2.4e-6 L=1e-6
mnway61_cell79 ML61 gate_way61_cell79 GND GND n1 W=1e-6 L=1e-6
mpway61_cell79 ML61 gate_way61_cell79 GND ML61 p1 W=2.4e-6 L=1e-6
mnway61_cell80 ML61 gate_way61_cell80 GND GND n1 W=1e-6 L=1e-6
mpway61_cell80 ML61 gate_way61_cell80 GND ML61 p1 W=2.4e-6 L=1e-6
mnway61_cell81 ML61 gate_way61_cell81 GND GND n1 W=1e-6 L=1e-6
mpway61_cell81 ML61 gate_way61_cell81 GND ML61 p1 W=2.4e-6 L=1e-6
mnway61_cell82 ML61 gate_way61_cell82 GND GND n1 W=1e-6 L=1e-6
mpway61_cell82 ML61 gate_way61_cell82 GND ML61 p1 W=2.4e-6 L=1e-6
mnway61_cell83 ML61 gate_way61_cell83 GND GND n1 W=1e-6 L=1e-6
mpway61_cell83 ML61 gate_way61_cell83 GND ML61 p1 W=2.4e-6 L=1e-6
mnway61_cell84 ML61 gate_way61_cell84 GND GND n1 W=1e-6 L=1e-6
mpway61_cell84 ML61 gate_way61_cell84 GND ML61 p1 W=2.4e-6 L=1e-6
mnway61_cell85 ML61 gate_way61_cell85 GND GND n1 W=1e-6 L=1e-6
mpway61_cell85 ML61 gate_way61_cell85 GND ML61 p1 W=2.4e-6 L=1e-6
mnway61_cell86 ML61 gate_way61_cell86 GND GND n1 W=1e-6 L=1e-6
mpway61_cell86 ML61 gate_way61_cell86 GND ML61 p1 W=2.4e-6 L=1e-6
mnway61_cell87 ML61 gate_way61_cell87 GND GND n1 W=1e-6 L=1e-6
mpway61_cell87 ML61 gate_way61_cell87 GND ML61 p1 W=2.4e-6 L=1e-6
mnway61_cell88 ML61 gate_way61_cell88 GND GND n1 W=1e-6 L=1e-6
mpway61_cell88 ML61 gate_way61_cell88 GND ML61 p1 W=2.4e-6 L=1e-6
mnway61_cell89 ML61 gate_way61_cell89 GND GND n1 W=1e-6 L=1e-6
mpway61_cell89 ML61 gate_way61_cell89 GND ML61 p1 W=2.4e-6 L=1e-6
mnway61_cell90 ML61 gate_way61_cell90 GND GND n1 W=1e-6 L=1e-6
mpway61_cell90 ML61 gate_way61_cell90 GND ML61 p1 W=2.4e-6 L=1e-6
mnway61_cell91 ML61 gate_way61_cell91 GND GND n1 W=1e-6 L=1e-6
mpway61_cell91 ML61 gate_way61_cell91 GND ML61 p1 W=2.4e-6 L=1e-6
mnway61_cell92 ML61 gate_way61_cell92 GND GND n1 W=1e-6 L=1e-6
mpway61_cell92 ML61 gate_way61_cell92 GND ML61 p1 W=2.4e-6 L=1e-6
mnway61_cell93 ML61 gate_way61_cell93 GND GND n1 W=1e-6 L=1e-6
mpway61_cell93 ML61 gate_way61_cell93 GND ML61 p1 W=2.4e-6 L=1e-6
mnway61_cell94 ML61 gate_way61_cell94 GND GND n1 W=1e-6 L=1e-6
mpway61_cell94 ML61 gate_way61_cell94 GND ML61 p1 W=2.4e-6 L=1e-6
mnway61_cell95 ML61 gate_way61_cell95 GND GND n1 W=1e-6 L=1e-6
mpway61_cell95 ML61 gate_way61_cell95 GND ML61 p1 W=2.4e-6 L=1e-6
mnway61_cell96 ML61 gate_way61_cell96 GND GND n1 W=1e-6 L=1e-6
mpway61_cell96 ML61 gate_way61_cell96 GND ML61 p1 W=2.4e-6 L=1e-6
mnway61_cell97 ML61 gate_way61_cell97 GND GND n1 W=1e-6 L=1e-6
mpway61_cell97 ML61 gate_way61_cell97 GND ML61 p1 W=2.4e-6 L=1e-6
mnway61_cell98 ML61 gate_way61_cell98 GND GND n1 W=1e-6 L=1e-6
mpway61_cell98 ML61 gate_way61_cell98 GND ML61 p1 W=2.4e-6 L=1e-6
mnway61_cell99 ML61 gate_way61_cell99 GND GND n1 W=1e-6 L=1e-6
mpway61_cell99 ML61 gate_way61_cell99 GND ML61 p1 W=2.4e-6 L=1e-6
mnway62_cell0 ML62 gate_way62_cell0 GND GND n1 W=1e-6 L=1e-6
mpway62_cell0 ML62 gate_way62_cell0 GND ML62 p1 W=2.4e-6 L=1e-6
mnway62_cell1 ML62 gate_way62_cell1 GND GND n1 W=1e-6 L=1e-6
mpway62_cell1 ML62 gate_way62_cell1 GND ML62 p1 W=2.4e-6 L=1e-6
mnway62_cell2 ML62 gate_way62_cell2 GND GND n1 W=1e-6 L=1e-6
mpway62_cell2 ML62 gate_way62_cell2 GND ML62 p1 W=2.4e-6 L=1e-6
mnway62_cell3 ML62 gate_way62_cell3 GND GND n1 W=1e-6 L=1e-6
mpway62_cell3 ML62 gate_way62_cell3 GND ML62 p1 W=2.4e-6 L=1e-6
mnway62_cell4 ML62 gate_way62_cell4 GND GND n1 W=1e-6 L=1e-6
mpway62_cell4 ML62 gate_way62_cell4 GND ML62 p1 W=2.4e-6 L=1e-6
mnway62_cell5 ML62 gate_way62_cell5 GND GND n1 W=1e-6 L=1e-6
mpway62_cell5 ML62 gate_way62_cell5 GND ML62 p1 W=2.4e-6 L=1e-6
mnway62_cell6 ML62 gate_way62_cell6 GND GND n1 W=1e-6 L=1e-6
mpway62_cell6 ML62 gate_way62_cell6 GND ML62 p1 W=2.4e-6 L=1e-6
mnway62_cell7 ML62 gate_way62_cell7 GND GND n1 W=1e-6 L=1e-6
mpway62_cell7 ML62 gate_way62_cell7 GND ML62 p1 W=2.4e-6 L=1e-6
mnway62_cell8 ML62 gate_way62_cell8 GND GND n1 W=1e-6 L=1e-6
mpway62_cell8 ML62 gate_way62_cell8 GND ML62 p1 W=2.4e-6 L=1e-6
mnway62_cell9 ML62 gate_way62_cell9 GND GND n1 W=1e-6 L=1e-6
mpway62_cell9 ML62 gate_way62_cell9 GND ML62 p1 W=2.4e-6 L=1e-6
mnway62_cell10 ML62 gate_way62_cell10 GND GND n1 W=1e-6 L=1e-6
mpway62_cell10 ML62 gate_way62_cell10 GND ML62 p1 W=2.4e-6 L=1e-6
mnway62_cell11 ML62 gate_way62_cell11 GND GND n1 W=1e-6 L=1e-6
mpway62_cell11 ML62 gate_way62_cell11 GND ML62 p1 W=2.4e-6 L=1e-6
mnway62_cell12 ML62 gate_way62_cell12 GND GND n1 W=1e-6 L=1e-6
mpway62_cell12 ML62 gate_way62_cell12 GND ML62 p1 W=2.4e-6 L=1e-6
mnway62_cell13 ML62 gate_way62_cell13 GND GND n1 W=1e-6 L=1e-6
mpway62_cell13 ML62 gate_way62_cell13 GND ML62 p1 W=2.4e-6 L=1e-6
mnway62_cell14 ML62 gate_way62_cell14 GND GND n1 W=1e-6 L=1e-6
mpway62_cell14 ML62 gate_way62_cell14 GND ML62 p1 W=2.4e-6 L=1e-6
mnway62_cell15 ML62 gate_way62_cell15 GND GND n1 W=1e-6 L=1e-6
mpway62_cell15 ML62 gate_way62_cell15 GND ML62 p1 W=2.4e-6 L=1e-6
mnway62_cell16 ML62 gate_way62_cell16 GND GND n1 W=1e-6 L=1e-6
mpway62_cell16 ML62 gate_way62_cell16 GND ML62 p1 W=2.4e-6 L=1e-6
mnway62_cell17 ML62 gate_way62_cell17 GND GND n1 W=1e-6 L=1e-6
mpway62_cell17 ML62 gate_way62_cell17 GND ML62 p1 W=2.4e-6 L=1e-6
mnway62_cell18 ML62 gate_way62_cell18 GND GND n1 W=1e-6 L=1e-6
mpway62_cell18 ML62 gate_way62_cell18 GND ML62 p1 W=2.4e-6 L=1e-6
mnway62_cell19 ML62 gate_way62_cell19 GND GND n1 W=1e-6 L=1e-6
mpway62_cell19 ML62 gate_way62_cell19 GND ML62 p1 W=2.4e-6 L=1e-6
mnway62_cell20 ML62 gate_way62_cell20 GND GND n1 W=1e-6 L=1e-6
mpway62_cell20 ML62 gate_way62_cell20 GND ML62 p1 W=2.4e-6 L=1e-6
mnway62_cell21 ML62 gate_way62_cell21 GND GND n1 W=1e-6 L=1e-6
mpway62_cell21 ML62 gate_way62_cell21 GND ML62 p1 W=2.4e-6 L=1e-6
mnway62_cell22 ML62 gate_way62_cell22 GND GND n1 W=1e-6 L=1e-6
mpway62_cell22 ML62 gate_way62_cell22 GND ML62 p1 W=2.4e-6 L=1e-6
mnway62_cell23 ML62 gate_way62_cell23 GND GND n1 W=1e-6 L=1e-6
mpway62_cell23 ML62 gate_way62_cell23 GND ML62 p1 W=2.4e-6 L=1e-6
mnway62_cell24 ML62 gate_way62_cell24 GND GND n1 W=1e-6 L=1e-6
mpway62_cell24 ML62 gate_way62_cell24 GND ML62 p1 W=2.4e-6 L=1e-6
mnway62_cell25 ML62 gate_way62_cell25 GND GND n1 W=1e-6 L=1e-6
mpway62_cell25 ML62 gate_way62_cell25 GND ML62 p1 W=2.4e-6 L=1e-6
mnway62_cell26 ML62 gate_way62_cell26 GND GND n1 W=1e-6 L=1e-6
mpway62_cell26 ML62 gate_way62_cell26 GND ML62 p1 W=2.4e-6 L=1e-6
mnway62_cell27 ML62 gate_way62_cell27 GND GND n1 W=1e-6 L=1e-6
mpway62_cell27 ML62 gate_way62_cell27 GND ML62 p1 W=2.4e-6 L=1e-6
mnway62_cell28 ML62 gate_way62_cell28 GND GND n1 W=1e-6 L=1e-6
mpway62_cell28 ML62 gate_way62_cell28 GND ML62 p1 W=2.4e-6 L=1e-6
mnway62_cell29 ML62 gate_way62_cell29 GND GND n1 W=1e-6 L=1e-6
mpway62_cell29 ML62 gate_way62_cell29 GND ML62 p1 W=2.4e-6 L=1e-6
mnway62_cell30 ML62 gate_way62_cell30 GND GND n1 W=1e-6 L=1e-6
mpway62_cell30 ML62 gate_way62_cell30 GND ML62 p1 W=2.4e-6 L=1e-6
mnway62_cell31 ML62 gate_way62_cell31 GND GND n1 W=1e-6 L=1e-6
mpway62_cell31 ML62 gate_way62_cell31 GND ML62 p1 W=2.4e-6 L=1e-6
mnway62_cell32 ML62 gate_way62_cell32 GND GND n1 W=1e-6 L=1e-6
mpway62_cell32 ML62 gate_way62_cell32 GND ML62 p1 W=2.4e-6 L=1e-6
mnway62_cell33 ML62 gate_way62_cell33 GND GND n1 W=1e-6 L=1e-6
mpway62_cell33 ML62 gate_way62_cell33 GND ML62 p1 W=2.4e-6 L=1e-6
mnway62_cell34 ML62 gate_way62_cell34 GND GND n1 W=1e-6 L=1e-6
mpway62_cell34 ML62 gate_way62_cell34 GND ML62 p1 W=2.4e-6 L=1e-6
mnway62_cell35 ML62 gate_way62_cell35 GND GND n1 W=1e-6 L=1e-6
mpway62_cell35 ML62 gate_way62_cell35 GND ML62 p1 W=2.4e-6 L=1e-6
mnway62_cell36 ML62 gate_way62_cell36 GND GND n1 W=1e-6 L=1e-6
mpway62_cell36 ML62 gate_way62_cell36 GND ML62 p1 W=2.4e-6 L=1e-6
mnway62_cell37 ML62 gate_way62_cell37 GND GND n1 W=1e-6 L=1e-6
mpway62_cell37 ML62 gate_way62_cell37 GND ML62 p1 W=2.4e-6 L=1e-6
mnway62_cell38 ML62 gate_way62_cell38 GND GND n1 W=1e-6 L=1e-6
mpway62_cell38 ML62 gate_way62_cell38 GND ML62 p1 W=2.4e-6 L=1e-6
mnway62_cell39 ML62 gate_way62_cell39 GND GND n1 W=1e-6 L=1e-6
mpway62_cell39 ML62 gate_way62_cell39 GND ML62 p1 W=2.4e-6 L=1e-6
mnway62_cell40 ML62 gate_way62_cell40 GND GND n1 W=1e-6 L=1e-6
mpway62_cell40 ML62 gate_way62_cell40 GND ML62 p1 W=2.4e-6 L=1e-6
mnway62_cell41 ML62 gate_way62_cell41 GND GND n1 W=1e-6 L=1e-6
mpway62_cell41 ML62 gate_way62_cell41 GND ML62 p1 W=2.4e-6 L=1e-6
mnway62_cell42 ML62 gate_way62_cell42 GND GND n1 W=1e-6 L=1e-6
mpway62_cell42 ML62 gate_way62_cell42 GND ML62 p1 W=2.4e-6 L=1e-6
mnway62_cell43 ML62 gate_way62_cell43 GND GND n1 W=1e-6 L=1e-6
mpway62_cell43 ML62 gate_way62_cell43 GND ML62 p1 W=2.4e-6 L=1e-6
mnway62_cell44 ML62 gate_way62_cell44 GND GND n1 W=1e-6 L=1e-6
mpway62_cell44 ML62 gate_way62_cell44 GND ML62 p1 W=2.4e-6 L=1e-6
mnway62_cell45 ML62 gate_way62_cell45 GND GND n1 W=1e-6 L=1e-6
mpway62_cell45 ML62 gate_way62_cell45 GND ML62 p1 W=2.4e-6 L=1e-6
mnway62_cell46 ML62 gate_way62_cell46 GND GND n1 W=1e-6 L=1e-6
mpway62_cell46 ML62 gate_way62_cell46 GND ML62 p1 W=2.4e-6 L=1e-6
mnway62_cell47 ML62 gate_way62_cell47 GND GND n1 W=1e-6 L=1e-6
mpway62_cell47 ML62 gate_way62_cell47 GND ML62 p1 W=2.4e-6 L=1e-6
mnway62_cell48 ML62 gate_way62_cell48 GND GND n1 W=1e-6 L=1e-6
mpway62_cell48 ML62 gate_way62_cell48 GND ML62 p1 W=2.4e-6 L=1e-6
mnway62_cell49 ML62 gate_way62_cell49 GND GND n1 W=1e-6 L=1e-6
mpway62_cell49 ML62 gate_way62_cell49 GND ML62 p1 W=2.4e-6 L=1e-6
mnway62_cell50 ML62 gate_way62_cell50 GND GND n1 W=1e-6 L=1e-6
mpway62_cell50 ML62 gate_way62_cell50 GND ML62 p1 W=2.4e-6 L=1e-6
mnway62_cell51 ML62 gate_way62_cell51 GND GND n1 W=1e-6 L=1e-6
mpway62_cell51 ML62 gate_way62_cell51 GND ML62 p1 W=2.4e-6 L=1e-6
mnway62_cell52 ML62 gate_way62_cell52 GND GND n1 W=1e-6 L=1e-6
mpway62_cell52 ML62 gate_way62_cell52 GND ML62 p1 W=2.4e-6 L=1e-6
mnway62_cell53 ML62 gate_way62_cell53 GND GND n1 W=1e-6 L=1e-6
mpway62_cell53 ML62 gate_way62_cell53 GND ML62 p1 W=2.4e-6 L=1e-6
mnway62_cell54 ML62 gate_way62_cell54 GND GND n1 W=1e-6 L=1e-6
mpway62_cell54 ML62 gate_way62_cell54 GND ML62 p1 W=2.4e-6 L=1e-6
mnway62_cell55 ML62 gate_way62_cell55 GND GND n1 W=1e-6 L=1e-6
mpway62_cell55 ML62 gate_way62_cell55 GND ML62 p1 W=2.4e-6 L=1e-6
mnway62_cell56 ML62 gate_way62_cell56 GND GND n1 W=1e-6 L=1e-6
mpway62_cell56 ML62 gate_way62_cell56 GND ML62 p1 W=2.4e-6 L=1e-6
mnway62_cell57 ML62 gate_way62_cell57 GND GND n1 W=1e-6 L=1e-6
mpway62_cell57 ML62 gate_way62_cell57 GND ML62 p1 W=2.4e-6 L=1e-6
mnway62_cell58 ML62 gate_way62_cell58 GND GND n1 W=1e-6 L=1e-6
mpway62_cell58 ML62 gate_way62_cell58 GND ML62 p1 W=2.4e-6 L=1e-6
mnway62_cell59 ML62 gate_way62_cell59 GND GND n1 W=1e-6 L=1e-6
mpway62_cell59 ML62 gate_way62_cell59 GND ML62 p1 W=2.4e-6 L=1e-6
mnway62_cell60 ML62 gate_way62_cell60 GND GND n1 W=1e-6 L=1e-6
mpway62_cell60 ML62 gate_way62_cell60 GND ML62 p1 W=2.4e-6 L=1e-6
mnway62_cell61 ML62 gate_way62_cell61 GND GND n1 W=1e-6 L=1e-6
mpway62_cell61 ML62 gate_way62_cell61 GND ML62 p1 W=2.4e-6 L=1e-6
mnway62_cell62 ML62 gate_way62_cell62 GND GND n1 W=1e-6 L=1e-6
mpway62_cell62 ML62 gate_way62_cell62 GND ML62 p1 W=2.4e-6 L=1e-6
mnway62_cell63 ML62 gate_way62_cell63 GND GND n1 W=1e-6 L=1e-6
mpway62_cell63 ML62 gate_way62_cell63 GND ML62 p1 W=2.4e-6 L=1e-6
mnway62_cell64 ML62 gate_way62_cell64 GND GND n1 W=1e-6 L=1e-6
mpway62_cell64 ML62 gate_way62_cell64 GND ML62 p1 W=2.4e-6 L=1e-6
mnway62_cell65 ML62 gate_way62_cell65 GND GND n1 W=1e-6 L=1e-6
mpway62_cell65 ML62 gate_way62_cell65 GND ML62 p1 W=2.4e-6 L=1e-6
mnway62_cell66 ML62 gate_way62_cell66 GND GND n1 W=1e-6 L=1e-6
mpway62_cell66 ML62 gate_way62_cell66 GND ML62 p1 W=2.4e-6 L=1e-6
mnway62_cell67 ML62 gate_way62_cell67 GND GND n1 W=1e-6 L=1e-6
mpway62_cell67 ML62 gate_way62_cell67 GND ML62 p1 W=2.4e-6 L=1e-6
mnway62_cell68 ML62 gate_way62_cell68 GND GND n1 W=1e-6 L=1e-6
mpway62_cell68 ML62 gate_way62_cell68 GND ML62 p1 W=2.4e-6 L=1e-6
mnway62_cell69 ML62 gate_way62_cell69 GND GND n1 W=1e-6 L=1e-6
mpway62_cell69 ML62 gate_way62_cell69 GND ML62 p1 W=2.4e-6 L=1e-6
mnway62_cell70 ML62 gate_way62_cell70 GND GND n1 W=1e-6 L=1e-6
mpway62_cell70 ML62 gate_way62_cell70 GND ML62 p1 W=2.4e-6 L=1e-6
mnway62_cell71 ML62 gate_way62_cell71 GND GND n1 W=1e-6 L=1e-6
mpway62_cell71 ML62 gate_way62_cell71 GND ML62 p1 W=2.4e-6 L=1e-6
mnway62_cell72 ML62 gate_way62_cell72 GND GND n1 W=1e-6 L=1e-6
mpway62_cell72 ML62 gate_way62_cell72 GND ML62 p1 W=2.4e-6 L=1e-6
mnway62_cell73 ML62 gate_way62_cell73 GND GND n1 W=1e-6 L=1e-6
mpway62_cell73 ML62 gate_way62_cell73 GND ML62 p1 W=2.4e-6 L=1e-6
mnway62_cell74 ML62 gate_way62_cell74 GND GND n1 W=1e-6 L=1e-6
mpway62_cell74 ML62 gate_way62_cell74 GND ML62 p1 W=2.4e-6 L=1e-6
mnway62_cell75 ML62 gate_way62_cell75 GND GND n1 W=1e-6 L=1e-6
mpway62_cell75 ML62 gate_way62_cell75 GND ML62 p1 W=2.4e-6 L=1e-6
mnway62_cell76 ML62 gate_way62_cell76 GND GND n1 W=1e-6 L=1e-6
mpway62_cell76 ML62 gate_way62_cell76 GND ML62 p1 W=2.4e-6 L=1e-6
mnway62_cell77 ML62 gate_way62_cell77 GND GND n1 W=1e-6 L=1e-6
mpway62_cell77 ML62 gate_way62_cell77 GND ML62 p1 W=2.4e-6 L=1e-6
mnway62_cell78 ML62 gate_way62_cell78 GND GND n1 W=1e-6 L=1e-6
mpway62_cell78 ML62 gate_way62_cell78 GND ML62 p1 W=2.4e-6 L=1e-6
mnway62_cell79 ML62 gate_way62_cell79 GND GND n1 W=1e-6 L=1e-6
mpway62_cell79 ML62 gate_way62_cell79 GND ML62 p1 W=2.4e-6 L=1e-6
mnway62_cell80 ML62 gate_way62_cell80 GND GND n1 W=1e-6 L=1e-6
mpway62_cell80 ML62 gate_way62_cell80 GND ML62 p1 W=2.4e-6 L=1e-6
mnway62_cell81 ML62 gate_way62_cell81 GND GND n1 W=1e-6 L=1e-6
mpway62_cell81 ML62 gate_way62_cell81 GND ML62 p1 W=2.4e-6 L=1e-6
mnway62_cell82 ML62 gate_way62_cell82 GND GND n1 W=1e-6 L=1e-6
mpway62_cell82 ML62 gate_way62_cell82 GND ML62 p1 W=2.4e-6 L=1e-6
mnway62_cell83 ML62 gate_way62_cell83 GND GND n1 W=1e-6 L=1e-6
mpway62_cell83 ML62 gate_way62_cell83 GND ML62 p1 W=2.4e-6 L=1e-6
mnway62_cell84 ML62 gate_way62_cell84 GND GND n1 W=1e-6 L=1e-6
mpway62_cell84 ML62 gate_way62_cell84 GND ML62 p1 W=2.4e-6 L=1e-6
mnway62_cell85 ML62 gate_way62_cell85 GND GND n1 W=1e-6 L=1e-6
mpway62_cell85 ML62 gate_way62_cell85 GND ML62 p1 W=2.4e-6 L=1e-6
mnway62_cell86 ML62 gate_way62_cell86 GND GND n1 W=1e-6 L=1e-6
mpway62_cell86 ML62 gate_way62_cell86 GND ML62 p1 W=2.4e-6 L=1e-6
mnway62_cell87 ML62 gate_way62_cell87 GND GND n1 W=1e-6 L=1e-6
mpway62_cell87 ML62 gate_way62_cell87 GND ML62 p1 W=2.4e-6 L=1e-6
mnway62_cell88 ML62 gate_way62_cell88 GND GND n1 W=1e-6 L=1e-6
mpway62_cell88 ML62 gate_way62_cell88 GND ML62 p1 W=2.4e-6 L=1e-6
mnway62_cell89 ML62 gate_way62_cell89 GND GND n1 W=1e-6 L=1e-6
mpway62_cell89 ML62 gate_way62_cell89 GND ML62 p1 W=2.4e-6 L=1e-6
mnway62_cell90 ML62 gate_way62_cell90 GND GND n1 W=1e-6 L=1e-6
mpway62_cell90 ML62 gate_way62_cell90 GND ML62 p1 W=2.4e-6 L=1e-6
mnway62_cell91 ML62 gate_way62_cell91 GND GND n1 W=1e-6 L=1e-6
mpway62_cell91 ML62 gate_way62_cell91 GND ML62 p1 W=2.4e-6 L=1e-6
mnway62_cell92 ML62 gate_way62_cell92 GND GND n1 W=1e-6 L=1e-6
mpway62_cell92 ML62 gate_way62_cell92 GND ML62 p1 W=2.4e-6 L=1e-6
mnway62_cell93 ML62 gate_way62_cell93 GND GND n1 W=1e-6 L=1e-6
mpway62_cell93 ML62 gate_way62_cell93 GND ML62 p1 W=2.4e-6 L=1e-6
mnway62_cell94 ML62 gate_way62_cell94 GND GND n1 W=1e-6 L=1e-6
mpway62_cell94 ML62 gate_way62_cell94 GND ML62 p1 W=2.4e-6 L=1e-6
mnway62_cell95 ML62 gate_way62_cell95 GND GND n1 W=1e-6 L=1e-6
mpway62_cell95 ML62 gate_way62_cell95 GND ML62 p1 W=2.4e-6 L=1e-6
mnway62_cell96 ML62 gate_way62_cell96 GND GND n1 W=1e-6 L=1e-6
mpway62_cell96 ML62 gate_way62_cell96 GND ML62 p1 W=2.4e-6 L=1e-6
mnway62_cell97 ML62 gate_way62_cell97 GND GND n1 W=1e-6 L=1e-6
mpway62_cell97 ML62 gate_way62_cell97 GND ML62 p1 W=2.4e-6 L=1e-6
mnway62_cell98 ML62 gate_way62_cell98 GND GND n1 W=1e-6 L=1e-6
mpway62_cell98 ML62 gate_way62_cell98 GND ML62 p1 W=2.4e-6 L=1e-6
mnway62_cell99 ML62 gate_way62_cell99 GND GND n1 W=1e-6 L=1e-6
mpway62_cell99 ML62 gate_way62_cell99 GND ML62 p1 W=2.4e-6 L=1e-6
mnway63_cell0 ML63 gate_way63_cell0 GND GND n1 W=1e-6 L=1e-6
mpway63_cell0 ML63 gate_way63_cell0 GND ML63 p1 W=2.4e-6 L=1e-6
mnway63_cell1 ML63 gate_way63_cell1 GND GND n1 W=1e-6 L=1e-6
mpway63_cell1 ML63 gate_way63_cell1 GND ML63 p1 W=2.4e-6 L=1e-6
mnway63_cell2 ML63 gate_way63_cell2 GND GND n1 W=1e-6 L=1e-6
mpway63_cell2 ML63 gate_way63_cell2 GND ML63 p1 W=2.4e-6 L=1e-6
mnway63_cell3 ML63 gate_way63_cell3 GND GND n1 W=1e-6 L=1e-6
mpway63_cell3 ML63 gate_way63_cell3 GND ML63 p1 W=2.4e-6 L=1e-6
mnway63_cell4 ML63 gate_way63_cell4 GND GND n1 W=1e-6 L=1e-6
mpway63_cell4 ML63 gate_way63_cell4 GND ML63 p1 W=2.4e-6 L=1e-6
mnway63_cell5 ML63 gate_way63_cell5 GND GND n1 W=1e-6 L=1e-6
mpway63_cell5 ML63 gate_way63_cell5 GND ML63 p1 W=2.4e-6 L=1e-6
mnway63_cell6 ML63 gate_way63_cell6 GND GND n1 W=1e-6 L=1e-6
mpway63_cell6 ML63 gate_way63_cell6 GND ML63 p1 W=2.4e-6 L=1e-6
mnway63_cell7 ML63 gate_way63_cell7 GND GND n1 W=1e-6 L=1e-6
mpway63_cell7 ML63 gate_way63_cell7 GND ML63 p1 W=2.4e-6 L=1e-6
mnway63_cell8 ML63 gate_way63_cell8 GND GND n1 W=1e-6 L=1e-6
mpway63_cell8 ML63 gate_way63_cell8 GND ML63 p1 W=2.4e-6 L=1e-6
mnway63_cell9 ML63 gate_way63_cell9 GND GND n1 W=1e-6 L=1e-6
mpway63_cell9 ML63 gate_way63_cell9 GND ML63 p1 W=2.4e-6 L=1e-6
mnway63_cell10 ML63 gate_way63_cell10 GND GND n1 W=1e-6 L=1e-6
mpway63_cell10 ML63 gate_way63_cell10 GND ML63 p1 W=2.4e-6 L=1e-6
mnway63_cell11 ML63 gate_way63_cell11 GND GND n1 W=1e-6 L=1e-6
mpway63_cell11 ML63 gate_way63_cell11 GND ML63 p1 W=2.4e-6 L=1e-6
mnway63_cell12 ML63 gate_way63_cell12 GND GND n1 W=1e-6 L=1e-6
mpway63_cell12 ML63 gate_way63_cell12 GND ML63 p1 W=2.4e-6 L=1e-6
mnway63_cell13 ML63 gate_way63_cell13 GND GND n1 W=1e-6 L=1e-6
mpway63_cell13 ML63 gate_way63_cell13 GND ML63 p1 W=2.4e-6 L=1e-6
mnway63_cell14 ML63 gate_way63_cell14 GND GND n1 W=1e-6 L=1e-6
mpway63_cell14 ML63 gate_way63_cell14 GND ML63 p1 W=2.4e-6 L=1e-6
mnway63_cell15 ML63 gate_way63_cell15 GND GND n1 W=1e-6 L=1e-6
mpway63_cell15 ML63 gate_way63_cell15 GND ML63 p1 W=2.4e-6 L=1e-6
mnway63_cell16 ML63 gate_way63_cell16 GND GND n1 W=1e-6 L=1e-6
mpway63_cell16 ML63 gate_way63_cell16 GND ML63 p1 W=2.4e-6 L=1e-6
mnway63_cell17 ML63 gate_way63_cell17 GND GND n1 W=1e-6 L=1e-6
mpway63_cell17 ML63 gate_way63_cell17 GND ML63 p1 W=2.4e-6 L=1e-6
mnway63_cell18 ML63 gate_way63_cell18 GND GND n1 W=1e-6 L=1e-6
mpway63_cell18 ML63 gate_way63_cell18 GND ML63 p1 W=2.4e-6 L=1e-6
mnway63_cell19 ML63 gate_way63_cell19 GND GND n1 W=1e-6 L=1e-6
mpway63_cell19 ML63 gate_way63_cell19 GND ML63 p1 W=2.4e-6 L=1e-6
mnway63_cell20 ML63 gate_way63_cell20 GND GND n1 W=1e-6 L=1e-6
mpway63_cell20 ML63 gate_way63_cell20 GND ML63 p1 W=2.4e-6 L=1e-6
mnway63_cell21 ML63 gate_way63_cell21 GND GND n1 W=1e-6 L=1e-6
mpway63_cell21 ML63 gate_way63_cell21 GND ML63 p1 W=2.4e-6 L=1e-6
mnway63_cell22 ML63 gate_way63_cell22 GND GND n1 W=1e-6 L=1e-6
mpway63_cell22 ML63 gate_way63_cell22 GND ML63 p1 W=2.4e-6 L=1e-6
mnway63_cell23 ML63 gate_way63_cell23 GND GND n1 W=1e-6 L=1e-6
mpway63_cell23 ML63 gate_way63_cell23 GND ML63 p1 W=2.4e-6 L=1e-6
mnway63_cell24 ML63 gate_way63_cell24 GND GND n1 W=1e-6 L=1e-6
mpway63_cell24 ML63 gate_way63_cell24 GND ML63 p1 W=2.4e-6 L=1e-6
mnway63_cell25 ML63 gate_way63_cell25 GND GND n1 W=1e-6 L=1e-6
mpway63_cell25 ML63 gate_way63_cell25 GND ML63 p1 W=2.4e-6 L=1e-6
mnway63_cell26 ML63 gate_way63_cell26 GND GND n1 W=1e-6 L=1e-6
mpway63_cell26 ML63 gate_way63_cell26 GND ML63 p1 W=2.4e-6 L=1e-6
mnway63_cell27 ML63 gate_way63_cell27 GND GND n1 W=1e-6 L=1e-6
mpway63_cell27 ML63 gate_way63_cell27 GND ML63 p1 W=2.4e-6 L=1e-6
mnway63_cell28 ML63 gate_way63_cell28 GND GND n1 W=1e-6 L=1e-6
mpway63_cell28 ML63 gate_way63_cell28 GND ML63 p1 W=2.4e-6 L=1e-6
mnway63_cell29 ML63 gate_way63_cell29 GND GND n1 W=1e-6 L=1e-6
mpway63_cell29 ML63 gate_way63_cell29 GND ML63 p1 W=2.4e-6 L=1e-6
mnway63_cell30 ML63 gate_way63_cell30 GND GND n1 W=1e-6 L=1e-6
mpway63_cell30 ML63 gate_way63_cell30 GND ML63 p1 W=2.4e-6 L=1e-6
mnway63_cell31 ML63 gate_way63_cell31 GND GND n1 W=1e-6 L=1e-6
mpway63_cell31 ML63 gate_way63_cell31 GND ML63 p1 W=2.4e-6 L=1e-6
mnway63_cell32 ML63 gate_way63_cell32 GND GND n1 W=1e-6 L=1e-6
mpway63_cell32 ML63 gate_way63_cell32 GND ML63 p1 W=2.4e-6 L=1e-6
mnway63_cell33 ML63 gate_way63_cell33 GND GND n1 W=1e-6 L=1e-6
mpway63_cell33 ML63 gate_way63_cell33 GND ML63 p1 W=2.4e-6 L=1e-6
mnway63_cell34 ML63 gate_way63_cell34 GND GND n1 W=1e-6 L=1e-6
mpway63_cell34 ML63 gate_way63_cell34 GND ML63 p1 W=2.4e-6 L=1e-6
mnway63_cell35 ML63 gate_way63_cell35 GND GND n1 W=1e-6 L=1e-6
mpway63_cell35 ML63 gate_way63_cell35 GND ML63 p1 W=2.4e-6 L=1e-6
mnway63_cell36 ML63 gate_way63_cell36 GND GND n1 W=1e-6 L=1e-6
mpway63_cell36 ML63 gate_way63_cell36 GND ML63 p1 W=2.4e-6 L=1e-6
mnway63_cell37 ML63 gate_way63_cell37 GND GND n1 W=1e-6 L=1e-6
mpway63_cell37 ML63 gate_way63_cell37 GND ML63 p1 W=2.4e-6 L=1e-6
mnway63_cell38 ML63 gate_way63_cell38 GND GND n1 W=1e-6 L=1e-6
mpway63_cell38 ML63 gate_way63_cell38 GND ML63 p1 W=2.4e-6 L=1e-6
mnway63_cell39 ML63 gate_way63_cell39 GND GND n1 W=1e-6 L=1e-6
mpway63_cell39 ML63 gate_way63_cell39 GND ML63 p1 W=2.4e-6 L=1e-6
mnway63_cell40 ML63 gate_way63_cell40 GND GND n1 W=1e-6 L=1e-6
mpway63_cell40 ML63 gate_way63_cell40 GND ML63 p1 W=2.4e-6 L=1e-6
mnway63_cell41 ML63 gate_way63_cell41 GND GND n1 W=1e-6 L=1e-6
mpway63_cell41 ML63 gate_way63_cell41 GND ML63 p1 W=2.4e-6 L=1e-6
mnway63_cell42 ML63 gate_way63_cell42 GND GND n1 W=1e-6 L=1e-6
mpway63_cell42 ML63 gate_way63_cell42 GND ML63 p1 W=2.4e-6 L=1e-6
mnway63_cell43 ML63 gate_way63_cell43 GND GND n1 W=1e-6 L=1e-6
mpway63_cell43 ML63 gate_way63_cell43 GND ML63 p1 W=2.4e-6 L=1e-6
mnway63_cell44 ML63 gate_way63_cell44 GND GND n1 W=1e-6 L=1e-6
mpway63_cell44 ML63 gate_way63_cell44 GND ML63 p1 W=2.4e-6 L=1e-6
mnway63_cell45 ML63 gate_way63_cell45 GND GND n1 W=1e-6 L=1e-6
mpway63_cell45 ML63 gate_way63_cell45 GND ML63 p1 W=2.4e-6 L=1e-6
mnway63_cell46 ML63 gate_way63_cell46 GND GND n1 W=1e-6 L=1e-6
mpway63_cell46 ML63 gate_way63_cell46 GND ML63 p1 W=2.4e-6 L=1e-6
mnway63_cell47 ML63 gate_way63_cell47 GND GND n1 W=1e-6 L=1e-6
mpway63_cell47 ML63 gate_way63_cell47 GND ML63 p1 W=2.4e-6 L=1e-6
mnway63_cell48 ML63 gate_way63_cell48 GND GND n1 W=1e-6 L=1e-6
mpway63_cell48 ML63 gate_way63_cell48 GND ML63 p1 W=2.4e-6 L=1e-6
mnway63_cell49 ML63 gate_way63_cell49 GND GND n1 W=1e-6 L=1e-6
mpway63_cell49 ML63 gate_way63_cell49 GND ML63 p1 W=2.4e-6 L=1e-6
mnway63_cell50 ML63 gate_way63_cell50 GND GND n1 W=1e-6 L=1e-6
mpway63_cell50 ML63 gate_way63_cell50 GND ML63 p1 W=2.4e-6 L=1e-6
mnway63_cell51 ML63 gate_way63_cell51 GND GND n1 W=1e-6 L=1e-6
mpway63_cell51 ML63 gate_way63_cell51 GND ML63 p1 W=2.4e-6 L=1e-6
mnway63_cell52 ML63 gate_way63_cell52 GND GND n1 W=1e-6 L=1e-6
mpway63_cell52 ML63 gate_way63_cell52 GND ML63 p1 W=2.4e-6 L=1e-6
mnway63_cell53 ML63 gate_way63_cell53 GND GND n1 W=1e-6 L=1e-6
mpway63_cell53 ML63 gate_way63_cell53 GND ML63 p1 W=2.4e-6 L=1e-6
mnway63_cell54 ML63 gate_way63_cell54 GND GND n1 W=1e-6 L=1e-6
mpway63_cell54 ML63 gate_way63_cell54 GND ML63 p1 W=2.4e-6 L=1e-6
mnway63_cell55 ML63 gate_way63_cell55 GND GND n1 W=1e-6 L=1e-6
mpway63_cell55 ML63 gate_way63_cell55 GND ML63 p1 W=2.4e-6 L=1e-6
mnway63_cell56 ML63 gate_way63_cell56 GND GND n1 W=1e-6 L=1e-6
mpway63_cell56 ML63 gate_way63_cell56 GND ML63 p1 W=2.4e-6 L=1e-6
mnway63_cell57 ML63 gate_way63_cell57 GND GND n1 W=1e-6 L=1e-6
mpway63_cell57 ML63 gate_way63_cell57 GND ML63 p1 W=2.4e-6 L=1e-6
mnway63_cell58 ML63 gate_way63_cell58 GND GND n1 W=1e-6 L=1e-6
mpway63_cell58 ML63 gate_way63_cell58 GND ML63 p1 W=2.4e-6 L=1e-6
mnway63_cell59 ML63 gate_way63_cell59 GND GND n1 W=1e-6 L=1e-6
mpway63_cell59 ML63 gate_way63_cell59 GND ML63 p1 W=2.4e-6 L=1e-6
mnway63_cell60 ML63 gate_way63_cell60 GND GND n1 W=1e-6 L=1e-6
mpway63_cell60 ML63 gate_way63_cell60 GND ML63 p1 W=2.4e-6 L=1e-6
mnway63_cell61 ML63 gate_way63_cell61 GND GND n1 W=1e-6 L=1e-6
mpway63_cell61 ML63 gate_way63_cell61 GND ML63 p1 W=2.4e-6 L=1e-6
mnway63_cell62 ML63 gate_way63_cell62 GND GND n1 W=1e-6 L=1e-6
mpway63_cell62 ML63 gate_way63_cell62 GND ML63 p1 W=2.4e-6 L=1e-6
mnway63_cell63 ML63 gate_way63_cell63 GND GND n1 W=1e-6 L=1e-6
mpway63_cell63 ML63 gate_way63_cell63 GND ML63 p1 W=2.4e-6 L=1e-6
mnway63_cell64 ML63 gate_way63_cell64 GND GND n1 W=1e-6 L=1e-6
mpway63_cell64 ML63 gate_way63_cell64 GND ML63 p1 W=2.4e-6 L=1e-6
mnway63_cell65 ML63 gate_way63_cell65 GND GND n1 W=1e-6 L=1e-6
mpway63_cell65 ML63 gate_way63_cell65 GND ML63 p1 W=2.4e-6 L=1e-6
mnway63_cell66 ML63 gate_way63_cell66 GND GND n1 W=1e-6 L=1e-6
mpway63_cell66 ML63 gate_way63_cell66 GND ML63 p1 W=2.4e-6 L=1e-6
mnway63_cell67 ML63 gate_way63_cell67 GND GND n1 W=1e-6 L=1e-6
mpway63_cell67 ML63 gate_way63_cell67 GND ML63 p1 W=2.4e-6 L=1e-6
mnway63_cell68 ML63 gate_way63_cell68 GND GND n1 W=1e-6 L=1e-6
mpway63_cell68 ML63 gate_way63_cell68 GND ML63 p1 W=2.4e-6 L=1e-6
mnway63_cell69 ML63 gate_way63_cell69 GND GND n1 W=1e-6 L=1e-6
mpway63_cell69 ML63 gate_way63_cell69 GND ML63 p1 W=2.4e-6 L=1e-6
mnway63_cell70 ML63 gate_way63_cell70 GND GND n1 W=1e-6 L=1e-6
mpway63_cell70 ML63 gate_way63_cell70 GND ML63 p1 W=2.4e-6 L=1e-6
mnway63_cell71 ML63 gate_way63_cell71 GND GND n1 W=1e-6 L=1e-6
mpway63_cell71 ML63 gate_way63_cell71 GND ML63 p1 W=2.4e-6 L=1e-6
mnway63_cell72 ML63 gate_way63_cell72 GND GND n1 W=1e-6 L=1e-6
mpway63_cell72 ML63 gate_way63_cell72 GND ML63 p1 W=2.4e-6 L=1e-6
mnway63_cell73 ML63 gate_way63_cell73 GND GND n1 W=1e-6 L=1e-6
mpway63_cell73 ML63 gate_way63_cell73 GND ML63 p1 W=2.4e-6 L=1e-6
mnway63_cell74 ML63 gate_way63_cell74 GND GND n1 W=1e-6 L=1e-6
mpway63_cell74 ML63 gate_way63_cell74 GND ML63 p1 W=2.4e-6 L=1e-6
mnway63_cell75 ML63 gate_way63_cell75 GND GND n1 W=1e-6 L=1e-6
mpway63_cell75 ML63 gate_way63_cell75 GND ML63 p1 W=2.4e-6 L=1e-6
mnway63_cell76 ML63 gate_way63_cell76 GND GND n1 W=1e-6 L=1e-6
mpway63_cell76 ML63 gate_way63_cell76 GND ML63 p1 W=2.4e-6 L=1e-6
mnway63_cell77 ML63 gate_way63_cell77 GND GND n1 W=1e-6 L=1e-6
mpway63_cell77 ML63 gate_way63_cell77 GND ML63 p1 W=2.4e-6 L=1e-6
mnway63_cell78 ML63 gate_way63_cell78 GND GND n1 W=1e-6 L=1e-6
mpway63_cell78 ML63 gate_way63_cell78 GND ML63 p1 W=2.4e-6 L=1e-6
mnway63_cell79 ML63 gate_way63_cell79 GND GND n1 W=1e-6 L=1e-6
mpway63_cell79 ML63 gate_way63_cell79 GND ML63 p1 W=2.4e-6 L=1e-6
mnway63_cell80 ML63 gate_way63_cell80 GND GND n1 W=1e-6 L=1e-6
mpway63_cell80 ML63 gate_way63_cell80 GND ML63 p1 W=2.4e-6 L=1e-6
mnway63_cell81 ML63 gate_way63_cell81 GND GND n1 W=1e-6 L=1e-6
mpway63_cell81 ML63 gate_way63_cell81 GND ML63 p1 W=2.4e-6 L=1e-6
mnway63_cell82 ML63 gate_way63_cell82 GND GND n1 W=1e-6 L=1e-6
mpway63_cell82 ML63 gate_way63_cell82 GND ML63 p1 W=2.4e-6 L=1e-6
mnway63_cell83 ML63 gate_way63_cell83 GND GND n1 W=1e-6 L=1e-6
mpway63_cell83 ML63 gate_way63_cell83 GND ML63 p1 W=2.4e-6 L=1e-6
mnway63_cell84 ML63 gate_way63_cell84 GND GND n1 W=1e-6 L=1e-6
mpway63_cell84 ML63 gate_way63_cell84 GND ML63 p1 W=2.4e-6 L=1e-6
mnway63_cell85 ML63 gate_way63_cell85 GND GND n1 W=1e-6 L=1e-6
mpway63_cell85 ML63 gate_way63_cell85 GND ML63 p1 W=2.4e-6 L=1e-6
mnway63_cell86 ML63 gate_way63_cell86 GND GND n1 W=1e-6 L=1e-6
mpway63_cell86 ML63 gate_way63_cell86 GND ML63 p1 W=2.4e-6 L=1e-6
mnway63_cell87 ML63 gate_way63_cell87 GND GND n1 W=1e-6 L=1e-6
mpway63_cell87 ML63 gate_way63_cell87 GND ML63 p1 W=2.4e-6 L=1e-6
mnway63_cell88 ML63 gate_way63_cell88 GND GND n1 W=1e-6 L=1e-6
mpway63_cell88 ML63 gate_way63_cell88 GND ML63 p1 W=2.4e-6 L=1e-6
mnway63_cell89 ML63 gate_way63_cell89 GND GND n1 W=1e-6 L=1e-6
mpway63_cell89 ML63 gate_way63_cell89 GND ML63 p1 W=2.4e-6 L=1e-6
mnway63_cell90 ML63 gate_way63_cell90 GND GND n1 W=1e-6 L=1e-6
mpway63_cell90 ML63 gate_way63_cell90 GND ML63 p1 W=2.4e-6 L=1e-6
mnway63_cell91 ML63 gate_way63_cell91 GND GND n1 W=1e-6 L=1e-6
mpway63_cell91 ML63 gate_way63_cell91 GND ML63 p1 W=2.4e-6 L=1e-6
mnway63_cell92 ML63 gate_way63_cell92 GND GND n1 W=1e-6 L=1e-6
mpway63_cell92 ML63 gate_way63_cell92 GND ML63 p1 W=2.4e-6 L=1e-6
mnway63_cell93 ML63 gate_way63_cell93 GND GND n1 W=1e-6 L=1e-6
mpway63_cell93 ML63 gate_way63_cell93 GND ML63 p1 W=2.4e-6 L=1e-6
mnway63_cell94 ML63 gate_way63_cell94 GND GND n1 W=1e-6 L=1e-6
mpway63_cell94 ML63 gate_way63_cell94 GND ML63 p1 W=2.4e-6 L=1e-6
mnway63_cell95 ML63 gate_way63_cell95 GND GND n1 W=1e-6 L=1e-6
mpway63_cell95 ML63 gate_way63_cell95 GND ML63 p1 W=2.4e-6 L=1e-6
mnway63_cell96 ML63 gate_way63_cell96 GND GND n1 W=1e-6 L=1e-6
mpway63_cell96 ML63 gate_way63_cell96 GND ML63 p1 W=2.4e-6 L=1e-6
mnway63_cell97 ML63 gate_way63_cell97 GND GND n1 W=1e-6 L=1e-6
mpway63_cell97 ML63 gate_way63_cell97 GND ML63 p1 W=2.4e-6 L=1e-6
mnway63_cell98 ML63 gate_way63_cell98 GND GND n1 W=1e-6 L=1e-6
mpway63_cell98 ML63 gate_way63_cell98 GND ML63 p1 W=2.4e-6 L=1e-6
mnway63_cell99 ML63 gate_way63_cell99 GND GND n1 W=1e-6 L=1e-6
mpway63_cell99 ML63 gate_way63_cell99 GND ML63 p1 W=2.4e-6 L=1e-6
